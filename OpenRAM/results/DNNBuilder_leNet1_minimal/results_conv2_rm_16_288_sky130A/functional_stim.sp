* Functional test stimulus file for 20ns period

* TT process corner
.include "/home/mm4uz/Documents/openram/vsdsram_sky130/OpenRAM/technology/sky130A/models/tt.sp"
.include "conv2_rm_sram_16_288_sky130A.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xconv2_rm_sram_16_288_sky130A din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 a0_8 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 vdd gnd conv2_rm_sram_16_288_sky130A

* SRAM output loads
CD00 dout0_0  0 39.2968f
CD01 dout0_1  0 39.2968f
CD02 dout0_2  0 39.2968f
CD03 dout0_3  0 39.2968f
CD04 dout0_4  0 39.2968f
CD05 dout0_5  0 39.2968f
CD06 dout0_6  0 39.2968f
CD07 dout0_7  0 39.2968f
CD08 dout0_8  0 39.2968f
CD09 dout0_9  0 39.2968f
CD010 dout0_10  0 39.2968f
CD011 dout0_11  0 39.2968f
CD012 dout0_12  0 39.2968f
CD013 dout0_13  0 39.2968f
CD014 dout0_14  0 39.2968f
CD015 dout0_15  0 39.2968f

* Important signals for debug
* bl:	xconv2_rm_sram_16_288_sky130a.xbank0.bl_0_0
* br:	xconv2_rm_sram_16_288_sky130a.xbank0.br_0_0
* s_en:	xconv2_rm_sram_16_288_sky130a.s_en
* q:	xconv2_rm_sram_16_288_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xconv2_rm_sram_16_288_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 20ns)
*	Writing 1110110111000100  to  address 100011110 (from port 0) during cycle 1 (20ns - 40ns)
*	Writing 1011101000101010  to  address 100011011 (from port 0) during cycle 2 (40ns - 60ns)
*	Writing 1000110001001100  to  address 000000011 (from port 0) during cycle 3 (60ns - 80ns)
*	Reading 1110110111000100 from address 100011110 (from port 0) during cycle 4 (80ns - 100ns)
*	Reading 1011101000101010 from address 100011011 (from port 0) during cycle 5 (100ns - 120ns)
*	Writing 0011011110001010  to  address 100011110 (from port 0) during cycle 8 (160ns - 180ns)
*	Reading 0011011110001010 from address 100011110 (from port 0) during cycle 9 (180ns - 200ns)
*	Reading 0011011110001010 from address 100011110 (from port 0) during cycle 10 (200ns - 220ns)
*	Reading 1000110001001100 from address 000000011 (from port 0) during cycle 11 (220ns - 240ns)
*	Reading 1000110001001100 from address 000000011 (from port 0) during cycle 12 (240ns - 260ns)
*	Writing 1001111001001110  to  address 000000000 (from port 0) during cycle 13 (260ns - 280ns)
*	Reading 1011101000101010 from address 100011011 (from port 0) during cycle 14 (280ns - 300ns)
*	Reading 1001111001001110 from address 000000000 (from port 0) during cycle 17 (340ns - 360ns)
*	Reading 0011011110001010 from address 100011110 (from port 0) during cycle 18 (360ns - 380ns)
*	Reading 0011011110001010 from address 100011110 (from port 0) during cycle 19 (380ns - 400ns)
*	Reading 1001111001001110 from address 000000000 (from port 0) during cycle 20 (400ns - 420ns)
*	Writing 1101010100100011  to  address 000000000 (from port 0) during cycle 22 (440ns - 460ns)
*	Reading 1101010100100011 from address 000000000 (from port 0) during cycle 23 (460ns - 480ns)
*	Reading 0011011110001010 from address 100011110 (from port 0) during cycle 24 (480ns - 500ns)
*	Writing 0110111110011101  to  address 000000011 (from port 0) during cycle 26 (520ns - 540ns)
*	Writing 0110110111011100  to  address 000000010 (from port 0) during cycle 27 (540ns - 560ns)
*	Reading 0110111110011101 from address 000000011 (from port 0) during cycle 28 (560ns - 580ns)
*	Writing 1001011001111111  to  address 100011101 (from port 0) during cycle 29 (580ns - 600ns)
*	Reading 1101010100100011 from address 000000000 (from port 0) during cycle 30 (600ns - 620ns)
*	Reading 1011101000101010 from address 100011011 (from port 0) during cycle 33 (660ns - 680ns)
*	Reading 1011101000101010 from address 100011011 (from port 0) during cycle 35 (700ns - 720ns)
*	Reading 0110110111011100 from address 000000010 (from port 0) during cycle 36 (720ns - 740ns)
*	Reading 1101010100100011 from address 000000000 (from port 0) during cycle 38 (760ns - 780ns)
*	Writing 0111000010011110  to  address 000000010 (from port 0) during cycle 39 (780ns - 800ns)
*	Reading 0011011110001010 from address 100011110 (from port 0) during cycle 40 (800ns - 820ns)
*	Reading 1101010100100011 from address 000000000 (from port 0) during cycle 41 (820ns - 840ns)
*	Reading 1101010100100011 from address 000000000 (from port 0) during cycle 42 (840ns - 860ns)
*	Reading 1011101000101010 from address 100011011 (from port 0) during cycle 43 (860ns - 880ns)
*	Reading 0110111110011101 from address 000000011 (from port 0) during cycle 45 (900ns - 920ns)
*	Writing 1110010000100111  to  address 000000000 (from port 0) during cycle 46 (920ns - 940ns)
*	Reading 0110111110011101 from address 000000011 (from port 0) during cycle 47 (940ns - 960ns)
*	Writing 1001011110101111  to  address 100011011 (from port 0) during cycle 48 (960ns - 980ns)
*	Reading 1001011110101111 from address 100011011 (from port 0) during cycle 51 (1020ns - 1040ns)
*	Reading 1001011001111111 from address 100011101 (from port 0) during cycle 52 (1040ns - 1060ns)
*	Reading 0111000010011110 from address 000000010 (from port 0) during cycle 53 (1060ns - 1080ns)
*	Writing 0001111100100001  to  address 100011100 (from port 0) during cycle 55 (1100ns - 1120ns)
*	Reading 1001011001111111 from address 100011101 (from port 0) during cycle 56 (1120ns - 1140ns)
*	Reading 0001111100100001 from address 100011100 (from port 0) during cycle 57 (1140ns - 1160ns)
*	Reading 1001011001111111 from address 100011101 (from port 0) during cycle 58 (1160ns - 1180ns)
*	Writing 1111001001000101  to  address 100011100 (from port 0) during cycle 59 (1180ns - 1200ns)
*	Reading 1110010000100111 from address 000000000 (from port 0) during cycle 60 (1200ns - 1220ns)
*	Writing 1011001001010001  to  address 100011100 (from port 0) during cycle 62 (1240ns - 1260ns)
*	Reading 1110010000100111 from address 000000000 (from port 0) during cycle 65 (1300ns - 1320ns)
*	Writing 0100000010001100  to  address 000000011 (from port 0) during cycle 66 (1320ns - 1340ns)
*	Reading 0011011110001010 from address 100011110 (from port 0) during cycle 67 (1340ns - 1360ns)
*	Reading 0100000010001100 from address 000000011 (from port 0) during cycle 68 (1360ns - 1380ns)
*	Reading 1011001001010001 from address 100011100 (from port 0) during cycle 69 (1380ns - 1400ns)
*	Reading 0111000010011110 from address 000000010 (from port 0) during cycle 72 (1440ns - 1460ns)
*	Reading 0111000010011110 from address 000000010 (from port 0) during cycle 73 (1460ns - 1480ns)
*	Reading 0100000010001100 from address 000000011 (from port 0) during cycle 74 (1480ns - 1500ns)
*	Reading 1001011110101111 from address 100011011 (from port 0) during cycle 75 (1500ns - 1520ns)
*	Reading 1001011001111111 from address 100011101 (from port 0) during cycle 76 (1520ns - 1540ns)
*	Writing 0011101101000000  to  address 100011011 (from port 0) during cycle 78 (1560ns - 1580ns)
*	Reading 0111000010011110 from address 000000010 (from port 0) during cycle 79 (1580ns - 1600ns)
*	Writing 1110101101001010  to  address 000000001 (from port 0) during cycle 81 (1620ns - 1640ns)
*	Reading 0011011110001010 from address 100011110 (from port 0) during cycle 82 (1640ns - 1660ns)
*	Reading 1001011001111111 from address 100011101 (from port 0) during cycle 83 (1660ns - 1680ns)
*	Writing 0001101000000111  to  address 000000000 (from port 0) during cycle 84 (1680ns - 1700ns)
*	Reading 0001101000000111 from address 000000000 (from port 0) during cycle 85 (1700ns - 1720ns)
*	Reading 0011101101000000 from address 100011011 (from port 0) during cycle 86 (1720ns - 1740ns)
*	Writing 1011001111011110  to  address 100011100 (from port 0) during cycle 87 (1740ns - 1760ns)
*	Writing 1110111100001001  to  address 000000010 (from port 0) during cycle 88 (1760ns - 1780ns)
*	Reading 0011011110001010 from address 100011110 (from port 0) during cycle 89 (1780ns - 1800ns)
*	Writing 1101000011001111  to  address 100011110 (from port 0) during cycle 90 (1800ns - 1820ns)
*	Writing 1111011111010111  to  address 100011101 (from port 0) during cycle 91 (1820ns - 1840ns)
*	Reading 1111011111010111 from address 100011101 (from port 0) during cycle 92 (1840ns - 1860ns)
*	Reading 0100000010001100 from address 000000011 (from port 0) during cycle 93 (1860ns - 1880ns)
*	Reading 1011001111011110 from address 100011100 (from port 0) during cycle 94 (1880ns - 1900ns)
*	Writing 1111000101000110  to  address 100011011 (from port 0) during cycle 95 (1900ns - 1920ns)
*	Reading 1111000101000110 from address 100011011 (from port 0) during cycle 96 (1920ns - 1940ns)
*	Reading 0100000010001100 from address 000000011 (from port 0) during cycle 97 (1940ns - 1960ns)
*	Writing 1111110100010010  to  address 100011101 (from port 0) during cycle 98 (1960ns - 1980ns)
*	Reading 1110111100001001 from address 000000010 (from port 0) during cycle 99 (1980ns - 2000ns)
*	Reading 1101000011001111 from address 100011110 (from port 0) during cycle 100 (2000ns - 2020ns)
*	Reading 0001101000000111 from address 000000000 (from port 0) during cycle 103 (2060ns - 2080ns)
*	Reading 1110101101001010 from address 000000001 (from port 0) during cycle 104 (2080ns - 2100ns)
*	Reading 0100000010001100 from address 000000011 (from port 0) during cycle 105 (2100ns - 2120ns)
*	Writing 0100110111011000  to  address 100011100 (from port 0) during cycle 106 (2120ns - 2140ns)
*	Writing 0010000101011110  to  address 100011101 (from port 0) during cycle 108 (2160ns - 2180ns)
*	Reading 0001101000000111 from address 000000000 (from port 0) during cycle 109 (2180ns - 2200ns)
*	Reading 0010000101011110 from address 100011101 (from port 0) during cycle 110 (2200ns - 2220ns)
*	Reading 1101000011001111 from address 100011110 (from port 0) during cycle 111 (2220ns - 2240ns)
*	Reading 1111000101000110 from address 100011011 (from port 0) during cycle 112 (2240ns - 2260ns)
*	Writing 1100011111101001  to  address 000000001 (from port 0) during cycle 114 (2280ns - 2300ns)
*	Reading 1100011111101001 from address 000000001 (from port 0) during cycle 115 (2300ns - 2320ns)
*	Reading 0100000010001100 from address 000000011 (from port 0) during cycle 120 (2400ns - 2420ns)
*	Reading 0001101000000111 from address 000000000 (from port 0) during cycle 122 (2440ns - 2460ns)
*	Reading 0010000101011110 from address 100011101 (from port 0) during cycle 123 (2460ns - 2480ns)
*	Reading 1111000101000110 from address 100011011 (from port 0) during cycle 125 (2500ns - 2520ns)
*	Reading 1101000011001111 from address 100011110 (from port 0) during cycle 126 (2520ns - 2540ns)
*	Reading 1100011111101001 from address 000000001 (from port 0) during cycle 127 (2540ns - 2560ns)
*	Writing 0001111100000111  to  address 100011110 (from port 0) during cycle 128 (2560ns - 2580ns)
*	Reading 0100110111011000 from address 100011100 (from port 0) during cycle 129 (2580ns - 2600ns)
*	Reading 1100011111101001 from address 000000001 (from port 0) during cycle 130 (2600ns - 2620ns)
*	Writing 0001100100111101  to  address 000000010 (from port 0) during cycle 131 (2620ns - 2640ns)
*	Writing 1001000100101110  to  address 000000000 (from port 0) during cycle 133 (2660ns - 2680ns)
*	Writing 0101100001010101  to  address 100011011 (from port 0) during cycle 134 (2680ns - 2700ns)
*	Reading 0100110111011000 from address 100011100 (from port 0) during cycle 135 (2700ns - 2720ns)
*	Reading 0100110111011000 from address 100011100 (from port 0) during cycle 136 (2720ns - 2740ns)
*	Writing 1110011110110011  to  address 000000011 (from port 0) during cycle 138 (2760ns - 2780ns)
*	Writing 1111010011110011  to  address 000000000 (from port 0) during cycle 139 (2780ns - 2800ns)
*	Reading 1110011110110011 from address 000000011 (from port 0) during cycle 141 (2820ns - 2840ns)
*	Reading 1110011110110011 from address 000000011 (from port 0) during cycle 142 (2840ns - 2860ns)
*	Reading 0010000101011110 from address 100011101 (from port 0) during cycle 143 (2860ns - 2880ns)
*	Writing 1110011101100011  to  address 000000001 (from port 0) during cycle 144 (2880ns - 2900ns)
*	Writing 0111110000101000  to  address 100011101 (from port 0) during cycle 145 (2900ns - 2920ns)
*	Reading 1110011101100011 from address 000000001 (from port 0) during cycle 146 (2920ns - 2940ns)
*	Reading 0001100100111101 from address 000000010 (from port 0) during cycle 147 (2940ns - 2960ns)
*	Reading 1110011101100011 from address 000000001 (from port 0) during cycle 149 (2980ns - 3000ns)
*	Reading 0111110000101000 from address 100011101 (from port 0) during cycle 150 (3000ns - 3020ns)
*	Reading 1110011101100011 from address 000000001 (from port 0) during cycle 151 (3020ns - 3040ns)
*	Writing 0000011010010100  to  address 000000000 (from port 0) during cycle 152 (3040ns - 3060ns)
*	Writing 0000011111000001  to  address 000000000 (from port 0) during cycle 153 (3060ns - 3080ns)
*	Writing 1010111010111010  to  address 000000001 (from port 0) during cycle 154 (3080ns - 3100ns)
*	Reading 1010111010111010 from address 000000001 (from port 0) during cycle 155 (3100ns - 3120ns)
*	Reading 0100110111011000 from address 100011100 (from port 0) during cycle 157 (3140ns - 3160ns)
*	Reading 1010111010111010 from address 000000001 (from port 0) during cycle 159 (3180ns - 3200ns)
*	Reading 0001111100000111 from address 100011110 (from port 0) during cycle 160 (3200ns - 3220ns)
*	Writing 0110111110000111  to  address 100011100 (from port 0) during cycle 164 (3280ns - 3300ns)
*	Writing 0010001011001100  to  address 100011100 (from port 0) during cycle 166 (3320ns - 3340ns)
*	Writing 1110100101001111  to  address 000000001 (from port 0) during cycle 167 (3340ns - 3360ns)
*	Writing 1100000001010011  to  address 100011101 (from port 0) during cycle 168 (3360ns - 3380ns)
*	Reading 0010001011001100 from address 100011100 (from port 0) during cycle 169 (3380ns - 3400ns)
*	Reading 0001100100111101 from address 000000010 (from port 0) during cycle 170 (3400ns - 3420ns)
*	Reading 0010001011001100 from address 100011100 (from port 0) during cycle 171 (3420ns - 3440ns)
*	Writing 1100101111011011  to  address 000000000 (from port 0) during cycle 172 (3440ns - 3460ns)
*	Reading 0101100001010101 from address 100011011 (from port 0) during cycle 173 (3460ns - 3480ns)
*	Writing 0011100100001110  to  address 100011100 (from port 0) during cycle 174 (3480ns - 3500ns)
*	Reading 0011100100001110 from address 100011100 (from port 0) during cycle 175 (3500ns - 3520ns)
*	Writing 0111111110100101  to  address 000000010 (from port 0) during cycle 176 (3520ns - 3540ns)
*	Reading 1110011110110011 from address 000000011 (from port 0) during cycle 178 (3560ns - 3580ns)
*	Reading 0001111100000111 from address 100011110 (from port 0) during cycle 179 (3580ns - 3600ns)
*	Writing 0000110110011110  to  address 100011110 (from port 0) during cycle 183 (3660ns - 3680ns)
*	Reading 1100101111011011 from address 000000000 (from port 0) during cycle 186 (3720ns - 3740ns)
*	Writing 1110110101011000  to  address 100011011 (from port 0) during cycle 187 (3740ns - 3760ns)
*	Writing 0001001000111100  to  address 100011100 (from port 0) during cycle 190 (3800ns - 3820ns)
*	Writing 0000110001100111  to  address 100011100 (from port 0) during cycle 191 (3820ns - 3840ns)
*	Reading 1110100101001111 from address 000000001 (from port 0) during cycle 193 (3860ns - 3880ns)
*	Writing 1011111001111001  to  address 100011110 (from port 0) during cycle 194 (3880ns - 3900ns)
*	Reading 1011111001111001 from address 100011110 (from port 0) during cycle 195 (3900ns - 3920ns)
*	Writing 1000010000010011  to  address 000000011 (from port 0) during cycle 197 (3940ns - 3960ns)
*	Reading 0000110001100111 from address 100011100 (from port 0) during cycle 198 (3960ns - 3980ns)
*	Reading 1000010000010011 from address 000000011 (from port 0) during cycle 199 (3980ns - 4000ns)
*	Reading 1100000001010011 from address 100011101 (from port 0) during cycle 201 (4020ns - 4040ns)
*	Reading 1000010000010011 from address 000000011 (from port 0) during cycle 202 (4040ns - 4060ns)
*	Writing 0010011110101111  to  address 100011011 (from port 0) during cycle 203 (4060ns - 4080ns)
*	Writing 0110101000000010  to  address 000000011 (from port 0) during cycle 204 (4080ns - 4100ns)
*	Idle during cycle 205 (4100ns - 4120ns)

* Generation of data and address signals
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 0), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 1), (1720, 1), (1740, 0), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 0), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 0), (540, 0), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 1), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 0), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 0), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 0), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 0), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 1), (520, 0), (540, 0), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 0), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 0), (520, 1), (540, 0), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 0), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 0), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 0), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 0), (540, 0), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 0), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 0), (540, 0), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 0), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 0), (220, 1), (240, 1), (260, 0), (280, 1), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 1), (540, 0), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 1), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 1), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 0), (1360, 1), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 0), (1620, 1), (1640, 0), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 1), (2180, 0), (2200, 1), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 0), (2540, 1), (2560, 0), (2580, 0), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 0), (3160, 0), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 1), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 1), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 1), (300, 1), (320, 1), (340, 0), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 0), (780, 1), (800, 1), (820, 0), (840, 0), (860, 1), (880, 1), (900, 1), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 0), (1060, 1), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 0), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 0), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 1), (1780, 1), (1800, 1), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 1), (2540, 0), (2560, 1), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 0), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 0), (3460, 1), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 1), (4000, 1), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 1), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 1), (520, 0), (540, 0), (560, 0), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 1), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 1), (1360, 0), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 1), (1980, 0), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 1), (2220, 1), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 0), (2520, 1), (2540, 0), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 0), (2900, 1), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 1), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 0), (3360, 1), (3380, 1), (3400, 0), (3420, 1), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 1), (3980, 0), (4000, 0), (4020, 1), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 0), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 0), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 1), (520, 0), (540, 0), (560, 0), (580, 1), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 1), (720, 0), (740, 0), (760, 0), (780, 0), (800, 1), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 1), (1360, 0), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 1), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 0), (1960, 1), (1980, 0), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 0), (2900, 1), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 1), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 0), (3360, 1), (3380, 1), (3400, 0), (3420, 1), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 1), (3980, 0), (4000, 0), (4020, 1), (4040, 0), (4060, 1), (4080, 0), (4100, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 0), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 0), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 1), (520, 0), (540, 0), (560, 0), (580, 1), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 1), (720, 0), (740, 0), (760, 0), (780, 0), (800, 1), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 1), (1360, 0), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 1), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 0), (1960, 1), (1980, 0), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 0), (2900, 1), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 1), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 0), (3360, 1), (3380, 1), (3400, 0), (3420, 1), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 1), (3980, 0), (4000, 0), (4020, 1), (4040, 0), (4060, 1), (4080, 0), (4100, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 0), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 0), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 1), (520, 0), (540, 0), (560, 0), (580, 1), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 1), (720, 0), (740, 0), (760, 0), (780, 0), (800, 1), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 1), (1360, 0), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 1), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 0), (1960, 1), (1980, 0), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 0), (2900, 1), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 1), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 0), (3360, 1), (3380, 1), (3400, 0), (3420, 1), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 1), (3980, 0), (4000, 0), (4020, 1), (4040, 0), (4060, 1), (4080, 0), (4100, 0)]
Va0_8  a0_8  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 1), (140, 1), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 0), (420, 1), (440, 0), (460, 0), (480, 0), (500, 1), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 1), (640, 1), (660, 0), (680, 1), (700, 0), (720, 0), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 1), (900, 0), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 1), (1240, 0), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 1), (1560, 0), (1580, 0), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 0), (2300, 0), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 0), (2420, 1), (2440, 0), (2460, 0), (2480, 1), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 1), (2760, 0), (2780, 0), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 1), (3140, 0), (3160, 1), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 1), (3560, 0), (3580, 0), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 1), (3700, 1), (3720, 0), (3740, 0), (3760, 1), (3780, 1), (3800, 0), (3820, 0), (3840, 1), (3860, 0), (3880, 0), (3900, 0), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 1.8v )
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 1), (480, 1), (500, 1), (520, 0), (540, 0), (560, 1), (580, 0), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 1), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 1), (1720, 1), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 1), (1940, 1), (1960, 0), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 1), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 1), (2600, 1), (2620, 0), (2640, 1), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 1), (3480, 0), (3500, 1), (3520, 0), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 1), (3780, 1), (3800, 0), (3820, 0), (3840, 1), (3860, 1), (3880, 0), (3900, 1), (3920, 1), (3940, 0), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 1.8v )
* PULSE: period=20
Vclk0 clk0 0 PULSE (0 1.8 19.95n 0.1n 0.1n 9.899999999999999n 20n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0 time = 100
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=100.1n

* CHECK dout0_1 Vdout0_1ck4 = 0 time = 100
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=100.1n

* CHECK dout0_2 Vdout0_2ck4 = 1.8 time = 100
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=100.1n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 100
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=100.1n

* CHECK dout0_4 Vdout0_4ck4 = 0 time = 100
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=100.1n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 100
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=100.1n

* CHECK dout0_6 Vdout0_6ck4 = 1.8 time = 100
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=100.1n

* CHECK dout0_7 Vdout0_7ck4 = 1.8 time = 100
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=100.1n

* CHECK dout0_8 Vdout0_8ck4 = 1.8 time = 100
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=100.1n

* CHECK dout0_9 Vdout0_9ck4 = 0 time = 100
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=100.1n

* CHECK dout0_10 Vdout0_10ck4 = 1.8 time = 100
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=100.1n

* CHECK dout0_11 Vdout0_11ck4 = 1.8 time = 100
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=100.1n

* CHECK dout0_12 Vdout0_12ck4 = 0 time = 100
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=100.1n

* CHECK dout0_13 Vdout0_13ck4 = 1.8 time = 100
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=100.1n

* CHECK dout0_14 Vdout0_14ck4 = 1.8 time = 100
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=100.1n

* CHECK dout0_15 Vdout0_15ck4 = 1.8 time = 100
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=100.1n

* CHECK dout0_0 Vdout0_0ck5 = 0 time = 120
.meas tran vdout0_0ck5 FIND v(dout0_0) AT=120.1n

* CHECK dout0_1 Vdout0_1ck5 = 1.8 time = 120
.meas tran vdout0_1ck5 FIND v(dout0_1) AT=120.1n

* CHECK dout0_2 Vdout0_2ck5 = 0 time = 120
.meas tran vdout0_2ck5 FIND v(dout0_2) AT=120.1n

* CHECK dout0_3 Vdout0_3ck5 = 1.8 time = 120
.meas tran vdout0_3ck5 FIND v(dout0_3) AT=120.1n

* CHECK dout0_4 Vdout0_4ck5 = 0 time = 120
.meas tran vdout0_4ck5 FIND v(dout0_4) AT=120.1n

* CHECK dout0_5 Vdout0_5ck5 = 1.8 time = 120
.meas tran vdout0_5ck5 FIND v(dout0_5) AT=120.1n

* CHECK dout0_6 Vdout0_6ck5 = 0 time = 120
.meas tran vdout0_6ck5 FIND v(dout0_6) AT=120.1n

* CHECK dout0_7 Vdout0_7ck5 = 0 time = 120
.meas tran vdout0_7ck5 FIND v(dout0_7) AT=120.1n

* CHECK dout0_8 Vdout0_8ck5 = 0 time = 120
.meas tran vdout0_8ck5 FIND v(dout0_8) AT=120.1n

* CHECK dout0_9 Vdout0_9ck5 = 1.8 time = 120
.meas tran vdout0_9ck5 FIND v(dout0_9) AT=120.1n

* CHECK dout0_10 Vdout0_10ck5 = 0 time = 120
.meas tran vdout0_10ck5 FIND v(dout0_10) AT=120.1n

* CHECK dout0_11 Vdout0_11ck5 = 1.8 time = 120
.meas tran vdout0_11ck5 FIND v(dout0_11) AT=120.1n

* CHECK dout0_12 Vdout0_12ck5 = 1.8 time = 120
.meas tran vdout0_12ck5 FIND v(dout0_12) AT=120.1n

* CHECK dout0_13 Vdout0_13ck5 = 1.8 time = 120
.meas tran vdout0_13ck5 FIND v(dout0_13) AT=120.1n

* CHECK dout0_14 Vdout0_14ck5 = 0 time = 120
.meas tran vdout0_14ck5 FIND v(dout0_14) AT=120.1n

* CHECK dout0_15 Vdout0_15ck5 = 1.8 time = 120
.meas tran vdout0_15ck5 FIND v(dout0_15) AT=120.1n

* CHECK dout0_0 Vdout0_0ck9 = 0 time = 200
.meas tran vdout0_0ck9 FIND v(dout0_0) AT=200.1n

* CHECK dout0_1 Vdout0_1ck9 = 1.8 time = 200
.meas tran vdout0_1ck9 FIND v(dout0_1) AT=200.1n

* CHECK dout0_2 Vdout0_2ck9 = 0 time = 200
.meas tran vdout0_2ck9 FIND v(dout0_2) AT=200.1n

* CHECK dout0_3 Vdout0_3ck9 = 1.8 time = 200
.meas tran vdout0_3ck9 FIND v(dout0_3) AT=200.1n

* CHECK dout0_4 Vdout0_4ck9 = 0 time = 200
.meas tran vdout0_4ck9 FIND v(dout0_4) AT=200.1n

* CHECK dout0_5 Vdout0_5ck9 = 0 time = 200
.meas tran vdout0_5ck9 FIND v(dout0_5) AT=200.1n

* CHECK dout0_6 Vdout0_6ck9 = 0 time = 200
.meas tran vdout0_6ck9 FIND v(dout0_6) AT=200.1n

* CHECK dout0_7 Vdout0_7ck9 = 1.8 time = 200
.meas tran vdout0_7ck9 FIND v(dout0_7) AT=200.1n

* CHECK dout0_8 Vdout0_8ck9 = 1.8 time = 200
.meas tran vdout0_8ck9 FIND v(dout0_8) AT=200.1n

* CHECK dout0_9 Vdout0_9ck9 = 1.8 time = 200
.meas tran vdout0_9ck9 FIND v(dout0_9) AT=200.1n

* CHECK dout0_10 Vdout0_10ck9 = 1.8 time = 200
.meas tran vdout0_10ck9 FIND v(dout0_10) AT=200.1n

* CHECK dout0_11 Vdout0_11ck9 = 0 time = 200
.meas tran vdout0_11ck9 FIND v(dout0_11) AT=200.1n

* CHECK dout0_12 Vdout0_12ck9 = 1.8 time = 200
.meas tran vdout0_12ck9 FIND v(dout0_12) AT=200.1n

* CHECK dout0_13 Vdout0_13ck9 = 1.8 time = 200
.meas tran vdout0_13ck9 FIND v(dout0_13) AT=200.1n

* CHECK dout0_14 Vdout0_14ck9 = 0 time = 200
.meas tran vdout0_14ck9 FIND v(dout0_14) AT=200.1n

* CHECK dout0_15 Vdout0_15ck9 = 0 time = 200
.meas tran vdout0_15ck9 FIND v(dout0_15) AT=200.1n

* CHECK dout0_0 Vdout0_0ck10 = 0 time = 220
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=220.1n

* CHECK dout0_1 Vdout0_1ck10 = 1.8 time = 220
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=220.1n

* CHECK dout0_2 Vdout0_2ck10 = 0 time = 220
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=220.1n

* CHECK dout0_3 Vdout0_3ck10 = 1.8 time = 220
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=220.1n

* CHECK dout0_4 Vdout0_4ck10 = 0 time = 220
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=220.1n

* CHECK dout0_5 Vdout0_5ck10 = 0 time = 220
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=220.1n

* CHECK dout0_6 Vdout0_6ck10 = 0 time = 220
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=220.1n

* CHECK dout0_7 Vdout0_7ck10 = 1.8 time = 220
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=220.1n

* CHECK dout0_8 Vdout0_8ck10 = 1.8 time = 220
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=220.1n

* CHECK dout0_9 Vdout0_9ck10 = 1.8 time = 220
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=220.1n

* CHECK dout0_10 Vdout0_10ck10 = 1.8 time = 220
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=220.1n

* CHECK dout0_11 Vdout0_11ck10 = 0 time = 220
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=220.1n

* CHECK dout0_12 Vdout0_12ck10 = 1.8 time = 220
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=220.1n

* CHECK dout0_13 Vdout0_13ck10 = 1.8 time = 220
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=220.1n

* CHECK dout0_14 Vdout0_14ck10 = 0 time = 220
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=220.1n

* CHECK dout0_15 Vdout0_15ck10 = 0 time = 220
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=220.1n

* CHECK dout0_0 Vdout0_0ck11 = 0 time = 240
.meas tran vdout0_0ck11 FIND v(dout0_0) AT=240.1n

* CHECK dout0_1 Vdout0_1ck11 = 0 time = 240
.meas tran vdout0_1ck11 FIND v(dout0_1) AT=240.1n

* CHECK dout0_2 Vdout0_2ck11 = 1.8 time = 240
.meas tran vdout0_2ck11 FIND v(dout0_2) AT=240.1n

* CHECK dout0_3 Vdout0_3ck11 = 1.8 time = 240
.meas tran vdout0_3ck11 FIND v(dout0_3) AT=240.1n

* CHECK dout0_4 Vdout0_4ck11 = 0 time = 240
.meas tran vdout0_4ck11 FIND v(dout0_4) AT=240.1n

* CHECK dout0_5 Vdout0_5ck11 = 0 time = 240
.meas tran vdout0_5ck11 FIND v(dout0_5) AT=240.1n

* CHECK dout0_6 Vdout0_6ck11 = 1.8 time = 240
.meas tran vdout0_6ck11 FIND v(dout0_6) AT=240.1n

* CHECK dout0_7 Vdout0_7ck11 = 0 time = 240
.meas tran vdout0_7ck11 FIND v(dout0_7) AT=240.1n

* CHECK dout0_8 Vdout0_8ck11 = 0 time = 240
.meas tran vdout0_8ck11 FIND v(dout0_8) AT=240.1n

* CHECK dout0_9 Vdout0_9ck11 = 0 time = 240
.meas tran vdout0_9ck11 FIND v(dout0_9) AT=240.1n

* CHECK dout0_10 Vdout0_10ck11 = 1.8 time = 240
.meas tran vdout0_10ck11 FIND v(dout0_10) AT=240.1n

* CHECK dout0_11 Vdout0_11ck11 = 1.8 time = 240
.meas tran vdout0_11ck11 FIND v(dout0_11) AT=240.1n

* CHECK dout0_12 Vdout0_12ck11 = 0 time = 240
.meas tran vdout0_12ck11 FIND v(dout0_12) AT=240.1n

* CHECK dout0_13 Vdout0_13ck11 = 0 time = 240
.meas tran vdout0_13ck11 FIND v(dout0_13) AT=240.1n

* CHECK dout0_14 Vdout0_14ck11 = 0 time = 240
.meas tran vdout0_14ck11 FIND v(dout0_14) AT=240.1n

* CHECK dout0_15 Vdout0_15ck11 = 1.8 time = 240
.meas tran vdout0_15ck11 FIND v(dout0_15) AT=240.1n

* CHECK dout0_0 Vdout0_0ck12 = 0 time = 260
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=260.1n

* CHECK dout0_1 Vdout0_1ck12 = 0 time = 260
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=260.1n

* CHECK dout0_2 Vdout0_2ck12 = 1.8 time = 260
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=260.1n

* CHECK dout0_3 Vdout0_3ck12 = 1.8 time = 260
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=260.1n

* CHECK dout0_4 Vdout0_4ck12 = 0 time = 260
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=260.1n

* CHECK dout0_5 Vdout0_5ck12 = 0 time = 260
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=260.1n

* CHECK dout0_6 Vdout0_6ck12 = 1.8 time = 260
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=260.1n

* CHECK dout0_7 Vdout0_7ck12 = 0 time = 260
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=260.1n

* CHECK dout0_8 Vdout0_8ck12 = 0 time = 260
.meas tran vdout0_8ck12 FIND v(dout0_8) AT=260.1n

* CHECK dout0_9 Vdout0_9ck12 = 0 time = 260
.meas tran vdout0_9ck12 FIND v(dout0_9) AT=260.1n

* CHECK dout0_10 Vdout0_10ck12 = 1.8 time = 260
.meas tran vdout0_10ck12 FIND v(dout0_10) AT=260.1n

* CHECK dout0_11 Vdout0_11ck12 = 1.8 time = 260
.meas tran vdout0_11ck12 FIND v(dout0_11) AT=260.1n

* CHECK dout0_12 Vdout0_12ck12 = 0 time = 260
.meas tran vdout0_12ck12 FIND v(dout0_12) AT=260.1n

* CHECK dout0_13 Vdout0_13ck12 = 0 time = 260
.meas tran vdout0_13ck12 FIND v(dout0_13) AT=260.1n

* CHECK dout0_14 Vdout0_14ck12 = 0 time = 260
.meas tran vdout0_14ck12 FIND v(dout0_14) AT=260.1n

* CHECK dout0_15 Vdout0_15ck12 = 1.8 time = 260
.meas tran vdout0_15ck12 FIND v(dout0_15) AT=260.1n

* CHECK dout0_0 Vdout0_0ck14 = 0 time = 300
.meas tran vdout0_0ck14 FIND v(dout0_0) AT=300.1n

* CHECK dout0_1 Vdout0_1ck14 = 1.8 time = 300
.meas tran vdout0_1ck14 FIND v(dout0_1) AT=300.1n

* CHECK dout0_2 Vdout0_2ck14 = 0 time = 300
.meas tran vdout0_2ck14 FIND v(dout0_2) AT=300.1n

* CHECK dout0_3 Vdout0_3ck14 = 1.8 time = 300
.meas tran vdout0_3ck14 FIND v(dout0_3) AT=300.1n

* CHECK dout0_4 Vdout0_4ck14 = 0 time = 300
.meas tran vdout0_4ck14 FIND v(dout0_4) AT=300.1n

* CHECK dout0_5 Vdout0_5ck14 = 1.8 time = 300
.meas tran vdout0_5ck14 FIND v(dout0_5) AT=300.1n

* CHECK dout0_6 Vdout0_6ck14 = 0 time = 300
.meas tran vdout0_6ck14 FIND v(dout0_6) AT=300.1n

* CHECK dout0_7 Vdout0_7ck14 = 0 time = 300
.meas tran vdout0_7ck14 FIND v(dout0_7) AT=300.1n

* CHECK dout0_8 Vdout0_8ck14 = 0 time = 300
.meas tran vdout0_8ck14 FIND v(dout0_8) AT=300.1n

* CHECK dout0_9 Vdout0_9ck14 = 1.8 time = 300
.meas tran vdout0_9ck14 FIND v(dout0_9) AT=300.1n

* CHECK dout0_10 Vdout0_10ck14 = 0 time = 300
.meas tran vdout0_10ck14 FIND v(dout0_10) AT=300.1n

* CHECK dout0_11 Vdout0_11ck14 = 1.8 time = 300
.meas tran vdout0_11ck14 FIND v(dout0_11) AT=300.1n

* CHECK dout0_12 Vdout0_12ck14 = 1.8 time = 300
.meas tran vdout0_12ck14 FIND v(dout0_12) AT=300.1n

* CHECK dout0_13 Vdout0_13ck14 = 1.8 time = 300
.meas tran vdout0_13ck14 FIND v(dout0_13) AT=300.1n

* CHECK dout0_14 Vdout0_14ck14 = 0 time = 300
.meas tran vdout0_14ck14 FIND v(dout0_14) AT=300.1n

* CHECK dout0_15 Vdout0_15ck14 = 1.8 time = 300
.meas tran vdout0_15ck14 FIND v(dout0_15) AT=300.1n

* CHECK dout0_0 Vdout0_0ck17 = 0 time = 360
.meas tran vdout0_0ck17 FIND v(dout0_0) AT=360.1n

* CHECK dout0_1 Vdout0_1ck17 = 1.8 time = 360
.meas tran vdout0_1ck17 FIND v(dout0_1) AT=360.1n

* CHECK dout0_2 Vdout0_2ck17 = 1.8 time = 360
.meas tran vdout0_2ck17 FIND v(dout0_2) AT=360.1n

* CHECK dout0_3 Vdout0_3ck17 = 1.8 time = 360
.meas tran vdout0_3ck17 FIND v(dout0_3) AT=360.1n

* CHECK dout0_4 Vdout0_4ck17 = 0 time = 360
.meas tran vdout0_4ck17 FIND v(dout0_4) AT=360.1n

* CHECK dout0_5 Vdout0_5ck17 = 0 time = 360
.meas tran vdout0_5ck17 FIND v(dout0_5) AT=360.1n

* CHECK dout0_6 Vdout0_6ck17 = 1.8 time = 360
.meas tran vdout0_6ck17 FIND v(dout0_6) AT=360.1n

* CHECK dout0_7 Vdout0_7ck17 = 0 time = 360
.meas tran vdout0_7ck17 FIND v(dout0_7) AT=360.1n

* CHECK dout0_8 Vdout0_8ck17 = 0 time = 360
.meas tran vdout0_8ck17 FIND v(dout0_8) AT=360.1n

* CHECK dout0_9 Vdout0_9ck17 = 1.8 time = 360
.meas tran vdout0_9ck17 FIND v(dout0_9) AT=360.1n

* CHECK dout0_10 Vdout0_10ck17 = 1.8 time = 360
.meas tran vdout0_10ck17 FIND v(dout0_10) AT=360.1n

* CHECK dout0_11 Vdout0_11ck17 = 1.8 time = 360
.meas tran vdout0_11ck17 FIND v(dout0_11) AT=360.1n

* CHECK dout0_12 Vdout0_12ck17 = 1.8 time = 360
.meas tran vdout0_12ck17 FIND v(dout0_12) AT=360.1n

* CHECK dout0_13 Vdout0_13ck17 = 0 time = 360
.meas tran vdout0_13ck17 FIND v(dout0_13) AT=360.1n

* CHECK dout0_14 Vdout0_14ck17 = 0 time = 360
.meas tran vdout0_14ck17 FIND v(dout0_14) AT=360.1n

* CHECK dout0_15 Vdout0_15ck17 = 1.8 time = 360
.meas tran vdout0_15ck17 FIND v(dout0_15) AT=360.1n

* CHECK dout0_0 Vdout0_0ck18 = 0 time = 380
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=380.1n

* CHECK dout0_1 Vdout0_1ck18 = 1.8 time = 380
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=380.1n

* CHECK dout0_2 Vdout0_2ck18 = 0 time = 380
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=380.1n

* CHECK dout0_3 Vdout0_3ck18 = 1.8 time = 380
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=380.1n

* CHECK dout0_4 Vdout0_4ck18 = 0 time = 380
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=380.1n

* CHECK dout0_5 Vdout0_5ck18 = 0 time = 380
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=380.1n

* CHECK dout0_6 Vdout0_6ck18 = 0 time = 380
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=380.1n

* CHECK dout0_7 Vdout0_7ck18 = 1.8 time = 380
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=380.1n

* CHECK dout0_8 Vdout0_8ck18 = 1.8 time = 380
.meas tran vdout0_8ck18 FIND v(dout0_8) AT=380.1n

* CHECK dout0_9 Vdout0_9ck18 = 1.8 time = 380
.meas tran vdout0_9ck18 FIND v(dout0_9) AT=380.1n

* CHECK dout0_10 Vdout0_10ck18 = 1.8 time = 380
.meas tran vdout0_10ck18 FIND v(dout0_10) AT=380.1n

* CHECK dout0_11 Vdout0_11ck18 = 0 time = 380
.meas tran vdout0_11ck18 FIND v(dout0_11) AT=380.1n

* CHECK dout0_12 Vdout0_12ck18 = 1.8 time = 380
.meas tran vdout0_12ck18 FIND v(dout0_12) AT=380.1n

* CHECK dout0_13 Vdout0_13ck18 = 1.8 time = 380
.meas tran vdout0_13ck18 FIND v(dout0_13) AT=380.1n

* CHECK dout0_14 Vdout0_14ck18 = 0 time = 380
.meas tran vdout0_14ck18 FIND v(dout0_14) AT=380.1n

* CHECK dout0_15 Vdout0_15ck18 = 0 time = 380
.meas tran vdout0_15ck18 FIND v(dout0_15) AT=380.1n

* CHECK dout0_0 Vdout0_0ck19 = 0 time = 400
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=400.1n

* CHECK dout0_1 Vdout0_1ck19 = 1.8 time = 400
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=400.1n

* CHECK dout0_2 Vdout0_2ck19 = 0 time = 400
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=400.1n

* CHECK dout0_3 Vdout0_3ck19 = 1.8 time = 400
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=400.1n

* CHECK dout0_4 Vdout0_4ck19 = 0 time = 400
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=400.1n

* CHECK dout0_5 Vdout0_5ck19 = 0 time = 400
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=400.1n

* CHECK dout0_6 Vdout0_6ck19 = 0 time = 400
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=400.1n

* CHECK dout0_7 Vdout0_7ck19 = 1.8 time = 400
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=400.1n

* CHECK dout0_8 Vdout0_8ck19 = 1.8 time = 400
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=400.1n

* CHECK dout0_9 Vdout0_9ck19 = 1.8 time = 400
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=400.1n

* CHECK dout0_10 Vdout0_10ck19 = 1.8 time = 400
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=400.1n

* CHECK dout0_11 Vdout0_11ck19 = 0 time = 400
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=400.1n

* CHECK dout0_12 Vdout0_12ck19 = 1.8 time = 400
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=400.1n

* CHECK dout0_13 Vdout0_13ck19 = 1.8 time = 400
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=400.1n

* CHECK dout0_14 Vdout0_14ck19 = 0 time = 400
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=400.1n

* CHECK dout0_15 Vdout0_15ck19 = 0 time = 400
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=400.1n

* CHECK dout0_0 Vdout0_0ck20 = 0 time = 420
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=420.1n

* CHECK dout0_1 Vdout0_1ck20 = 1.8 time = 420
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=420.1n

* CHECK dout0_2 Vdout0_2ck20 = 1.8 time = 420
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=420.1n

* CHECK dout0_3 Vdout0_3ck20 = 1.8 time = 420
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=420.1n

* CHECK dout0_4 Vdout0_4ck20 = 0 time = 420
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=420.1n

* CHECK dout0_5 Vdout0_5ck20 = 0 time = 420
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=420.1n

* CHECK dout0_6 Vdout0_6ck20 = 1.8 time = 420
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=420.1n

* CHECK dout0_7 Vdout0_7ck20 = 0 time = 420
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=420.1n

* CHECK dout0_8 Vdout0_8ck20 = 0 time = 420
.meas tran vdout0_8ck20 FIND v(dout0_8) AT=420.1n

* CHECK dout0_9 Vdout0_9ck20 = 1.8 time = 420
.meas tran vdout0_9ck20 FIND v(dout0_9) AT=420.1n

* CHECK dout0_10 Vdout0_10ck20 = 1.8 time = 420
.meas tran vdout0_10ck20 FIND v(dout0_10) AT=420.1n

* CHECK dout0_11 Vdout0_11ck20 = 1.8 time = 420
.meas tran vdout0_11ck20 FIND v(dout0_11) AT=420.1n

* CHECK dout0_12 Vdout0_12ck20 = 1.8 time = 420
.meas tran vdout0_12ck20 FIND v(dout0_12) AT=420.1n

* CHECK dout0_13 Vdout0_13ck20 = 0 time = 420
.meas tran vdout0_13ck20 FIND v(dout0_13) AT=420.1n

* CHECK dout0_14 Vdout0_14ck20 = 0 time = 420
.meas tran vdout0_14ck20 FIND v(dout0_14) AT=420.1n

* CHECK dout0_15 Vdout0_15ck20 = 1.8 time = 420
.meas tran vdout0_15ck20 FIND v(dout0_15) AT=420.1n

* CHECK dout0_0 Vdout0_0ck23 = 1.8 time = 480
.meas tran vdout0_0ck23 FIND v(dout0_0) AT=480.1n

* CHECK dout0_1 Vdout0_1ck23 = 1.8 time = 480
.meas tran vdout0_1ck23 FIND v(dout0_1) AT=480.1n

* CHECK dout0_2 Vdout0_2ck23 = 0 time = 480
.meas tran vdout0_2ck23 FIND v(dout0_2) AT=480.1n

* CHECK dout0_3 Vdout0_3ck23 = 0 time = 480
.meas tran vdout0_3ck23 FIND v(dout0_3) AT=480.1n

* CHECK dout0_4 Vdout0_4ck23 = 0 time = 480
.meas tran vdout0_4ck23 FIND v(dout0_4) AT=480.1n

* CHECK dout0_5 Vdout0_5ck23 = 1.8 time = 480
.meas tran vdout0_5ck23 FIND v(dout0_5) AT=480.1n

* CHECK dout0_6 Vdout0_6ck23 = 0 time = 480
.meas tran vdout0_6ck23 FIND v(dout0_6) AT=480.1n

* CHECK dout0_7 Vdout0_7ck23 = 0 time = 480
.meas tran vdout0_7ck23 FIND v(dout0_7) AT=480.1n

* CHECK dout0_8 Vdout0_8ck23 = 1.8 time = 480
.meas tran vdout0_8ck23 FIND v(dout0_8) AT=480.1n

* CHECK dout0_9 Vdout0_9ck23 = 0 time = 480
.meas tran vdout0_9ck23 FIND v(dout0_9) AT=480.1n

* CHECK dout0_10 Vdout0_10ck23 = 1.8 time = 480
.meas tran vdout0_10ck23 FIND v(dout0_10) AT=480.1n

* CHECK dout0_11 Vdout0_11ck23 = 0 time = 480
.meas tran vdout0_11ck23 FIND v(dout0_11) AT=480.1n

* CHECK dout0_12 Vdout0_12ck23 = 1.8 time = 480
.meas tran vdout0_12ck23 FIND v(dout0_12) AT=480.1n

* CHECK dout0_13 Vdout0_13ck23 = 0 time = 480
.meas tran vdout0_13ck23 FIND v(dout0_13) AT=480.1n

* CHECK dout0_14 Vdout0_14ck23 = 1.8 time = 480
.meas tran vdout0_14ck23 FIND v(dout0_14) AT=480.1n

* CHECK dout0_15 Vdout0_15ck23 = 1.8 time = 480
.meas tran vdout0_15ck23 FIND v(dout0_15) AT=480.1n

* CHECK dout0_0 Vdout0_0ck24 = 0 time = 500
.meas tran vdout0_0ck24 FIND v(dout0_0) AT=500.1n

* CHECK dout0_1 Vdout0_1ck24 = 1.8 time = 500
.meas tran vdout0_1ck24 FIND v(dout0_1) AT=500.1n

* CHECK dout0_2 Vdout0_2ck24 = 0 time = 500
.meas tran vdout0_2ck24 FIND v(dout0_2) AT=500.1n

* CHECK dout0_3 Vdout0_3ck24 = 1.8 time = 500
.meas tran vdout0_3ck24 FIND v(dout0_3) AT=500.1n

* CHECK dout0_4 Vdout0_4ck24 = 0 time = 500
.meas tran vdout0_4ck24 FIND v(dout0_4) AT=500.1n

* CHECK dout0_5 Vdout0_5ck24 = 0 time = 500
.meas tran vdout0_5ck24 FIND v(dout0_5) AT=500.1n

* CHECK dout0_6 Vdout0_6ck24 = 0 time = 500
.meas tran vdout0_6ck24 FIND v(dout0_6) AT=500.1n

* CHECK dout0_7 Vdout0_7ck24 = 1.8 time = 500
.meas tran vdout0_7ck24 FIND v(dout0_7) AT=500.1n

* CHECK dout0_8 Vdout0_8ck24 = 1.8 time = 500
.meas tran vdout0_8ck24 FIND v(dout0_8) AT=500.1n

* CHECK dout0_9 Vdout0_9ck24 = 1.8 time = 500
.meas tran vdout0_9ck24 FIND v(dout0_9) AT=500.1n

* CHECK dout0_10 Vdout0_10ck24 = 1.8 time = 500
.meas tran vdout0_10ck24 FIND v(dout0_10) AT=500.1n

* CHECK dout0_11 Vdout0_11ck24 = 0 time = 500
.meas tran vdout0_11ck24 FIND v(dout0_11) AT=500.1n

* CHECK dout0_12 Vdout0_12ck24 = 1.8 time = 500
.meas tran vdout0_12ck24 FIND v(dout0_12) AT=500.1n

* CHECK dout0_13 Vdout0_13ck24 = 1.8 time = 500
.meas tran vdout0_13ck24 FIND v(dout0_13) AT=500.1n

* CHECK dout0_14 Vdout0_14ck24 = 0 time = 500
.meas tran vdout0_14ck24 FIND v(dout0_14) AT=500.1n

* CHECK dout0_15 Vdout0_15ck24 = 0 time = 500
.meas tran vdout0_15ck24 FIND v(dout0_15) AT=500.1n

* CHECK dout0_0 Vdout0_0ck28 = 1.8 time = 580
.meas tran vdout0_0ck28 FIND v(dout0_0) AT=580.1n

* CHECK dout0_1 Vdout0_1ck28 = 0 time = 580
.meas tran vdout0_1ck28 FIND v(dout0_1) AT=580.1n

* CHECK dout0_2 Vdout0_2ck28 = 1.8 time = 580
.meas tran vdout0_2ck28 FIND v(dout0_2) AT=580.1n

* CHECK dout0_3 Vdout0_3ck28 = 1.8 time = 580
.meas tran vdout0_3ck28 FIND v(dout0_3) AT=580.1n

* CHECK dout0_4 Vdout0_4ck28 = 1.8 time = 580
.meas tran vdout0_4ck28 FIND v(dout0_4) AT=580.1n

* CHECK dout0_5 Vdout0_5ck28 = 0 time = 580
.meas tran vdout0_5ck28 FIND v(dout0_5) AT=580.1n

* CHECK dout0_6 Vdout0_6ck28 = 0 time = 580
.meas tran vdout0_6ck28 FIND v(dout0_6) AT=580.1n

* CHECK dout0_7 Vdout0_7ck28 = 1.8 time = 580
.meas tran vdout0_7ck28 FIND v(dout0_7) AT=580.1n

* CHECK dout0_8 Vdout0_8ck28 = 1.8 time = 580
.meas tran vdout0_8ck28 FIND v(dout0_8) AT=580.1n

* CHECK dout0_9 Vdout0_9ck28 = 1.8 time = 580
.meas tran vdout0_9ck28 FIND v(dout0_9) AT=580.1n

* CHECK dout0_10 Vdout0_10ck28 = 1.8 time = 580
.meas tran vdout0_10ck28 FIND v(dout0_10) AT=580.1n

* CHECK dout0_11 Vdout0_11ck28 = 1.8 time = 580
.meas tran vdout0_11ck28 FIND v(dout0_11) AT=580.1n

* CHECK dout0_12 Vdout0_12ck28 = 0 time = 580
.meas tran vdout0_12ck28 FIND v(dout0_12) AT=580.1n

* CHECK dout0_13 Vdout0_13ck28 = 1.8 time = 580
.meas tran vdout0_13ck28 FIND v(dout0_13) AT=580.1n

* CHECK dout0_14 Vdout0_14ck28 = 1.8 time = 580
.meas tran vdout0_14ck28 FIND v(dout0_14) AT=580.1n

* CHECK dout0_15 Vdout0_15ck28 = 0 time = 580
.meas tran vdout0_15ck28 FIND v(dout0_15) AT=580.1n

* CHECK dout0_0 Vdout0_0ck30 = 1.8 time = 620
.meas tran vdout0_0ck30 FIND v(dout0_0) AT=620.1n

* CHECK dout0_1 Vdout0_1ck30 = 1.8 time = 620
.meas tran vdout0_1ck30 FIND v(dout0_1) AT=620.1n

* CHECK dout0_2 Vdout0_2ck30 = 0 time = 620
.meas tran vdout0_2ck30 FIND v(dout0_2) AT=620.1n

* CHECK dout0_3 Vdout0_3ck30 = 0 time = 620
.meas tran vdout0_3ck30 FIND v(dout0_3) AT=620.1n

* CHECK dout0_4 Vdout0_4ck30 = 0 time = 620
.meas tran vdout0_4ck30 FIND v(dout0_4) AT=620.1n

* CHECK dout0_5 Vdout0_5ck30 = 1.8 time = 620
.meas tran vdout0_5ck30 FIND v(dout0_5) AT=620.1n

* CHECK dout0_6 Vdout0_6ck30 = 0 time = 620
.meas tran vdout0_6ck30 FIND v(dout0_6) AT=620.1n

* CHECK dout0_7 Vdout0_7ck30 = 0 time = 620
.meas tran vdout0_7ck30 FIND v(dout0_7) AT=620.1n

* CHECK dout0_8 Vdout0_8ck30 = 1.8 time = 620
.meas tran vdout0_8ck30 FIND v(dout0_8) AT=620.1n

* CHECK dout0_9 Vdout0_9ck30 = 0 time = 620
.meas tran vdout0_9ck30 FIND v(dout0_9) AT=620.1n

* CHECK dout0_10 Vdout0_10ck30 = 1.8 time = 620
.meas tran vdout0_10ck30 FIND v(dout0_10) AT=620.1n

* CHECK dout0_11 Vdout0_11ck30 = 0 time = 620
.meas tran vdout0_11ck30 FIND v(dout0_11) AT=620.1n

* CHECK dout0_12 Vdout0_12ck30 = 1.8 time = 620
.meas tran vdout0_12ck30 FIND v(dout0_12) AT=620.1n

* CHECK dout0_13 Vdout0_13ck30 = 0 time = 620
.meas tran vdout0_13ck30 FIND v(dout0_13) AT=620.1n

* CHECK dout0_14 Vdout0_14ck30 = 1.8 time = 620
.meas tran vdout0_14ck30 FIND v(dout0_14) AT=620.1n

* CHECK dout0_15 Vdout0_15ck30 = 1.8 time = 620
.meas tran vdout0_15ck30 FIND v(dout0_15) AT=620.1n

* CHECK dout0_0 Vdout0_0ck33 = 0 time = 680
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=680.1n

* CHECK dout0_1 Vdout0_1ck33 = 1.8 time = 680
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=680.1n

* CHECK dout0_2 Vdout0_2ck33 = 0 time = 680
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=680.1n

* CHECK dout0_3 Vdout0_3ck33 = 1.8 time = 680
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=680.1n

* CHECK dout0_4 Vdout0_4ck33 = 0 time = 680
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=680.1n

* CHECK dout0_5 Vdout0_5ck33 = 1.8 time = 680
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=680.1n

* CHECK dout0_6 Vdout0_6ck33 = 0 time = 680
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=680.1n

* CHECK dout0_7 Vdout0_7ck33 = 0 time = 680
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=680.1n

* CHECK dout0_8 Vdout0_8ck33 = 0 time = 680
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=680.1n

* CHECK dout0_9 Vdout0_9ck33 = 1.8 time = 680
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=680.1n

* CHECK dout0_10 Vdout0_10ck33 = 0 time = 680
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=680.1n

* CHECK dout0_11 Vdout0_11ck33 = 1.8 time = 680
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=680.1n

* CHECK dout0_12 Vdout0_12ck33 = 1.8 time = 680
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=680.1n

* CHECK dout0_13 Vdout0_13ck33 = 1.8 time = 680
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=680.1n

* CHECK dout0_14 Vdout0_14ck33 = 0 time = 680
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=680.1n

* CHECK dout0_15 Vdout0_15ck33 = 1.8 time = 680
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=680.1n

* CHECK dout0_0 Vdout0_0ck35 = 0 time = 720
.meas tran vdout0_0ck35 FIND v(dout0_0) AT=720.1n

* CHECK dout0_1 Vdout0_1ck35 = 1.8 time = 720
.meas tran vdout0_1ck35 FIND v(dout0_1) AT=720.1n

* CHECK dout0_2 Vdout0_2ck35 = 0 time = 720
.meas tran vdout0_2ck35 FIND v(dout0_2) AT=720.1n

* CHECK dout0_3 Vdout0_3ck35 = 1.8 time = 720
.meas tran vdout0_3ck35 FIND v(dout0_3) AT=720.1n

* CHECK dout0_4 Vdout0_4ck35 = 0 time = 720
.meas tran vdout0_4ck35 FIND v(dout0_4) AT=720.1n

* CHECK dout0_5 Vdout0_5ck35 = 1.8 time = 720
.meas tran vdout0_5ck35 FIND v(dout0_5) AT=720.1n

* CHECK dout0_6 Vdout0_6ck35 = 0 time = 720
.meas tran vdout0_6ck35 FIND v(dout0_6) AT=720.1n

* CHECK dout0_7 Vdout0_7ck35 = 0 time = 720
.meas tran vdout0_7ck35 FIND v(dout0_7) AT=720.1n

* CHECK dout0_8 Vdout0_8ck35 = 0 time = 720
.meas tran vdout0_8ck35 FIND v(dout0_8) AT=720.1n

* CHECK dout0_9 Vdout0_9ck35 = 1.8 time = 720
.meas tran vdout0_9ck35 FIND v(dout0_9) AT=720.1n

* CHECK dout0_10 Vdout0_10ck35 = 0 time = 720
.meas tran vdout0_10ck35 FIND v(dout0_10) AT=720.1n

* CHECK dout0_11 Vdout0_11ck35 = 1.8 time = 720
.meas tran vdout0_11ck35 FIND v(dout0_11) AT=720.1n

* CHECK dout0_12 Vdout0_12ck35 = 1.8 time = 720
.meas tran vdout0_12ck35 FIND v(dout0_12) AT=720.1n

* CHECK dout0_13 Vdout0_13ck35 = 1.8 time = 720
.meas tran vdout0_13ck35 FIND v(dout0_13) AT=720.1n

* CHECK dout0_14 Vdout0_14ck35 = 0 time = 720
.meas tran vdout0_14ck35 FIND v(dout0_14) AT=720.1n

* CHECK dout0_15 Vdout0_15ck35 = 1.8 time = 720
.meas tran vdout0_15ck35 FIND v(dout0_15) AT=720.1n

* CHECK dout0_0 Vdout0_0ck36 = 0 time = 740
.meas tran vdout0_0ck36 FIND v(dout0_0) AT=740.1n

* CHECK dout0_1 Vdout0_1ck36 = 0 time = 740
.meas tran vdout0_1ck36 FIND v(dout0_1) AT=740.1n

* CHECK dout0_2 Vdout0_2ck36 = 1.8 time = 740
.meas tran vdout0_2ck36 FIND v(dout0_2) AT=740.1n

* CHECK dout0_3 Vdout0_3ck36 = 1.8 time = 740
.meas tran vdout0_3ck36 FIND v(dout0_3) AT=740.1n

* CHECK dout0_4 Vdout0_4ck36 = 1.8 time = 740
.meas tran vdout0_4ck36 FIND v(dout0_4) AT=740.1n

* CHECK dout0_5 Vdout0_5ck36 = 0 time = 740
.meas tran vdout0_5ck36 FIND v(dout0_5) AT=740.1n

* CHECK dout0_6 Vdout0_6ck36 = 1.8 time = 740
.meas tran vdout0_6ck36 FIND v(dout0_6) AT=740.1n

* CHECK dout0_7 Vdout0_7ck36 = 1.8 time = 740
.meas tran vdout0_7ck36 FIND v(dout0_7) AT=740.1n

* CHECK dout0_8 Vdout0_8ck36 = 1.8 time = 740
.meas tran vdout0_8ck36 FIND v(dout0_8) AT=740.1n

* CHECK dout0_9 Vdout0_9ck36 = 0 time = 740
.meas tran vdout0_9ck36 FIND v(dout0_9) AT=740.1n

* CHECK dout0_10 Vdout0_10ck36 = 1.8 time = 740
.meas tran vdout0_10ck36 FIND v(dout0_10) AT=740.1n

* CHECK dout0_11 Vdout0_11ck36 = 1.8 time = 740
.meas tran vdout0_11ck36 FIND v(dout0_11) AT=740.1n

* CHECK dout0_12 Vdout0_12ck36 = 0 time = 740
.meas tran vdout0_12ck36 FIND v(dout0_12) AT=740.1n

* CHECK dout0_13 Vdout0_13ck36 = 1.8 time = 740
.meas tran vdout0_13ck36 FIND v(dout0_13) AT=740.1n

* CHECK dout0_14 Vdout0_14ck36 = 1.8 time = 740
.meas tran vdout0_14ck36 FIND v(dout0_14) AT=740.1n

* CHECK dout0_15 Vdout0_15ck36 = 0 time = 740
.meas tran vdout0_15ck36 FIND v(dout0_15) AT=740.1n

* CHECK dout0_0 Vdout0_0ck38 = 1.8 time = 780
.meas tran vdout0_0ck38 FIND v(dout0_0) AT=780.1n

* CHECK dout0_1 Vdout0_1ck38 = 1.8 time = 780
.meas tran vdout0_1ck38 FIND v(dout0_1) AT=780.1n

* CHECK dout0_2 Vdout0_2ck38 = 0 time = 780
.meas tran vdout0_2ck38 FIND v(dout0_2) AT=780.1n

* CHECK dout0_3 Vdout0_3ck38 = 0 time = 780
.meas tran vdout0_3ck38 FIND v(dout0_3) AT=780.1n

* CHECK dout0_4 Vdout0_4ck38 = 0 time = 780
.meas tran vdout0_4ck38 FIND v(dout0_4) AT=780.1n

* CHECK dout0_5 Vdout0_5ck38 = 1.8 time = 780
.meas tran vdout0_5ck38 FIND v(dout0_5) AT=780.1n

* CHECK dout0_6 Vdout0_6ck38 = 0 time = 780
.meas tran vdout0_6ck38 FIND v(dout0_6) AT=780.1n

* CHECK dout0_7 Vdout0_7ck38 = 0 time = 780
.meas tran vdout0_7ck38 FIND v(dout0_7) AT=780.1n

* CHECK dout0_8 Vdout0_8ck38 = 1.8 time = 780
.meas tran vdout0_8ck38 FIND v(dout0_8) AT=780.1n

* CHECK dout0_9 Vdout0_9ck38 = 0 time = 780
.meas tran vdout0_9ck38 FIND v(dout0_9) AT=780.1n

* CHECK dout0_10 Vdout0_10ck38 = 1.8 time = 780
.meas tran vdout0_10ck38 FIND v(dout0_10) AT=780.1n

* CHECK dout0_11 Vdout0_11ck38 = 0 time = 780
.meas tran vdout0_11ck38 FIND v(dout0_11) AT=780.1n

* CHECK dout0_12 Vdout0_12ck38 = 1.8 time = 780
.meas tran vdout0_12ck38 FIND v(dout0_12) AT=780.1n

* CHECK dout0_13 Vdout0_13ck38 = 0 time = 780
.meas tran vdout0_13ck38 FIND v(dout0_13) AT=780.1n

* CHECK dout0_14 Vdout0_14ck38 = 1.8 time = 780
.meas tran vdout0_14ck38 FIND v(dout0_14) AT=780.1n

* CHECK dout0_15 Vdout0_15ck38 = 1.8 time = 780
.meas tran vdout0_15ck38 FIND v(dout0_15) AT=780.1n

* CHECK dout0_0 Vdout0_0ck40 = 0 time = 820
.meas tran vdout0_0ck40 FIND v(dout0_0) AT=820.1n

* CHECK dout0_1 Vdout0_1ck40 = 1.8 time = 820
.meas tran vdout0_1ck40 FIND v(dout0_1) AT=820.1n

* CHECK dout0_2 Vdout0_2ck40 = 0 time = 820
.meas tran vdout0_2ck40 FIND v(dout0_2) AT=820.1n

* CHECK dout0_3 Vdout0_3ck40 = 1.8 time = 820
.meas tran vdout0_3ck40 FIND v(dout0_3) AT=820.1n

* CHECK dout0_4 Vdout0_4ck40 = 0 time = 820
.meas tran vdout0_4ck40 FIND v(dout0_4) AT=820.1n

* CHECK dout0_5 Vdout0_5ck40 = 0 time = 820
.meas tran vdout0_5ck40 FIND v(dout0_5) AT=820.1n

* CHECK dout0_6 Vdout0_6ck40 = 0 time = 820
.meas tran vdout0_6ck40 FIND v(dout0_6) AT=820.1n

* CHECK dout0_7 Vdout0_7ck40 = 1.8 time = 820
.meas tran vdout0_7ck40 FIND v(dout0_7) AT=820.1n

* CHECK dout0_8 Vdout0_8ck40 = 1.8 time = 820
.meas tran vdout0_8ck40 FIND v(dout0_8) AT=820.1n

* CHECK dout0_9 Vdout0_9ck40 = 1.8 time = 820
.meas tran vdout0_9ck40 FIND v(dout0_9) AT=820.1n

* CHECK dout0_10 Vdout0_10ck40 = 1.8 time = 820
.meas tran vdout0_10ck40 FIND v(dout0_10) AT=820.1n

* CHECK dout0_11 Vdout0_11ck40 = 0 time = 820
.meas tran vdout0_11ck40 FIND v(dout0_11) AT=820.1n

* CHECK dout0_12 Vdout0_12ck40 = 1.8 time = 820
.meas tran vdout0_12ck40 FIND v(dout0_12) AT=820.1n

* CHECK dout0_13 Vdout0_13ck40 = 1.8 time = 820
.meas tran vdout0_13ck40 FIND v(dout0_13) AT=820.1n

* CHECK dout0_14 Vdout0_14ck40 = 0 time = 820
.meas tran vdout0_14ck40 FIND v(dout0_14) AT=820.1n

* CHECK dout0_15 Vdout0_15ck40 = 0 time = 820
.meas tran vdout0_15ck40 FIND v(dout0_15) AT=820.1n

* CHECK dout0_0 Vdout0_0ck41 = 1.8 time = 840
.meas tran vdout0_0ck41 FIND v(dout0_0) AT=840.1n

* CHECK dout0_1 Vdout0_1ck41 = 1.8 time = 840
.meas tran vdout0_1ck41 FIND v(dout0_1) AT=840.1n

* CHECK dout0_2 Vdout0_2ck41 = 0 time = 840
.meas tran vdout0_2ck41 FIND v(dout0_2) AT=840.1n

* CHECK dout0_3 Vdout0_3ck41 = 0 time = 840
.meas tran vdout0_3ck41 FIND v(dout0_3) AT=840.1n

* CHECK dout0_4 Vdout0_4ck41 = 0 time = 840
.meas tran vdout0_4ck41 FIND v(dout0_4) AT=840.1n

* CHECK dout0_5 Vdout0_5ck41 = 1.8 time = 840
.meas tran vdout0_5ck41 FIND v(dout0_5) AT=840.1n

* CHECK dout0_6 Vdout0_6ck41 = 0 time = 840
.meas tran vdout0_6ck41 FIND v(dout0_6) AT=840.1n

* CHECK dout0_7 Vdout0_7ck41 = 0 time = 840
.meas tran vdout0_7ck41 FIND v(dout0_7) AT=840.1n

* CHECK dout0_8 Vdout0_8ck41 = 1.8 time = 840
.meas tran vdout0_8ck41 FIND v(dout0_8) AT=840.1n

* CHECK dout0_9 Vdout0_9ck41 = 0 time = 840
.meas tran vdout0_9ck41 FIND v(dout0_9) AT=840.1n

* CHECK dout0_10 Vdout0_10ck41 = 1.8 time = 840
.meas tran vdout0_10ck41 FIND v(dout0_10) AT=840.1n

* CHECK dout0_11 Vdout0_11ck41 = 0 time = 840
.meas tran vdout0_11ck41 FIND v(dout0_11) AT=840.1n

* CHECK dout0_12 Vdout0_12ck41 = 1.8 time = 840
.meas tran vdout0_12ck41 FIND v(dout0_12) AT=840.1n

* CHECK dout0_13 Vdout0_13ck41 = 0 time = 840
.meas tran vdout0_13ck41 FIND v(dout0_13) AT=840.1n

* CHECK dout0_14 Vdout0_14ck41 = 1.8 time = 840
.meas tran vdout0_14ck41 FIND v(dout0_14) AT=840.1n

* CHECK dout0_15 Vdout0_15ck41 = 1.8 time = 840
.meas tran vdout0_15ck41 FIND v(dout0_15) AT=840.1n

* CHECK dout0_0 Vdout0_0ck42 = 1.8 time = 860
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=860.1n

* CHECK dout0_1 Vdout0_1ck42 = 1.8 time = 860
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=860.1n

* CHECK dout0_2 Vdout0_2ck42 = 0 time = 860
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=860.1n

* CHECK dout0_3 Vdout0_3ck42 = 0 time = 860
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=860.1n

* CHECK dout0_4 Vdout0_4ck42 = 0 time = 860
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=860.1n

* CHECK dout0_5 Vdout0_5ck42 = 1.8 time = 860
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=860.1n

* CHECK dout0_6 Vdout0_6ck42 = 0 time = 860
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=860.1n

* CHECK dout0_7 Vdout0_7ck42 = 0 time = 860
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=860.1n

* CHECK dout0_8 Vdout0_8ck42 = 1.8 time = 860
.meas tran vdout0_8ck42 FIND v(dout0_8) AT=860.1n

* CHECK dout0_9 Vdout0_9ck42 = 0 time = 860
.meas tran vdout0_9ck42 FIND v(dout0_9) AT=860.1n

* CHECK dout0_10 Vdout0_10ck42 = 1.8 time = 860
.meas tran vdout0_10ck42 FIND v(dout0_10) AT=860.1n

* CHECK dout0_11 Vdout0_11ck42 = 0 time = 860
.meas tran vdout0_11ck42 FIND v(dout0_11) AT=860.1n

* CHECK dout0_12 Vdout0_12ck42 = 1.8 time = 860
.meas tran vdout0_12ck42 FIND v(dout0_12) AT=860.1n

* CHECK dout0_13 Vdout0_13ck42 = 0 time = 860
.meas tran vdout0_13ck42 FIND v(dout0_13) AT=860.1n

* CHECK dout0_14 Vdout0_14ck42 = 1.8 time = 860
.meas tran vdout0_14ck42 FIND v(dout0_14) AT=860.1n

* CHECK dout0_15 Vdout0_15ck42 = 1.8 time = 860
.meas tran vdout0_15ck42 FIND v(dout0_15) AT=860.1n

* CHECK dout0_0 Vdout0_0ck43 = 0 time = 880
.meas tran vdout0_0ck43 FIND v(dout0_0) AT=880.1n

* CHECK dout0_1 Vdout0_1ck43 = 1.8 time = 880
.meas tran vdout0_1ck43 FIND v(dout0_1) AT=880.1n

* CHECK dout0_2 Vdout0_2ck43 = 0 time = 880
.meas tran vdout0_2ck43 FIND v(dout0_2) AT=880.1n

* CHECK dout0_3 Vdout0_3ck43 = 1.8 time = 880
.meas tran vdout0_3ck43 FIND v(dout0_3) AT=880.1n

* CHECK dout0_4 Vdout0_4ck43 = 0 time = 880
.meas tran vdout0_4ck43 FIND v(dout0_4) AT=880.1n

* CHECK dout0_5 Vdout0_5ck43 = 1.8 time = 880
.meas tran vdout0_5ck43 FIND v(dout0_5) AT=880.1n

* CHECK dout0_6 Vdout0_6ck43 = 0 time = 880
.meas tran vdout0_6ck43 FIND v(dout0_6) AT=880.1n

* CHECK dout0_7 Vdout0_7ck43 = 0 time = 880
.meas tran vdout0_7ck43 FIND v(dout0_7) AT=880.1n

* CHECK dout0_8 Vdout0_8ck43 = 0 time = 880
.meas tran vdout0_8ck43 FIND v(dout0_8) AT=880.1n

* CHECK dout0_9 Vdout0_9ck43 = 1.8 time = 880
.meas tran vdout0_9ck43 FIND v(dout0_9) AT=880.1n

* CHECK dout0_10 Vdout0_10ck43 = 0 time = 880
.meas tran vdout0_10ck43 FIND v(dout0_10) AT=880.1n

* CHECK dout0_11 Vdout0_11ck43 = 1.8 time = 880
.meas tran vdout0_11ck43 FIND v(dout0_11) AT=880.1n

* CHECK dout0_12 Vdout0_12ck43 = 1.8 time = 880
.meas tran vdout0_12ck43 FIND v(dout0_12) AT=880.1n

* CHECK dout0_13 Vdout0_13ck43 = 1.8 time = 880
.meas tran vdout0_13ck43 FIND v(dout0_13) AT=880.1n

* CHECK dout0_14 Vdout0_14ck43 = 0 time = 880
.meas tran vdout0_14ck43 FIND v(dout0_14) AT=880.1n

* CHECK dout0_15 Vdout0_15ck43 = 1.8 time = 880
.meas tran vdout0_15ck43 FIND v(dout0_15) AT=880.1n

* CHECK dout0_0 Vdout0_0ck45 = 1.8 time = 920
.meas tran vdout0_0ck45 FIND v(dout0_0) AT=920.1n

* CHECK dout0_1 Vdout0_1ck45 = 0 time = 920
.meas tran vdout0_1ck45 FIND v(dout0_1) AT=920.1n

* CHECK dout0_2 Vdout0_2ck45 = 1.8 time = 920
.meas tran vdout0_2ck45 FIND v(dout0_2) AT=920.1n

* CHECK dout0_3 Vdout0_3ck45 = 1.8 time = 920
.meas tran vdout0_3ck45 FIND v(dout0_3) AT=920.1n

* CHECK dout0_4 Vdout0_4ck45 = 1.8 time = 920
.meas tran vdout0_4ck45 FIND v(dout0_4) AT=920.1n

* CHECK dout0_5 Vdout0_5ck45 = 0 time = 920
.meas tran vdout0_5ck45 FIND v(dout0_5) AT=920.1n

* CHECK dout0_6 Vdout0_6ck45 = 0 time = 920
.meas tran vdout0_6ck45 FIND v(dout0_6) AT=920.1n

* CHECK dout0_7 Vdout0_7ck45 = 1.8 time = 920
.meas tran vdout0_7ck45 FIND v(dout0_7) AT=920.1n

* CHECK dout0_8 Vdout0_8ck45 = 1.8 time = 920
.meas tran vdout0_8ck45 FIND v(dout0_8) AT=920.1n

* CHECK dout0_9 Vdout0_9ck45 = 1.8 time = 920
.meas tran vdout0_9ck45 FIND v(dout0_9) AT=920.1n

* CHECK dout0_10 Vdout0_10ck45 = 1.8 time = 920
.meas tran vdout0_10ck45 FIND v(dout0_10) AT=920.1n

* CHECK dout0_11 Vdout0_11ck45 = 1.8 time = 920
.meas tran vdout0_11ck45 FIND v(dout0_11) AT=920.1n

* CHECK dout0_12 Vdout0_12ck45 = 0 time = 920
.meas tran vdout0_12ck45 FIND v(dout0_12) AT=920.1n

* CHECK dout0_13 Vdout0_13ck45 = 1.8 time = 920
.meas tran vdout0_13ck45 FIND v(dout0_13) AT=920.1n

* CHECK dout0_14 Vdout0_14ck45 = 1.8 time = 920
.meas tran vdout0_14ck45 FIND v(dout0_14) AT=920.1n

* CHECK dout0_15 Vdout0_15ck45 = 0 time = 920
.meas tran vdout0_15ck45 FIND v(dout0_15) AT=920.1n

* CHECK dout0_0 Vdout0_0ck47 = 1.8 time = 960
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=960.1n

* CHECK dout0_1 Vdout0_1ck47 = 0 time = 960
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=960.1n

* CHECK dout0_2 Vdout0_2ck47 = 1.8 time = 960
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=960.1n

* CHECK dout0_3 Vdout0_3ck47 = 1.8 time = 960
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=960.1n

* CHECK dout0_4 Vdout0_4ck47 = 1.8 time = 960
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=960.1n

* CHECK dout0_5 Vdout0_5ck47 = 0 time = 960
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=960.1n

* CHECK dout0_6 Vdout0_6ck47 = 0 time = 960
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=960.1n

* CHECK dout0_7 Vdout0_7ck47 = 1.8 time = 960
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=960.1n

* CHECK dout0_8 Vdout0_8ck47 = 1.8 time = 960
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=960.1n

* CHECK dout0_9 Vdout0_9ck47 = 1.8 time = 960
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=960.1n

* CHECK dout0_10 Vdout0_10ck47 = 1.8 time = 960
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=960.1n

* CHECK dout0_11 Vdout0_11ck47 = 1.8 time = 960
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=960.1n

* CHECK dout0_12 Vdout0_12ck47 = 0 time = 960
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=960.1n

* CHECK dout0_13 Vdout0_13ck47 = 1.8 time = 960
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=960.1n

* CHECK dout0_14 Vdout0_14ck47 = 1.8 time = 960
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=960.1n

* CHECK dout0_15 Vdout0_15ck47 = 0 time = 960
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=960.1n

* CHECK dout0_0 Vdout0_0ck51 = 1.8 time = 1040
.meas tran vdout0_0ck51 FIND v(dout0_0) AT=1040.1n

* CHECK dout0_1 Vdout0_1ck51 = 1.8 time = 1040
.meas tran vdout0_1ck51 FIND v(dout0_1) AT=1040.1n

* CHECK dout0_2 Vdout0_2ck51 = 1.8 time = 1040
.meas tran vdout0_2ck51 FIND v(dout0_2) AT=1040.1n

* CHECK dout0_3 Vdout0_3ck51 = 1.8 time = 1040
.meas tran vdout0_3ck51 FIND v(dout0_3) AT=1040.1n

* CHECK dout0_4 Vdout0_4ck51 = 0 time = 1040
.meas tran vdout0_4ck51 FIND v(dout0_4) AT=1040.1n

* CHECK dout0_5 Vdout0_5ck51 = 1.8 time = 1040
.meas tran vdout0_5ck51 FIND v(dout0_5) AT=1040.1n

* CHECK dout0_6 Vdout0_6ck51 = 0 time = 1040
.meas tran vdout0_6ck51 FIND v(dout0_6) AT=1040.1n

* CHECK dout0_7 Vdout0_7ck51 = 1.8 time = 1040
.meas tran vdout0_7ck51 FIND v(dout0_7) AT=1040.1n

* CHECK dout0_8 Vdout0_8ck51 = 1.8 time = 1040
.meas tran vdout0_8ck51 FIND v(dout0_8) AT=1040.1n

* CHECK dout0_9 Vdout0_9ck51 = 1.8 time = 1040
.meas tran vdout0_9ck51 FIND v(dout0_9) AT=1040.1n

* CHECK dout0_10 Vdout0_10ck51 = 1.8 time = 1040
.meas tran vdout0_10ck51 FIND v(dout0_10) AT=1040.1n

* CHECK dout0_11 Vdout0_11ck51 = 0 time = 1040
.meas tran vdout0_11ck51 FIND v(dout0_11) AT=1040.1n

* CHECK dout0_12 Vdout0_12ck51 = 1.8 time = 1040
.meas tran vdout0_12ck51 FIND v(dout0_12) AT=1040.1n

* CHECK dout0_13 Vdout0_13ck51 = 0 time = 1040
.meas tran vdout0_13ck51 FIND v(dout0_13) AT=1040.1n

* CHECK dout0_14 Vdout0_14ck51 = 0 time = 1040
.meas tran vdout0_14ck51 FIND v(dout0_14) AT=1040.1n

* CHECK dout0_15 Vdout0_15ck51 = 1.8 time = 1040
.meas tran vdout0_15ck51 FIND v(dout0_15) AT=1040.1n

* CHECK dout0_0 Vdout0_0ck52 = 1.8 time = 1060
.meas tran vdout0_0ck52 FIND v(dout0_0) AT=1060.1n

* CHECK dout0_1 Vdout0_1ck52 = 1.8 time = 1060
.meas tran vdout0_1ck52 FIND v(dout0_1) AT=1060.1n

* CHECK dout0_2 Vdout0_2ck52 = 1.8 time = 1060
.meas tran vdout0_2ck52 FIND v(dout0_2) AT=1060.1n

* CHECK dout0_3 Vdout0_3ck52 = 1.8 time = 1060
.meas tran vdout0_3ck52 FIND v(dout0_3) AT=1060.1n

* CHECK dout0_4 Vdout0_4ck52 = 1.8 time = 1060
.meas tran vdout0_4ck52 FIND v(dout0_4) AT=1060.1n

* CHECK dout0_5 Vdout0_5ck52 = 1.8 time = 1060
.meas tran vdout0_5ck52 FIND v(dout0_5) AT=1060.1n

* CHECK dout0_6 Vdout0_6ck52 = 1.8 time = 1060
.meas tran vdout0_6ck52 FIND v(dout0_6) AT=1060.1n

* CHECK dout0_7 Vdout0_7ck52 = 0 time = 1060
.meas tran vdout0_7ck52 FIND v(dout0_7) AT=1060.1n

* CHECK dout0_8 Vdout0_8ck52 = 0 time = 1060
.meas tran vdout0_8ck52 FIND v(dout0_8) AT=1060.1n

* CHECK dout0_9 Vdout0_9ck52 = 1.8 time = 1060
.meas tran vdout0_9ck52 FIND v(dout0_9) AT=1060.1n

* CHECK dout0_10 Vdout0_10ck52 = 1.8 time = 1060
.meas tran vdout0_10ck52 FIND v(dout0_10) AT=1060.1n

* CHECK dout0_11 Vdout0_11ck52 = 0 time = 1060
.meas tran vdout0_11ck52 FIND v(dout0_11) AT=1060.1n

* CHECK dout0_12 Vdout0_12ck52 = 1.8 time = 1060
.meas tran vdout0_12ck52 FIND v(dout0_12) AT=1060.1n

* CHECK dout0_13 Vdout0_13ck52 = 0 time = 1060
.meas tran vdout0_13ck52 FIND v(dout0_13) AT=1060.1n

* CHECK dout0_14 Vdout0_14ck52 = 0 time = 1060
.meas tran vdout0_14ck52 FIND v(dout0_14) AT=1060.1n

* CHECK dout0_15 Vdout0_15ck52 = 1.8 time = 1060
.meas tran vdout0_15ck52 FIND v(dout0_15) AT=1060.1n

* CHECK dout0_0 Vdout0_0ck53 = 0 time = 1080
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=1080.1n

* CHECK dout0_1 Vdout0_1ck53 = 1.8 time = 1080
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=1080.1n

* CHECK dout0_2 Vdout0_2ck53 = 1.8 time = 1080
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=1080.1n

* CHECK dout0_3 Vdout0_3ck53 = 1.8 time = 1080
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=1080.1n

* CHECK dout0_4 Vdout0_4ck53 = 1.8 time = 1080
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=1080.1n

* CHECK dout0_5 Vdout0_5ck53 = 0 time = 1080
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=1080.1n

* CHECK dout0_6 Vdout0_6ck53 = 0 time = 1080
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=1080.1n

* CHECK dout0_7 Vdout0_7ck53 = 1.8 time = 1080
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=1080.1n

* CHECK dout0_8 Vdout0_8ck53 = 0 time = 1080
.meas tran vdout0_8ck53 FIND v(dout0_8) AT=1080.1n

* CHECK dout0_9 Vdout0_9ck53 = 0 time = 1080
.meas tran vdout0_9ck53 FIND v(dout0_9) AT=1080.1n

* CHECK dout0_10 Vdout0_10ck53 = 0 time = 1080
.meas tran vdout0_10ck53 FIND v(dout0_10) AT=1080.1n

* CHECK dout0_11 Vdout0_11ck53 = 0 time = 1080
.meas tran vdout0_11ck53 FIND v(dout0_11) AT=1080.1n

* CHECK dout0_12 Vdout0_12ck53 = 1.8 time = 1080
.meas tran vdout0_12ck53 FIND v(dout0_12) AT=1080.1n

* CHECK dout0_13 Vdout0_13ck53 = 1.8 time = 1080
.meas tran vdout0_13ck53 FIND v(dout0_13) AT=1080.1n

* CHECK dout0_14 Vdout0_14ck53 = 1.8 time = 1080
.meas tran vdout0_14ck53 FIND v(dout0_14) AT=1080.1n

* CHECK dout0_15 Vdout0_15ck53 = 0 time = 1080
.meas tran vdout0_15ck53 FIND v(dout0_15) AT=1080.1n

* CHECK dout0_0 Vdout0_0ck56 = 1.8 time = 1140
.meas tran vdout0_0ck56 FIND v(dout0_0) AT=1140.1n

* CHECK dout0_1 Vdout0_1ck56 = 1.8 time = 1140
.meas tran vdout0_1ck56 FIND v(dout0_1) AT=1140.1n

* CHECK dout0_2 Vdout0_2ck56 = 1.8 time = 1140
.meas tran vdout0_2ck56 FIND v(dout0_2) AT=1140.1n

* CHECK dout0_3 Vdout0_3ck56 = 1.8 time = 1140
.meas tran vdout0_3ck56 FIND v(dout0_3) AT=1140.1n

* CHECK dout0_4 Vdout0_4ck56 = 1.8 time = 1140
.meas tran vdout0_4ck56 FIND v(dout0_4) AT=1140.1n

* CHECK dout0_5 Vdout0_5ck56 = 1.8 time = 1140
.meas tran vdout0_5ck56 FIND v(dout0_5) AT=1140.1n

* CHECK dout0_6 Vdout0_6ck56 = 1.8 time = 1140
.meas tran vdout0_6ck56 FIND v(dout0_6) AT=1140.1n

* CHECK dout0_7 Vdout0_7ck56 = 0 time = 1140
.meas tran vdout0_7ck56 FIND v(dout0_7) AT=1140.1n

* CHECK dout0_8 Vdout0_8ck56 = 0 time = 1140
.meas tran vdout0_8ck56 FIND v(dout0_8) AT=1140.1n

* CHECK dout0_9 Vdout0_9ck56 = 1.8 time = 1140
.meas tran vdout0_9ck56 FIND v(dout0_9) AT=1140.1n

* CHECK dout0_10 Vdout0_10ck56 = 1.8 time = 1140
.meas tran vdout0_10ck56 FIND v(dout0_10) AT=1140.1n

* CHECK dout0_11 Vdout0_11ck56 = 0 time = 1140
.meas tran vdout0_11ck56 FIND v(dout0_11) AT=1140.1n

* CHECK dout0_12 Vdout0_12ck56 = 1.8 time = 1140
.meas tran vdout0_12ck56 FIND v(dout0_12) AT=1140.1n

* CHECK dout0_13 Vdout0_13ck56 = 0 time = 1140
.meas tran vdout0_13ck56 FIND v(dout0_13) AT=1140.1n

* CHECK dout0_14 Vdout0_14ck56 = 0 time = 1140
.meas tran vdout0_14ck56 FIND v(dout0_14) AT=1140.1n

* CHECK dout0_15 Vdout0_15ck56 = 1.8 time = 1140
.meas tran vdout0_15ck56 FIND v(dout0_15) AT=1140.1n

* CHECK dout0_0 Vdout0_0ck57 = 1.8 time = 1160
.meas tran vdout0_0ck57 FIND v(dout0_0) AT=1160.1n

* CHECK dout0_1 Vdout0_1ck57 = 0 time = 1160
.meas tran vdout0_1ck57 FIND v(dout0_1) AT=1160.1n

* CHECK dout0_2 Vdout0_2ck57 = 0 time = 1160
.meas tran vdout0_2ck57 FIND v(dout0_2) AT=1160.1n

* CHECK dout0_3 Vdout0_3ck57 = 0 time = 1160
.meas tran vdout0_3ck57 FIND v(dout0_3) AT=1160.1n

* CHECK dout0_4 Vdout0_4ck57 = 0 time = 1160
.meas tran vdout0_4ck57 FIND v(dout0_4) AT=1160.1n

* CHECK dout0_5 Vdout0_5ck57 = 1.8 time = 1160
.meas tran vdout0_5ck57 FIND v(dout0_5) AT=1160.1n

* CHECK dout0_6 Vdout0_6ck57 = 0 time = 1160
.meas tran vdout0_6ck57 FIND v(dout0_6) AT=1160.1n

* CHECK dout0_7 Vdout0_7ck57 = 0 time = 1160
.meas tran vdout0_7ck57 FIND v(dout0_7) AT=1160.1n

* CHECK dout0_8 Vdout0_8ck57 = 1.8 time = 1160
.meas tran vdout0_8ck57 FIND v(dout0_8) AT=1160.1n

* CHECK dout0_9 Vdout0_9ck57 = 1.8 time = 1160
.meas tran vdout0_9ck57 FIND v(dout0_9) AT=1160.1n

* CHECK dout0_10 Vdout0_10ck57 = 1.8 time = 1160
.meas tran vdout0_10ck57 FIND v(dout0_10) AT=1160.1n

* CHECK dout0_11 Vdout0_11ck57 = 1.8 time = 1160
.meas tran vdout0_11ck57 FIND v(dout0_11) AT=1160.1n

* CHECK dout0_12 Vdout0_12ck57 = 1.8 time = 1160
.meas tran vdout0_12ck57 FIND v(dout0_12) AT=1160.1n

* CHECK dout0_13 Vdout0_13ck57 = 0 time = 1160
.meas tran vdout0_13ck57 FIND v(dout0_13) AT=1160.1n

* CHECK dout0_14 Vdout0_14ck57 = 0 time = 1160
.meas tran vdout0_14ck57 FIND v(dout0_14) AT=1160.1n

* CHECK dout0_15 Vdout0_15ck57 = 0 time = 1160
.meas tran vdout0_15ck57 FIND v(dout0_15) AT=1160.1n

* CHECK dout0_0 Vdout0_0ck58 = 1.8 time = 1180
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=1180.1n

* CHECK dout0_1 Vdout0_1ck58 = 1.8 time = 1180
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=1180.1n

* CHECK dout0_2 Vdout0_2ck58 = 1.8 time = 1180
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=1180.1n

* CHECK dout0_3 Vdout0_3ck58 = 1.8 time = 1180
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=1180.1n

* CHECK dout0_4 Vdout0_4ck58 = 1.8 time = 1180
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=1180.1n

* CHECK dout0_5 Vdout0_5ck58 = 1.8 time = 1180
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=1180.1n

* CHECK dout0_6 Vdout0_6ck58 = 1.8 time = 1180
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=1180.1n

* CHECK dout0_7 Vdout0_7ck58 = 0 time = 1180
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=1180.1n

* CHECK dout0_8 Vdout0_8ck58 = 0 time = 1180
.meas tran vdout0_8ck58 FIND v(dout0_8) AT=1180.1n

* CHECK dout0_9 Vdout0_9ck58 = 1.8 time = 1180
.meas tran vdout0_9ck58 FIND v(dout0_9) AT=1180.1n

* CHECK dout0_10 Vdout0_10ck58 = 1.8 time = 1180
.meas tran vdout0_10ck58 FIND v(dout0_10) AT=1180.1n

* CHECK dout0_11 Vdout0_11ck58 = 0 time = 1180
.meas tran vdout0_11ck58 FIND v(dout0_11) AT=1180.1n

* CHECK dout0_12 Vdout0_12ck58 = 1.8 time = 1180
.meas tran vdout0_12ck58 FIND v(dout0_12) AT=1180.1n

* CHECK dout0_13 Vdout0_13ck58 = 0 time = 1180
.meas tran vdout0_13ck58 FIND v(dout0_13) AT=1180.1n

* CHECK dout0_14 Vdout0_14ck58 = 0 time = 1180
.meas tran vdout0_14ck58 FIND v(dout0_14) AT=1180.1n

* CHECK dout0_15 Vdout0_15ck58 = 1.8 time = 1180
.meas tran vdout0_15ck58 FIND v(dout0_15) AT=1180.1n

* CHECK dout0_0 Vdout0_0ck60 = 1.8 time = 1220
.meas tran vdout0_0ck60 FIND v(dout0_0) AT=1220.1n

* CHECK dout0_1 Vdout0_1ck60 = 1.8 time = 1220
.meas tran vdout0_1ck60 FIND v(dout0_1) AT=1220.1n

* CHECK dout0_2 Vdout0_2ck60 = 1.8 time = 1220
.meas tran vdout0_2ck60 FIND v(dout0_2) AT=1220.1n

* CHECK dout0_3 Vdout0_3ck60 = 0 time = 1220
.meas tran vdout0_3ck60 FIND v(dout0_3) AT=1220.1n

* CHECK dout0_4 Vdout0_4ck60 = 0 time = 1220
.meas tran vdout0_4ck60 FIND v(dout0_4) AT=1220.1n

* CHECK dout0_5 Vdout0_5ck60 = 1.8 time = 1220
.meas tran vdout0_5ck60 FIND v(dout0_5) AT=1220.1n

* CHECK dout0_6 Vdout0_6ck60 = 0 time = 1220
.meas tran vdout0_6ck60 FIND v(dout0_6) AT=1220.1n

* CHECK dout0_7 Vdout0_7ck60 = 0 time = 1220
.meas tran vdout0_7ck60 FIND v(dout0_7) AT=1220.1n

* CHECK dout0_8 Vdout0_8ck60 = 0 time = 1220
.meas tran vdout0_8ck60 FIND v(dout0_8) AT=1220.1n

* CHECK dout0_9 Vdout0_9ck60 = 0 time = 1220
.meas tran vdout0_9ck60 FIND v(dout0_9) AT=1220.1n

* CHECK dout0_10 Vdout0_10ck60 = 1.8 time = 1220
.meas tran vdout0_10ck60 FIND v(dout0_10) AT=1220.1n

* CHECK dout0_11 Vdout0_11ck60 = 0 time = 1220
.meas tran vdout0_11ck60 FIND v(dout0_11) AT=1220.1n

* CHECK dout0_12 Vdout0_12ck60 = 0 time = 1220
.meas tran vdout0_12ck60 FIND v(dout0_12) AT=1220.1n

* CHECK dout0_13 Vdout0_13ck60 = 1.8 time = 1220
.meas tran vdout0_13ck60 FIND v(dout0_13) AT=1220.1n

* CHECK dout0_14 Vdout0_14ck60 = 1.8 time = 1220
.meas tran vdout0_14ck60 FIND v(dout0_14) AT=1220.1n

* CHECK dout0_15 Vdout0_15ck60 = 1.8 time = 1220
.meas tran vdout0_15ck60 FIND v(dout0_15) AT=1220.1n

* CHECK dout0_0 Vdout0_0ck65 = 1.8 time = 1320
.meas tran vdout0_0ck65 FIND v(dout0_0) AT=1320.1n

* CHECK dout0_1 Vdout0_1ck65 = 1.8 time = 1320
.meas tran vdout0_1ck65 FIND v(dout0_1) AT=1320.1n

* CHECK dout0_2 Vdout0_2ck65 = 1.8 time = 1320
.meas tran vdout0_2ck65 FIND v(dout0_2) AT=1320.1n

* CHECK dout0_3 Vdout0_3ck65 = 0 time = 1320
.meas tran vdout0_3ck65 FIND v(dout0_3) AT=1320.1n

* CHECK dout0_4 Vdout0_4ck65 = 0 time = 1320
.meas tran vdout0_4ck65 FIND v(dout0_4) AT=1320.1n

* CHECK dout0_5 Vdout0_5ck65 = 1.8 time = 1320
.meas tran vdout0_5ck65 FIND v(dout0_5) AT=1320.1n

* CHECK dout0_6 Vdout0_6ck65 = 0 time = 1320
.meas tran vdout0_6ck65 FIND v(dout0_6) AT=1320.1n

* CHECK dout0_7 Vdout0_7ck65 = 0 time = 1320
.meas tran vdout0_7ck65 FIND v(dout0_7) AT=1320.1n

* CHECK dout0_8 Vdout0_8ck65 = 0 time = 1320
.meas tran vdout0_8ck65 FIND v(dout0_8) AT=1320.1n

* CHECK dout0_9 Vdout0_9ck65 = 0 time = 1320
.meas tran vdout0_9ck65 FIND v(dout0_9) AT=1320.1n

* CHECK dout0_10 Vdout0_10ck65 = 1.8 time = 1320
.meas tran vdout0_10ck65 FIND v(dout0_10) AT=1320.1n

* CHECK dout0_11 Vdout0_11ck65 = 0 time = 1320
.meas tran vdout0_11ck65 FIND v(dout0_11) AT=1320.1n

* CHECK dout0_12 Vdout0_12ck65 = 0 time = 1320
.meas tran vdout0_12ck65 FIND v(dout0_12) AT=1320.1n

* CHECK dout0_13 Vdout0_13ck65 = 1.8 time = 1320
.meas tran vdout0_13ck65 FIND v(dout0_13) AT=1320.1n

* CHECK dout0_14 Vdout0_14ck65 = 1.8 time = 1320
.meas tran vdout0_14ck65 FIND v(dout0_14) AT=1320.1n

* CHECK dout0_15 Vdout0_15ck65 = 1.8 time = 1320
.meas tran vdout0_15ck65 FIND v(dout0_15) AT=1320.1n

* CHECK dout0_0 Vdout0_0ck67 = 0 time = 1360
.meas tran vdout0_0ck67 FIND v(dout0_0) AT=1360.1n

* CHECK dout0_1 Vdout0_1ck67 = 1.8 time = 1360
.meas tran vdout0_1ck67 FIND v(dout0_1) AT=1360.1n

* CHECK dout0_2 Vdout0_2ck67 = 0 time = 1360
.meas tran vdout0_2ck67 FIND v(dout0_2) AT=1360.1n

* CHECK dout0_3 Vdout0_3ck67 = 1.8 time = 1360
.meas tran vdout0_3ck67 FIND v(dout0_3) AT=1360.1n

* CHECK dout0_4 Vdout0_4ck67 = 0 time = 1360
.meas tran vdout0_4ck67 FIND v(dout0_4) AT=1360.1n

* CHECK dout0_5 Vdout0_5ck67 = 0 time = 1360
.meas tran vdout0_5ck67 FIND v(dout0_5) AT=1360.1n

* CHECK dout0_6 Vdout0_6ck67 = 0 time = 1360
.meas tran vdout0_6ck67 FIND v(dout0_6) AT=1360.1n

* CHECK dout0_7 Vdout0_7ck67 = 1.8 time = 1360
.meas tran vdout0_7ck67 FIND v(dout0_7) AT=1360.1n

* CHECK dout0_8 Vdout0_8ck67 = 1.8 time = 1360
.meas tran vdout0_8ck67 FIND v(dout0_8) AT=1360.1n

* CHECK dout0_9 Vdout0_9ck67 = 1.8 time = 1360
.meas tran vdout0_9ck67 FIND v(dout0_9) AT=1360.1n

* CHECK dout0_10 Vdout0_10ck67 = 1.8 time = 1360
.meas tran vdout0_10ck67 FIND v(dout0_10) AT=1360.1n

* CHECK dout0_11 Vdout0_11ck67 = 0 time = 1360
.meas tran vdout0_11ck67 FIND v(dout0_11) AT=1360.1n

* CHECK dout0_12 Vdout0_12ck67 = 1.8 time = 1360
.meas tran vdout0_12ck67 FIND v(dout0_12) AT=1360.1n

* CHECK dout0_13 Vdout0_13ck67 = 1.8 time = 1360
.meas tran vdout0_13ck67 FIND v(dout0_13) AT=1360.1n

* CHECK dout0_14 Vdout0_14ck67 = 0 time = 1360
.meas tran vdout0_14ck67 FIND v(dout0_14) AT=1360.1n

* CHECK dout0_15 Vdout0_15ck67 = 0 time = 1360
.meas tran vdout0_15ck67 FIND v(dout0_15) AT=1360.1n

* CHECK dout0_0 Vdout0_0ck68 = 0 time = 1380
.meas tran vdout0_0ck68 FIND v(dout0_0) AT=1380.1n

* CHECK dout0_1 Vdout0_1ck68 = 0 time = 1380
.meas tran vdout0_1ck68 FIND v(dout0_1) AT=1380.1n

* CHECK dout0_2 Vdout0_2ck68 = 1.8 time = 1380
.meas tran vdout0_2ck68 FIND v(dout0_2) AT=1380.1n

* CHECK dout0_3 Vdout0_3ck68 = 1.8 time = 1380
.meas tran vdout0_3ck68 FIND v(dout0_3) AT=1380.1n

* CHECK dout0_4 Vdout0_4ck68 = 0 time = 1380
.meas tran vdout0_4ck68 FIND v(dout0_4) AT=1380.1n

* CHECK dout0_5 Vdout0_5ck68 = 0 time = 1380
.meas tran vdout0_5ck68 FIND v(dout0_5) AT=1380.1n

* CHECK dout0_6 Vdout0_6ck68 = 0 time = 1380
.meas tran vdout0_6ck68 FIND v(dout0_6) AT=1380.1n

* CHECK dout0_7 Vdout0_7ck68 = 1.8 time = 1380
.meas tran vdout0_7ck68 FIND v(dout0_7) AT=1380.1n

* CHECK dout0_8 Vdout0_8ck68 = 0 time = 1380
.meas tran vdout0_8ck68 FIND v(dout0_8) AT=1380.1n

* CHECK dout0_9 Vdout0_9ck68 = 0 time = 1380
.meas tran vdout0_9ck68 FIND v(dout0_9) AT=1380.1n

* CHECK dout0_10 Vdout0_10ck68 = 0 time = 1380
.meas tran vdout0_10ck68 FIND v(dout0_10) AT=1380.1n

* CHECK dout0_11 Vdout0_11ck68 = 0 time = 1380
.meas tran vdout0_11ck68 FIND v(dout0_11) AT=1380.1n

* CHECK dout0_12 Vdout0_12ck68 = 0 time = 1380
.meas tran vdout0_12ck68 FIND v(dout0_12) AT=1380.1n

* CHECK dout0_13 Vdout0_13ck68 = 0 time = 1380
.meas tran vdout0_13ck68 FIND v(dout0_13) AT=1380.1n

* CHECK dout0_14 Vdout0_14ck68 = 1.8 time = 1380
.meas tran vdout0_14ck68 FIND v(dout0_14) AT=1380.1n

* CHECK dout0_15 Vdout0_15ck68 = 0 time = 1380
.meas tran vdout0_15ck68 FIND v(dout0_15) AT=1380.1n

* CHECK dout0_0 Vdout0_0ck69 = 1.8 time = 1400
.meas tran vdout0_0ck69 FIND v(dout0_0) AT=1400.1n

* CHECK dout0_1 Vdout0_1ck69 = 0 time = 1400
.meas tran vdout0_1ck69 FIND v(dout0_1) AT=1400.1n

* CHECK dout0_2 Vdout0_2ck69 = 0 time = 1400
.meas tran vdout0_2ck69 FIND v(dout0_2) AT=1400.1n

* CHECK dout0_3 Vdout0_3ck69 = 0 time = 1400
.meas tran vdout0_3ck69 FIND v(dout0_3) AT=1400.1n

* CHECK dout0_4 Vdout0_4ck69 = 1.8 time = 1400
.meas tran vdout0_4ck69 FIND v(dout0_4) AT=1400.1n

* CHECK dout0_5 Vdout0_5ck69 = 0 time = 1400
.meas tran vdout0_5ck69 FIND v(dout0_5) AT=1400.1n

* CHECK dout0_6 Vdout0_6ck69 = 1.8 time = 1400
.meas tran vdout0_6ck69 FIND v(dout0_6) AT=1400.1n

* CHECK dout0_7 Vdout0_7ck69 = 0 time = 1400
.meas tran vdout0_7ck69 FIND v(dout0_7) AT=1400.1n

* CHECK dout0_8 Vdout0_8ck69 = 0 time = 1400
.meas tran vdout0_8ck69 FIND v(dout0_8) AT=1400.1n

* CHECK dout0_9 Vdout0_9ck69 = 1.8 time = 1400
.meas tran vdout0_9ck69 FIND v(dout0_9) AT=1400.1n

* CHECK dout0_10 Vdout0_10ck69 = 0 time = 1400
.meas tran vdout0_10ck69 FIND v(dout0_10) AT=1400.1n

* CHECK dout0_11 Vdout0_11ck69 = 0 time = 1400
.meas tran vdout0_11ck69 FIND v(dout0_11) AT=1400.1n

* CHECK dout0_12 Vdout0_12ck69 = 1.8 time = 1400
.meas tran vdout0_12ck69 FIND v(dout0_12) AT=1400.1n

* CHECK dout0_13 Vdout0_13ck69 = 1.8 time = 1400
.meas tran vdout0_13ck69 FIND v(dout0_13) AT=1400.1n

* CHECK dout0_14 Vdout0_14ck69 = 0 time = 1400
.meas tran vdout0_14ck69 FIND v(dout0_14) AT=1400.1n

* CHECK dout0_15 Vdout0_15ck69 = 1.8 time = 1400
.meas tran vdout0_15ck69 FIND v(dout0_15) AT=1400.1n

* CHECK dout0_0 Vdout0_0ck72 = 0 time = 1460
.meas tran vdout0_0ck72 FIND v(dout0_0) AT=1460.1n

* CHECK dout0_1 Vdout0_1ck72 = 1.8 time = 1460
.meas tran vdout0_1ck72 FIND v(dout0_1) AT=1460.1n

* CHECK dout0_2 Vdout0_2ck72 = 1.8 time = 1460
.meas tran vdout0_2ck72 FIND v(dout0_2) AT=1460.1n

* CHECK dout0_3 Vdout0_3ck72 = 1.8 time = 1460
.meas tran vdout0_3ck72 FIND v(dout0_3) AT=1460.1n

* CHECK dout0_4 Vdout0_4ck72 = 1.8 time = 1460
.meas tran vdout0_4ck72 FIND v(dout0_4) AT=1460.1n

* CHECK dout0_5 Vdout0_5ck72 = 0 time = 1460
.meas tran vdout0_5ck72 FIND v(dout0_5) AT=1460.1n

* CHECK dout0_6 Vdout0_6ck72 = 0 time = 1460
.meas tran vdout0_6ck72 FIND v(dout0_6) AT=1460.1n

* CHECK dout0_7 Vdout0_7ck72 = 1.8 time = 1460
.meas tran vdout0_7ck72 FIND v(dout0_7) AT=1460.1n

* CHECK dout0_8 Vdout0_8ck72 = 0 time = 1460
.meas tran vdout0_8ck72 FIND v(dout0_8) AT=1460.1n

* CHECK dout0_9 Vdout0_9ck72 = 0 time = 1460
.meas tran vdout0_9ck72 FIND v(dout0_9) AT=1460.1n

* CHECK dout0_10 Vdout0_10ck72 = 0 time = 1460
.meas tran vdout0_10ck72 FIND v(dout0_10) AT=1460.1n

* CHECK dout0_11 Vdout0_11ck72 = 0 time = 1460
.meas tran vdout0_11ck72 FIND v(dout0_11) AT=1460.1n

* CHECK dout0_12 Vdout0_12ck72 = 1.8 time = 1460
.meas tran vdout0_12ck72 FIND v(dout0_12) AT=1460.1n

* CHECK dout0_13 Vdout0_13ck72 = 1.8 time = 1460
.meas tran vdout0_13ck72 FIND v(dout0_13) AT=1460.1n

* CHECK dout0_14 Vdout0_14ck72 = 1.8 time = 1460
.meas tran vdout0_14ck72 FIND v(dout0_14) AT=1460.1n

* CHECK dout0_15 Vdout0_15ck72 = 0 time = 1460
.meas tran vdout0_15ck72 FIND v(dout0_15) AT=1460.1n

* CHECK dout0_0 Vdout0_0ck73 = 0 time = 1480
.meas tran vdout0_0ck73 FIND v(dout0_0) AT=1480.1n

* CHECK dout0_1 Vdout0_1ck73 = 1.8 time = 1480
.meas tran vdout0_1ck73 FIND v(dout0_1) AT=1480.1n

* CHECK dout0_2 Vdout0_2ck73 = 1.8 time = 1480
.meas tran vdout0_2ck73 FIND v(dout0_2) AT=1480.1n

* CHECK dout0_3 Vdout0_3ck73 = 1.8 time = 1480
.meas tran vdout0_3ck73 FIND v(dout0_3) AT=1480.1n

* CHECK dout0_4 Vdout0_4ck73 = 1.8 time = 1480
.meas tran vdout0_4ck73 FIND v(dout0_4) AT=1480.1n

* CHECK dout0_5 Vdout0_5ck73 = 0 time = 1480
.meas tran vdout0_5ck73 FIND v(dout0_5) AT=1480.1n

* CHECK dout0_6 Vdout0_6ck73 = 0 time = 1480
.meas tran vdout0_6ck73 FIND v(dout0_6) AT=1480.1n

* CHECK dout0_7 Vdout0_7ck73 = 1.8 time = 1480
.meas tran vdout0_7ck73 FIND v(dout0_7) AT=1480.1n

* CHECK dout0_8 Vdout0_8ck73 = 0 time = 1480
.meas tran vdout0_8ck73 FIND v(dout0_8) AT=1480.1n

* CHECK dout0_9 Vdout0_9ck73 = 0 time = 1480
.meas tran vdout0_9ck73 FIND v(dout0_9) AT=1480.1n

* CHECK dout0_10 Vdout0_10ck73 = 0 time = 1480
.meas tran vdout0_10ck73 FIND v(dout0_10) AT=1480.1n

* CHECK dout0_11 Vdout0_11ck73 = 0 time = 1480
.meas tran vdout0_11ck73 FIND v(dout0_11) AT=1480.1n

* CHECK dout0_12 Vdout0_12ck73 = 1.8 time = 1480
.meas tran vdout0_12ck73 FIND v(dout0_12) AT=1480.1n

* CHECK dout0_13 Vdout0_13ck73 = 1.8 time = 1480
.meas tran vdout0_13ck73 FIND v(dout0_13) AT=1480.1n

* CHECK dout0_14 Vdout0_14ck73 = 1.8 time = 1480
.meas tran vdout0_14ck73 FIND v(dout0_14) AT=1480.1n

* CHECK dout0_15 Vdout0_15ck73 = 0 time = 1480
.meas tran vdout0_15ck73 FIND v(dout0_15) AT=1480.1n

* CHECK dout0_0 Vdout0_0ck74 = 0 time = 1500
.meas tran vdout0_0ck74 FIND v(dout0_0) AT=1500.1n

* CHECK dout0_1 Vdout0_1ck74 = 0 time = 1500
.meas tran vdout0_1ck74 FIND v(dout0_1) AT=1500.1n

* CHECK dout0_2 Vdout0_2ck74 = 1.8 time = 1500
.meas tran vdout0_2ck74 FIND v(dout0_2) AT=1500.1n

* CHECK dout0_3 Vdout0_3ck74 = 1.8 time = 1500
.meas tran vdout0_3ck74 FIND v(dout0_3) AT=1500.1n

* CHECK dout0_4 Vdout0_4ck74 = 0 time = 1500
.meas tran vdout0_4ck74 FIND v(dout0_4) AT=1500.1n

* CHECK dout0_5 Vdout0_5ck74 = 0 time = 1500
.meas tran vdout0_5ck74 FIND v(dout0_5) AT=1500.1n

* CHECK dout0_6 Vdout0_6ck74 = 0 time = 1500
.meas tran vdout0_6ck74 FIND v(dout0_6) AT=1500.1n

* CHECK dout0_7 Vdout0_7ck74 = 1.8 time = 1500
.meas tran vdout0_7ck74 FIND v(dout0_7) AT=1500.1n

* CHECK dout0_8 Vdout0_8ck74 = 0 time = 1500
.meas tran vdout0_8ck74 FIND v(dout0_8) AT=1500.1n

* CHECK dout0_9 Vdout0_9ck74 = 0 time = 1500
.meas tran vdout0_9ck74 FIND v(dout0_9) AT=1500.1n

* CHECK dout0_10 Vdout0_10ck74 = 0 time = 1500
.meas tran vdout0_10ck74 FIND v(dout0_10) AT=1500.1n

* CHECK dout0_11 Vdout0_11ck74 = 0 time = 1500
.meas tran vdout0_11ck74 FIND v(dout0_11) AT=1500.1n

* CHECK dout0_12 Vdout0_12ck74 = 0 time = 1500
.meas tran vdout0_12ck74 FIND v(dout0_12) AT=1500.1n

* CHECK dout0_13 Vdout0_13ck74 = 0 time = 1500
.meas tran vdout0_13ck74 FIND v(dout0_13) AT=1500.1n

* CHECK dout0_14 Vdout0_14ck74 = 1.8 time = 1500
.meas tran vdout0_14ck74 FIND v(dout0_14) AT=1500.1n

* CHECK dout0_15 Vdout0_15ck74 = 0 time = 1500
.meas tran vdout0_15ck74 FIND v(dout0_15) AT=1500.1n

* CHECK dout0_0 Vdout0_0ck75 = 1.8 time = 1520
.meas tran vdout0_0ck75 FIND v(dout0_0) AT=1520.1n

* CHECK dout0_1 Vdout0_1ck75 = 1.8 time = 1520
.meas tran vdout0_1ck75 FIND v(dout0_1) AT=1520.1n

* CHECK dout0_2 Vdout0_2ck75 = 1.8 time = 1520
.meas tran vdout0_2ck75 FIND v(dout0_2) AT=1520.1n

* CHECK dout0_3 Vdout0_3ck75 = 1.8 time = 1520
.meas tran vdout0_3ck75 FIND v(dout0_3) AT=1520.1n

* CHECK dout0_4 Vdout0_4ck75 = 0 time = 1520
.meas tran vdout0_4ck75 FIND v(dout0_4) AT=1520.1n

* CHECK dout0_5 Vdout0_5ck75 = 1.8 time = 1520
.meas tran vdout0_5ck75 FIND v(dout0_5) AT=1520.1n

* CHECK dout0_6 Vdout0_6ck75 = 0 time = 1520
.meas tran vdout0_6ck75 FIND v(dout0_6) AT=1520.1n

* CHECK dout0_7 Vdout0_7ck75 = 1.8 time = 1520
.meas tran vdout0_7ck75 FIND v(dout0_7) AT=1520.1n

* CHECK dout0_8 Vdout0_8ck75 = 1.8 time = 1520
.meas tran vdout0_8ck75 FIND v(dout0_8) AT=1520.1n

* CHECK dout0_9 Vdout0_9ck75 = 1.8 time = 1520
.meas tran vdout0_9ck75 FIND v(dout0_9) AT=1520.1n

* CHECK dout0_10 Vdout0_10ck75 = 1.8 time = 1520
.meas tran vdout0_10ck75 FIND v(dout0_10) AT=1520.1n

* CHECK dout0_11 Vdout0_11ck75 = 0 time = 1520
.meas tran vdout0_11ck75 FIND v(dout0_11) AT=1520.1n

* CHECK dout0_12 Vdout0_12ck75 = 1.8 time = 1520
.meas tran vdout0_12ck75 FIND v(dout0_12) AT=1520.1n

* CHECK dout0_13 Vdout0_13ck75 = 0 time = 1520
.meas tran vdout0_13ck75 FIND v(dout0_13) AT=1520.1n

* CHECK dout0_14 Vdout0_14ck75 = 0 time = 1520
.meas tran vdout0_14ck75 FIND v(dout0_14) AT=1520.1n

* CHECK dout0_15 Vdout0_15ck75 = 1.8 time = 1520
.meas tran vdout0_15ck75 FIND v(dout0_15) AT=1520.1n

* CHECK dout0_0 Vdout0_0ck76 = 1.8 time = 1540
.meas tran vdout0_0ck76 FIND v(dout0_0) AT=1540.1n

* CHECK dout0_1 Vdout0_1ck76 = 1.8 time = 1540
.meas tran vdout0_1ck76 FIND v(dout0_1) AT=1540.1n

* CHECK dout0_2 Vdout0_2ck76 = 1.8 time = 1540
.meas tran vdout0_2ck76 FIND v(dout0_2) AT=1540.1n

* CHECK dout0_3 Vdout0_3ck76 = 1.8 time = 1540
.meas tran vdout0_3ck76 FIND v(dout0_3) AT=1540.1n

* CHECK dout0_4 Vdout0_4ck76 = 1.8 time = 1540
.meas tran vdout0_4ck76 FIND v(dout0_4) AT=1540.1n

* CHECK dout0_5 Vdout0_5ck76 = 1.8 time = 1540
.meas tran vdout0_5ck76 FIND v(dout0_5) AT=1540.1n

* CHECK dout0_6 Vdout0_6ck76 = 1.8 time = 1540
.meas tran vdout0_6ck76 FIND v(dout0_6) AT=1540.1n

* CHECK dout0_7 Vdout0_7ck76 = 0 time = 1540
.meas tran vdout0_7ck76 FIND v(dout0_7) AT=1540.1n

* CHECK dout0_8 Vdout0_8ck76 = 0 time = 1540
.meas tran vdout0_8ck76 FIND v(dout0_8) AT=1540.1n

* CHECK dout0_9 Vdout0_9ck76 = 1.8 time = 1540
.meas tran vdout0_9ck76 FIND v(dout0_9) AT=1540.1n

* CHECK dout0_10 Vdout0_10ck76 = 1.8 time = 1540
.meas tran vdout0_10ck76 FIND v(dout0_10) AT=1540.1n

* CHECK dout0_11 Vdout0_11ck76 = 0 time = 1540
.meas tran vdout0_11ck76 FIND v(dout0_11) AT=1540.1n

* CHECK dout0_12 Vdout0_12ck76 = 1.8 time = 1540
.meas tran vdout0_12ck76 FIND v(dout0_12) AT=1540.1n

* CHECK dout0_13 Vdout0_13ck76 = 0 time = 1540
.meas tran vdout0_13ck76 FIND v(dout0_13) AT=1540.1n

* CHECK dout0_14 Vdout0_14ck76 = 0 time = 1540
.meas tran vdout0_14ck76 FIND v(dout0_14) AT=1540.1n

* CHECK dout0_15 Vdout0_15ck76 = 1.8 time = 1540
.meas tran vdout0_15ck76 FIND v(dout0_15) AT=1540.1n

* CHECK dout0_0 Vdout0_0ck79 = 0 time = 1600
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=1600.1n

* CHECK dout0_1 Vdout0_1ck79 = 1.8 time = 1600
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=1600.1n

* CHECK dout0_2 Vdout0_2ck79 = 1.8 time = 1600
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=1600.1n

* CHECK dout0_3 Vdout0_3ck79 = 1.8 time = 1600
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=1600.1n

* CHECK dout0_4 Vdout0_4ck79 = 1.8 time = 1600
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=1600.1n

* CHECK dout0_5 Vdout0_5ck79 = 0 time = 1600
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=1600.1n

* CHECK dout0_6 Vdout0_6ck79 = 0 time = 1600
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=1600.1n

* CHECK dout0_7 Vdout0_7ck79 = 1.8 time = 1600
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=1600.1n

* CHECK dout0_8 Vdout0_8ck79 = 0 time = 1600
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=1600.1n

* CHECK dout0_9 Vdout0_9ck79 = 0 time = 1600
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=1600.1n

* CHECK dout0_10 Vdout0_10ck79 = 0 time = 1600
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=1600.1n

* CHECK dout0_11 Vdout0_11ck79 = 0 time = 1600
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=1600.1n

* CHECK dout0_12 Vdout0_12ck79 = 1.8 time = 1600
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=1600.1n

* CHECK dout0_13 Vdout0_13ck79 = 1.8 time = 1600
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=1600.1n

* CHECK dout0_14 Vdout0_14ck79 = 1.8 time = 1600
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=1600.1n

* CHECK dout0_15 Vdout0_15ck79 = 0 time = 1600
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=1600.1n

* CHECK dout0_0 Vdout0_0ck82 = 0 time = 1660
.meas tran vdout0_0ck82 FIND v(dout0_0) AT=1660.1n

* CHECK dout0_1 Vdout0_1ck82 = 1.8 time = 1660
.meas tran vdout0_1ck82 FIND v(dout0_1) AT=1660.1n

* CHECK dout0_2 Vdout0_2ck82 = 0 time = 1660
.meas tran vdout0_2ck82 FIND v(dout0_2) AT=1660.1n

* CHECK dout0_3 Vdout0_3ck82 = 1.8 time = 1660
.meas tran vdout0_3ck82 FIND v(dout0_3) AT=1660.1n

* CHECK dout0_4 Vdout0_4ck82 = 0 time = 1660
.meas tran vdout0_4ck82 FIND v(dout0_4) AT=1660.1n

* CHECK dout0_5 Vdout0_5ck82 = 0 time = 1660
.meas tran vdout0_5ck82 FIND v(dout0_5) AT=1660.1n

* CHECK dout0_6 Vdout0_6ck82 = 0 time = 1660
.meas tran vdout0_6ck82 FIND v(dout0_6) AT=1660.1n

* CHECK dout0_7 Vdout0_7ck82 = 1.8 time = 1660
.meas tran vdout0_7ck82 FIND v(dout0_7) AT=1660.1n

* CHECK dout0_8 Vdout0_8ck82 = 1.8 time = 1660
.meas tran vdout0_8ck82 FIND v(dout0_8) AT=1660.1n

* CHECK dout0_9 Vdout0_9ck82 = 1.8 time = 1660
.meas tran vdout0_9ck82 FIND v(dout0_9) AT=1660.1n

* CHECK dout0_10 Vdout0_10ck82 = 1.8 time = 1660
.meas tran vdout0_10ck82 FIND v(dout0_10) AT=1660.1n

* CHECK dout0_11 Vdout0_11ck82 = 0 time = 1660
.meas tran vdout0_11ck82 FIND v(dout0_11) AT=1660.1n

* CHECK dout0_12 Vdout0_12ck82 = 1.8 time = 1660
.meas tran vdout0_12ck82 FIND v(dout0_12) AT=1660.1n

* CHECK dout0_13 Vdout0_13ck82 = 1.8 time = 1660
.meas tran vdout0_13ck82 FIND v(dout0_13) AT=1660.1n

* CHECK dout0_14 Vdout0_14ck82 = 0 time = 1660
.meas tran vdout0_14ck82 FIND v(dout0_14) AT=1660.1n

* CHECK dout0_15 Vdout0_15ck82 = 0 time = 1660
.meas tran vdout0_15ck82 FIND v(dout0_15) AT=1660.1n

* CHECK dout0_0 Vdout0_0ck83 = 1.8 time = 1680
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=1680.1n

* CHECK dout0_1 Vdout0_1ck83 = 1.8 time = 1680
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=1680.1n

* CHECK dout0_2 Vdout0_2ck83 = 1.8 time = 1680
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=1680.1n

* CHECK dout0_3 Vdout0_3ck83 = 1.8 time = 1680
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=1680.1n

* CHECK dout0_4 Vdout0_4ck83 = 1.8 time = 1680
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=1680.1n

* CHECK dout0_5 Vdout0_5ck83 = 1.8 time = 1680
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=1680.1n

* CHECK dout0_6 Vdout0_6ck83 = 1.8 time = 1680
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=1680.1n

* CHECK dout0_7 Vdout0_7ck83 = 0 time = 1680
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=1680.1n

* CHECK dout0_8 Vdout0_8ck83 = 0 time = 1680
.meas tran vdout0_8ck83 FIND v(dout0_8) AT=1680.1n

* CHECK dout0_9 Vdout0_9ck83 = 1.8 time = 1680
.meas tran vdout0_9ck83 FIND v(dout0_9) AT=1680.1n

* CHECK dout0_10 Vdout0_10ck83 = 1.8 time = 1680
.meas tran vdout0_10ck83 FIND v(dout0_10) AT=1680.1n

* CHECK dout0_11 Vdout0_11ck83 = 0 time = 1680
.meas tran vdout0_11ck83 FIND v(dout0_11) AT=1680.1n

* CHECK dout0_12 Vdout0_12ck83 = 1.8 time = 1680
.meas tran vdout0_12ck83 FIND v(dout0_12) AT=1680.1n

* CHECK dout0_13 Vdout0_13ck83 = 0 time = 1680
.meas tran vdout0_13ck83 FIND v(dout0_13) AT=1680.1n

* CHECK dout0_14 Vdout0_14ck83 = 0 time = 1680
.meas tran vdout0_14ck83 FIND v(dout0_14) AT=1680.1n

* CHECK dout0_15 Vdout0_15ck83 = 1.8 time = 1680
.meas tran vdout0_15ck83 FIND v(dout0_15) AT=1680.1n

* CHECK dout0_0 Vdout0_0ck85 = 1.8 time = 1720
.meas tran vdout0_0ck85 FIND v(dout0_0) AT=1720.1n

* CHECK dout0_1 Vdout0_1ck85 = 1.8 time = 1720
.meas tran vdout0_1ck85 FIND v(dout0_1) AT=1720.1n

* CHECK dout0_2 Vdout0_2ck85 = 1.8 time = 1720
.meas tran vdout0_2ck85 FIND v(dout0_2) AT=1720.1n

* CHECK dout0_3 Vdout0_3ck85 = 0 time = 1720
.meas tran vdout0_3ck85 FIND v(dout0_3) AT=1720.1n

* CHECK dout0_4 Vdout0_4ck85 = 0 time = 1720
.meas tran vdout0_4ck85 FIND v(dout0_4) AT=1720.1n

* CHECK dout0_5 Vdout0_5ck85 = 0 time = 1720
.meas tran vdout0_5ck85 FIND v(dout0_5) AT=1720.1n

* CHECK dout0_6 Vdout0_6ck85 = 0 time = 1720
.meas tran vdout0_6ck85 FIND v(dout0_6) AT=1720.1n

* CHECK dout0_7 Vdout0_7ck85 = 0 time = 1720
.meas tran vdout0_7ck85 FIND v(dout0_7) AT=1720.1n

* CHECK dout0_8 Vdout0_8ck85 = 0 time = 1720
.meas tran vdout0_8ck85 FIND v(dout0_8) AT=1720.1n

* CHECK dout0_9 Vdout0_9ck85 = 1.8 time = 1720
.meas tran vdout0_9ck85 FIND v(dout0_9) AT=1720.1n

* CHECK dout0_10 Vdout0_10ck85 = 0 time = 1720
.meas tran vdout0_10ck85 FIND v(dout0_10) AT=1720.1n

* CHECK dout0_11 Vdout0_11ck85 = 1.8 time = 1720
.meas tran vdout0_11ck85 FIND v(dout0_11) AT=1720.1n

* CHECK dout0_12 Vdout0_12ck85 = 1.8 time = 1720
.meas tran vdout0_12ck85 FIND v(dout0_12) AT=1720.1n

* CHECK dout0_13 Vdout0_13ck85 = 0 time = 1720
.meas tran vdout0_13ck85 FIND v(dout0_13) AT=1720.1n

* CHECK dout0_14 Vdout0_14ck85 = 0 time = 1720
.meas tran vdout0_14ck85 FIND v(dout0_14) AT=1720.1n

* CHECK dout0_15 Vdout0_15ck85 = 0 time = 1720
.meas tran vdout0_15ck85 FIND v(dout0_15) AT=1720.1n

* CHECK dout0_0 Vdout0_0ck86 = 0 time = 1740
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=1740.1n

* CHECK dout0_1 Vdout0_1ck86 = 0 time = 1740
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=1740.1n

* CHECK dout0_2 Vdout0_2ck86 = 0 time = 1740
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=1740.1n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 1740
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=1740.1n

* CHECK dout0_4 Vdout0_4ck86 = 0 time = 1740
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=1740.1n

* CHECK dout0_5 Vdout0_5ck86 = 0 time = 1740
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=1740.1n

* CHECK dout0_6 Vdout0_6ck86 = 1.8 time = 1740
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=1740.1n

* CHECK dout0_7 Vdout0_7ck86 = 0 time = 1740
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=1740.1n

* CHECK dout0_8 Vdout0_8ck86 = 1.8 time = 1740
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=1740.1n

* CHECK dout0_9 Vdout0_9ck86 = 1.8 time = 1740
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=1740.1n

* CHECK dout0_10 Vdout0_10ck86 = 0 time = 1740
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=1740.1n

* CHECK dout0_11 Vdout0_11ck86 = 1.8 time = 1740
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=1740.1n

* CHECK dout0_12 Vdout0_12ck86 = 1.8 time = 1740
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=1740.1n

* CHECK dout0_13 Vdout0_13ck86 = 1.8 time = 1740
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=1740.1n

* CHECK dout0_14 Vdout0_14ck86 = 0 time = 1740
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=1740.1n

* CHECK dout0_15 Vdout0_15ck86 = 0 time = 1740
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=1740.1n

* CHECK dout0_0 Vdout0_0ck89 = 0 time = 1800
.meas tran vdout0_0ck89 FIND v(dout0_0) AT=1800.1n

* CHECK dout0_1 Vdout0_1ck89 = 1.8 time = 1800
.meas tran vdout0_1ck89 FIND v(dout0_1) AT=1800.1n

* CHECK dout0_2 Vdout0_2ck89 = 0 time = 1800
.meas tran vdout0_2ck89 FIND v(dout0_2) AT=1800.1n

* CHECK dout0_3 Vdout0_3ck89 = 1.8 time = 1800
.meas tran vdout0_3ck89 FIND v(dout0_3) AT=1800.1n

* CHECK dout0_4 Vdout0_4ck89 = 0 time = 1800
.meas tran vdout0_4ck89 FIND v(dout0_4) AT=1800.1n

* CHECK dout0_5 Vdout0_5ck89 = 0 time = 1800
.meas tran vdout0_5ck89 FIND v(dout0_5) AT=1800.1n

* CHECK dout0_6 Vdout0_6ck89 = 0 time = 1800
.meas tran vdout0_6ck89 FIND v(dout0_6) AT=1800.1n

* CHECK dout0_7 Vdout0_7ck89 = 1.8 time = 1800
.meas tran vdout0_7ck89 FIND v(dout0_7) AT=1800.1n

* CHECK dout0_8 Vdout0_8ck89 = 1.8 time = 1800
.meas tran vdout0_8ck89 FIND v(dout0_8) AT=1800.1n

* CHECK dout0_9 Vdout0_9ck89 = 1.8 time = 1800
.meas tran vdout0_9ck89 FIND v(dout0_9) AT=1800.1n

* CHECK dout0_10 Vdout0_10ck89 = 1.8 time = 1800
.meas tran vdout0_10ck89 FIND v(dout0_10) AT=1800.1n

* CHECK dout0_11 Vdout0_11ck89 = 0 time = 1800
.meas tran vdout0_11ck89 FIND v(dout0_11) AT=1800.1n

* CHECK dout0_12 Vdout0_12ck89 = 1.8 time = 1800
.meas tran vdout0_12ck89 FIND v(dout0_12) AT=1800.1n

* CHECK dout0_13 Vdout0_13ck89 = 1.8 time = 1800
.meas tran vdout0_13ck89 FIND v(dout0_13) AT=1800.1n

* CHECK dout0_14 Vdout0_14ck89 = 0 time = 1800
.meas tran vdout0_14ck89 FIND v(dout0_14) AT=1800.1n

* CHECK dout0_15 Vdout0_15ck89 = 0 time = 1800
.meas tran vdout0_15ck89 FIND v(dout0_15) AT=1800.1n

* CHECK dout0_0 Vdout0_0ck92 = 1.8 time = 1860
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=1860.1n

* CHECK dout0_1 Vdout0_1ck92 = 1.8 time = 1860
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=1860.1n

* CHECK dout0_2 Vdout0_2ck92 = 1.8 time = 1860
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=1860.1n

* CHECK dout0_3 Vdout0_3ck92 = 0 time = 1860
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=1860.1n

* CHECK dout0_4 Vdout0_4ck92 = 1.8 time = 1860
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=1860.1n

* CHECK dout0_5 Vdout0_5ck92 = 0 time = 1860
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=1860.1n

* CHECK dout0_6 Vdout0_6ck92 = 1.8 time = 1860
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=1860.1n

* CHECK dout0_7 Vdout0_7ck92 = 1.8 time = 1860
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=1860.1n

* CHECK dout0_8 Vdout0_8ck92 = 1.8 time = 1860
.meas tran vdout0_8ck92 FIND v(dout0_8) AT=1860.1n

* CHECK dout0_9 Vdout0_9ck92 = 1.8 time = 1860
.meas tran vdout0_9ck92 FIND v(dout0_9) AT=1860.1n

* CHECK dout0_10 Vdout0_10ck92 = 1.8 time = 1860
.meas tran vdout0_10ck92 FIND v(dout0_10) AT=1860.1n

* CHECK dout0_11 Vdout0_11ck92 = 0 time = 1860
.meas tran vdout0_11ck92 FIND v(dout0_11) AT=1860.1n

* CHECK dout0_12 Vdout0_12ck92 = 1.8 time = 1860
.meas tran vdout0_12ck92 FIND v(dout0_12) AT=1860.1n

* CHECK dout0_13 Vdout0_13ck92 = 1.8 time = 1860
.meas tran vdout0_13ck92 FIND v(dout0_13) AT=1860.1n

* CHECK dout0_14 Vdout0_14ck92 = 1.8 time = 1860
.meas tran vdout0_14ck92 FIND v(dout0_14) AT=1860.1n

* CHECK dout0_15 Vdout0_15ck92 = 1.8 time = 1860
.meas tran vdout0_15ck92 FIND v(dout0_15) AT=1860.1n

* CHECK dout0_0 Vdout0_0ck93 = 0 time = 1880
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=1880.1n

* CHECK dout0_1 Vdout0_1ck93 = 0 time = 1880
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=1880.1n

* CHECK dout0_2 Vdout0_2ck93 = 1.8 time = 1880
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=1880.1n

* CHECK dout0_3 Vdout0_3ck93 = 1.8 time = 1880
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=1880.1n

* CHECK dout0_4 Vdout0_4ck93 = 0 time = 1880
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=1880.1n

* CHECK dout0_5 Vdout0_5ck93 = 0 time = 1880
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=1880.1n

* CHECK dout0_6 Vdout0_6ck93 = 0 time = 1880
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=1880.1n

* CHECK dout0_7 Vdout0_7ck93 = 1.8 time = 1880
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=1880.1n

* CHECK dout0_8 Vdout0_8ck93 = 0 time = 1880
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=1880.1n

* CHECK dout0_9 Vdout0_9ck93 = 0 time = 1880
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=1880.1n

* CHECK dout0_10 Vdout0_10ck93 = 0 time = 1880
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=1880.1n

* CHECK dout0_11 Vdout0_11ck93 = 0 time = 1880
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=1880.1n

* CHECK dout0_12 Vdout0_12ck93 = 0 time = 1880
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=1880.1n

* CHECK dout0_13 Vdout0_13ck93 = 0 time = 1880
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=1880.1n

* CHECK dout0_14 Vdout0_14ck93 = 1.8 time = 1880
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=1880.1n

* CHECK dout0_15 Vdout0_15ck93 = 0 time = 1880
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=1880.1n

* CHECK dout0_0 Vdout0_0ck94 = 0 time = 1900
.meas tran vdout0_0ck94 FIND v(dout0_0) AT=1900.1n

* CHECK dout0_1 Vdout0_1ck94 = 1.8 time = 1900
.meas tran vdout0_1ck94 FIND v(dout0_1) AT=1900.1n

* CHECK dout0_2 Vdout0_2ck94 = 1.8 time = 1900
.meas tran vdout0_2ck94 FIND v(dout0_2) AT=1900.1n

* CHECK dout0_3 Vdout0_3ck94 = 1.8 time = 1900
.meas tran vdout0_3ck94 FIND v(dout0_3) AT=1900.1n

* CHECK dout0_4 Vdout0_4ck94 = 1.8 time = 1900
.meas tran vdout0_4ck94 FIND v(dout0_4) AT=1900.1n

* CHECK dout0_5 Vdout0_5ck94 = 0 time = 1900
.meas tran vdout0_5ck94 FIND v(dout0_5) AT=1900.1n

* CHECK dout0_6 Vdout0_6ck94 = 1.8 time = 1900
.meas tran vdout0_6ck94 FIND v(dout0_6) AT=1900.1n

* CHECK dout0_7 Vdout0_7ck94 = 1.8 time = 1900
.meas tran vdout0_7ck94 FIND v(dout0_7) AT=1900.1n

* CHECK dout0_8 Vdout0_8ck94 = 1.8 time = 1900
.meas tran vdout0_8ck94 FIND v(dout0_8) AT=1900.1n

* CHECK dout0_9 Vdout0_9ck94 = 1.8 time = 1900
.meas tran vdout0_9ck94 FIND v(dout0_9) AT=1900.1n

* CHECK dout0_10 Vdout0_10ck94 = 0 time = 1900
.meas tran vdout0_10ck94 FIND v(dout0_10) AT=1900.1n

* CHECK dout0_11 Vdout0_11ck94 = 0 time = 1900
.meas tran vdout0_11ck94 FIND v(dout0_11) AT=1900.1n

* CHECK dout0_12 Vdout0_12ck94 = 1.8 time = 1900
.meas tran vdout0_12ck94 FIND v(dout0_12) AT=1900.1n

* CHECK dout0_13 Vdout0_13ck94 = 1.8 time = 1900
.meas tran vdout0_13ck94 FIND v(dout0_13) AT=1900.1n

* CHECK dout0_14 Vdout0_14ck94 = 0 time = 1900
.meas tran vdout0_14ck94 FIND v(dout0_14) AT=1900.1n

* CHECK dout0_15 Vdout0_15ck94 = 1.8 time = 1900
.meas tran vdout0_15ck94 FIND v(dout0_15) AT=1900.1n

* CHECK dout0_0 Vdout0_0ck96 = 0 time = 1940
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=1940.1n

* CHECK dout0_1 Vdout0_1ck96 = 1.8 time = 1940
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=1940.1n

* CHECK dout0_2 Vdout0_2ck96 = 1.8 time = 1940
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=1940.1n

* CHECK dout0_3 Vdout0_3ck96 = 0 time = 1940
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=1940.1n

* CHECK dout0_4 Vdout0_4ck96 = 0 time = 1940
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=1940.1n

* CHECK dout0_5 Vdout0_5ck96 = 0 time = 1940
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=1940.1n

* CHECK dout0_6 Vdout0_6ck96 = 1.8 time = 1940
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=1940.1n

* CHECK dout0_7 Vdout0_7ck96 = 0 time = 1940
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=1940.1n

* CHECK dout0_8 Vdout0_8ck96 = 1.8 time = 1940
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=1940.1n

* CHECK dout0_9 Vdout0_9ck96 = 0 time = 1940
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=1940.1n

* CHECK dout0_10 Vdout0_10ck96 = 0 time = 1940
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=1940.1n

* CHECK dout0_11 Vdout0_11ck96 = 0 time = 1940
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=1940.1n

* CHECK dout0_12 Vdout0_12ck96 = 1.8 time = 1940
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=1940.1n

* CHECK dout0_13 Vdout0_13ck96 = 1.8 time = 1940
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=1940.1n

* CHECK dout0_14 Vdout0_14ck96 = 1.8 time = 1940
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=1940.1n

* CHECK dout0_15 Vdout0_15ck96 = 1.8 time = 1940
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=1940.1n

* CHECK dout0_0 Vdout0_0ck97 = 0 time = 1960
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=1960.1n

* CHECK dout0_1 Vdout0_1ck97 = 0 time = 1960
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=1960.1n

* CHECK dout0_2 Vdout0_2ck97 = 1.8 time = 1960
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=1960.1n

* CHECK dout0_3 Vdout0_3ck97 = 1.8 time = 1960
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=1960.1n

* CHECK dout0_4 Vdout0_4ck97 = 0 time = 1960
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=1960.1n

* CHECK dout0_5 Vdout0_5ck97 = 0 time = 1960
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=1960.1n

* CHECK dout0_6 Vdout0_6ck97 = 0 time = 1960
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=1960.1n

* CHECK dout0_7 Vdout0_7ck97 = 1.8 time = 1960
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=1960.1n

* CHECK dout0_8 Vdout0_8ck97 = 0 time = 1960
.meas tran vdout0_8ck97 FIND v(dout0_8) AT=1960.1n

* CHECK dout0_9 Vdout0_9ck97 = 0 time = 1960
.meas tran vdout0_9ck97 FIND v(dout0_9) AT=1960.1n

* CHECK dout0_10 Vdout0_10ck97 = 0 time = 1960
.meas tran vdout0_10ck97 FIND v(dout0_10) AT=1960.1n

* CHECK dout0_11 Vdout0_11ck97 = 0 time = 1960
.meas tran vdout0_11ck97 FIND v(dout0_11) AT=1960.1n

* CHECK dout0_12 Vdout0_12ck97 = 0 time = 1960
.meas tran vdout0_12ck97 FIND v(dout0_12) AT=1960.1n

* CHECK dout0_13 Vdout0_13ck97 = 0 time = 1960
.meas tran vdout0_13ck97 FIND v(dout0_13) AT=1960.1n

* CHECK dout0_14 Vdout0_14ck97 = 1.8 time = 1960
.meas tran vdout0_14ck97 FIND v(dout0_14) AT=1960.1n

* CHECK dout0_15 Vdout0_15ck97 = 0 time = 1960
.meas tran vdout0_15ck97 FIND v(dout0_15) AT=1960.1n

* CHECK dout0_0 Vdout0_0ck99 = 1.8 time = 2000
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=2000.1n

* CHECK dout0_1 Vdout0_1ck99 = 0 time = 2000
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=2000.1n

* CHECK dout0_2 Vdout0_2ck99 = 0 time = 2000
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=2000.1n

* CHECK dout0_3 Vdout0_3ck99 = 1.8 time = 2000
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=2000.1n

* CHECK dout0_4 Vdout0_4ck99 = 0 time = 2000
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=2000.1n

* CHECK dout0_5 Vdout0_5ck99 = 0 time = 2000
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=2000.1n

* CHECK dout0_6 Vdout0_6ck99 = 0 time = 2000
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=2000.1n

* CHECK dout0_7 Vdout0_7ck99 = 0 time = 2000
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=2000.1n

* CHECK dout0_8 Vdout0_8ck99 = 1.8 time = 2000
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=2000.1n

* CHECK dout0_9 Vdout0_9ck99 = 1.8 time = 2000
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=2000.1n

* CHECK dout0_10 Vdout0_10ck99 = 1.8 time = 2000
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=2000.1n

* CHECK dout0_11 Vdout0_11ck99 = 1.8 time = 2000
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=2000.1n

* CHECK dout0_12 Vdout0_12ck99 = 0 time = 2000
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=2000.1n

* CHECK dout0_13 Vdout0_13ck99 = 1.8 time = 2000
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=2000.1n

* CHECK dout0_14 Vdout0_14ck99 = 1.8 time = 2000
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=2000.1n

* CHECK dout0_15 Vdout0_15ck99 = 1.8 time = 2000
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=2000.1n

* CHECK dout0_0 Vdout0_0ck100 = 1.8 time = 2020
.meas tran vdout0_0ck100 FIND v(dout0_0) AT=2020.1n

* CHECK dout0_1 Vdout0_1ck100 = 1.8 time = 2020
.meas tran vdout0_1ck100 FIND v(dout0_1) AT=2020.1n

* CHECK dout0_2 Vdout0_2ck100 = 1.8 time = 2020
.meas tran vdout0_2ck100 FIND v(dout0_2) AT=2020.1n

* CHECK dout0_3 Vdout0_3ck100 = 1.8 time = 2020
.meas tran vdout0_3ck100 FIND v(dout0_3) AT=2020.1n

* CHECK dout0_4 Vdout0_4ck100 = 0 time = 2020
.meas tran vdout0_4ck100 FIND v(dout0_4) AT=2020.1n

* CHECK dout0_5 Vdout0_5ck100 = 0 time = 2020
.meas tran vdout0_5ck100 FIND v(dout0_5) AT=2020.1n

* CHECK dout0_6 Vdout0_6ck100 = 1.8 time = 2020
.meas tran vdout0_6ck100 FIND v(dout0_6) AT=2020.1n

* CHECK dout0_7 Vdout0_7ck100 = 1.8 time = 2020
.meas tran vdout0_7ck100 FIND v(dout0_7) AT=2020.1n

* CHECK dout0_8 Vdout0_8ck100 = 0 time = 2020
.meas tran vdout0_8ck100 FIND v(dout0_8) AT=2020.1n

* CHECK dout0_9 Vdout0_9ck100 = 0 time = 2020
.meas tran vdout0_9ck100 FIND v(dout0_9) AT=2020.1n

* CHECK dout0_10 Vdout0_10ck100 = 0 time = 2020
.meas tran vdout0_10ck100 FIND v(dout0_10) AT=2020.1n

* CHECK dout0_11 Vdout0_11ck100 = 0 time = 2020
.meas tran vdout0_11ck100 FIND v(dout0_11) AT=2020.1n

* CHECK dout0_12 Vdout0_12ck100 = 1.8 time = 2020
.meas tran vdout0_12ck100 FIND v(dout0_12) AT=2020.1n

* CHECK dout0_13 Vdout0_13ck100 = 0 time = 2020
.meas tran vdout0_13ck100 FIND v(dout0_13) AT=2020.1n

* CHECK dout0_14 Vdout0_14ck100 = 1.8 time = 2020
.meas tran vdout0_14ck100 FIND v(dout0_14) AT=2020.1n

* CHECK dout0_15 Vdout0_15ck100 = 1.8 time = 2020
.meas tran vdout0_15ck100 FIND v(dout0_15) AT=2020.1n

* CHECK dout0_0 Vdout0_0ck103 = 1.8 time = 2080
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=2080.1n

* CHECK dout0_1 Vdout0_1ck103 = 1.8 time = 2080
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=2080.1n

* CHECK dout0_2 Vdout0_2ck103 = 1.8 time = 2080
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=2080.1n

* CHECK dout0_3 Vdout0_3ck103 = 0 time = 2080
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=2080.1n

* CHECK dout0_4 Vdout0_4ck103 = 0 time = 2080
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=2080.1n

* CHECK dout0_5 Vdout0_5ck103 = 0 time = 2080
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=2080.1n

* CHECK dout0_6 Vdout0_6ck103 = 0 time = 2080
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=2080.1n

* CHECK dout0_7 Vdout0_7ck103 = 0 time = 2080
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=2080.1n

* CHECK dout0_8 Vdout0_8ck103 = 0 time = 2080
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=2080.1n

* CHECK dout0_9 Vdout0_9ck103 = 1.8 time = 2080
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=2080.1n

* CHECK dout0_10 Vdout0_10ck103 = 0 time = 2080
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=2080.1n

* CHECK dout0_11 Vdout0_11ck103 = 1.8 time = 2080
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=2080.1n

* CHECK dout0_12 Vdout0_12ck103 = 1.8 time = 2080
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=2080.1n

* CHECK dout0_13 Vdout0_13ck103 = 0 time = 2080
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=2080.1n

* CHECK dout0_14 Vdout0_14ck103 = 0 time = 2080
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=2080.1n

* CHECK dout0_15 Vdout0_15ck103 = 0 time = 2080
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=2080.1n

* CHECK dout0_0 Vdout0_0ck104 = 0 time = 2100
.meas tran vdout0_0ck104 FIND v(dout0_0) AT=2100.1n

* CHECK dout0_1 Vdout0_1ck104 = 1.8 time = 2100
.meas tran vdout0_1ck104 FIND v(dout0_1) AT=2100.1n

* CHECK dout0_2 Vdout0_2ck104 = 0 time = 2100
.meas tran vdout0_2ck104 FIND v(dout0_2) AT=2100.1n

* CHECK dout0_3 Vdout0_3ck104 = 1.8 time = 2100
.meas tran vdout0_3ck104 FIND v(dout0_3) AT=2100.1n

* CHECK dout0_4 Vdout0_4ck104 = 0 time = 2100
.meas tran vdout0_4ck104 FIND v(dout0_4) AT=2100.1n

* CHECK dout0_5 Vdout0_5ck104 = 0 time = 2100
.meas tran vdout0_5ck104 FIND v(dout0_5) AT=2100.1n

* CHECK dout0_6 Vdout0_6ck104 = 1.8 time = 2100
.meas tran vdout0_6ck104 FIND v(dout0_6) AT=2100.1n

* CHECK dout0_7 Vdout0_7ck104 = 0 time = 2100
.meas tran vdout0_7ck104 FIND v(dout0_7) AT=2100.1n

* CHECK dout0_8 Vdout0_8ck104 = 1.8 time = 2100
.meas tran vdout0_8ck104 FIND v(dout0_8) AT=2100.1n

* CHECK dout0_9 Vdout0_9ck104 = 1.8 time = 2100
.meas tran vdout0_9ck104 FIND v(dout0_9) AT=2100.1n

* CHECK dout0_10 Vdout0_10ck104 = 0 time = 2100
.meas tran vdout0_10ck104 FIND v(dout0_10) AT=2100.1n

* CHECK dout0_11 Vdout0_11ck104 = 1.8 time = 2100
.meas tran vdout0_11ck104 FIND v(dout0_11) AT=2100.1n

* CHECK dout0_12 Vdout0_12ck104 = 0 time = 2100
.meas tran vdout0_12ck104 FIND v(dout0_12) AT=2100.1n

* CHECK dout0_13 Vdout0_13ck104 = 1.8 time = 2100
.meas tran vdout0_13ck104 FIND v(dout0_13) AT=2100.1n

* CHECK dout0_14 Vdout0_14ck104 = 1.8 time = 2100
.meas tran vdout0_14ck104 FIND v(dout0_14) AT=2100.1n

* CHECK dout0_15 Vdout0_15ck104 = 1.8 time = 2100
.meas tran vdout0_15ck104 FIND v(dout0_15) AT=2100.1n

* CHECK dout0_0 Vdout0_0ck105 = 0 time = 2120
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=2120.1n

* CHECK dout0_1 Vdout0_1ck105 = 0 time = 2120
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=2120.1n

* CHECK dout0_2 Vdout0_2ck105 = 1.8 time = 2120
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=2120.1n

* CHECK dout0_3 Vdout0_3ck105 = 1.8 time = 2120
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=2120.1n

* CHECK dout0_4 Vdout0_4ck105 = 0 time = 2120
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=2120.1n

* CHECK dout0_5 Vdout0_5ck105 = 0 time = 2120
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=2120.1n

* CHECK dout0_6 Vdout0_6ck105 = 0 time = 2120
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=2120.1n

* CHECK dout0_7 Vdout0_7ck105 = 1.8 time = 2120
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=2120.1n

* CHECK dout0_8 Vdout0_8ck105 = 0 time = 2120
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=2120.1n

* CHECK dout0_9 Vdout0_9ck105 = 0 time = 2120
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=2120.1n

* CHECK dout0_10 Vdout0_10ck105 = 0 time = 2120
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=2120.1n

* CHECK dout0_11 Vdout0_11ck105 = 0 time = 2120
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=2120.1n

* CHECK dout0_12 Vdout0_12ck105 = 0 time = 2120
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=2120.1n

* CHECK dout0_13 Vdout0_13ck105 = 0 time = 2120
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=2120.1n

* CHECK dout0_14 Vdout0_14ck105 = 1.8 time = 2120
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=2120.1n

* CHECK dout0_15 Vdout0_15ck105 = 0 time = 2120
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=2120.1n

* CHECK dout0_0 Vdout0_0ck109 = 1.8 time = 2200
.meas tran vdout0_0ck109 FIND v(dout0_0) AT=2200.1n

* CHECK dout0_1 Vdout0_1ck109 = 1.8 time = 2200
.meas tran vdout0_1ck109 FIND v(dout0_1) AT=2200.1n

* CHECK dout0_2 Vdout0_2ck109 = 1.8 time = 2200
.meas tran vdout0_2ck109 FIND v(dout0_2) AT=2200.1n

* CHECK dout0_3 Vdout0_3ck109 = 0 time = 2200
.meas tran vdout0_3ck109 FIND v(dout0_3) AT=2200.1n

* CHECK dout0_4 Vdout0_4ck109 = 0 time = 2200
.meas tran vdout0_4ck109 FIND v(dout0_4) AT=2200.1n

* CHECK dout0_5 Vdout0_5ck109 = 0 time = 2200
.meas tran vdout0_5ck109 FIND v(dout0_5) AT=2200.1n

* CHECK dout0_6 Vdout0_6ck109 = 0 time = 2200
.meas tran vdout0_6ck109 FIND v(dout0_6) AT=2200.1n

* CHECK dout0_7 Vdout0_7ck109 = 0 time = 2200
.meas tran vdout0_7ck109 FIND v(dout0_7) AT=2200.1n

* CHECK dout0_8 Vdout0_8ck109 = 0 time = 2200
.meas tran vdout0_8ck109 FIND v(dout0_8) AT=2200.1n

* CHECK dout0_9 Vdout0_9ck109 = 1.8 time = 2200
.meas tran vdout0_9ck109 FIND v(dout0_9) AT=2200.1n

* CHECK dout0_10 Vdout0_10ck109 = 0 time = 2200
.meas tran vdout0_10ck109 FIND v(dout0_10) AT=2200.1n

* CHECK dout0_11 Vdout0_11ck109 = 1.8 time = 2200
.meas tran vdout0_11ck109 FIND v(dout0_11) AT=2200.1n

* CHECK dout0_12 Vdout0_12ck109 = 1.8 time = 2200
.meas tran vdout0_12ck109 FIND v(dout0_12) AT=2200.1n

* CHECK dout0_13 Vdout0_13ck109 = 0 time = 2200
.meas tran vdout0_13ck109 FIND v(dout0_13) AT=2200.1n

* CHECK dout0_14 Vdout0_14ck109 = 0 time = 2200
.meas tran vdout0_14ck109 FIND v(dout0_14) AT=2200.1n

* CHECK dout0_15 Vdout0_15ck109 = 0 time = 2200
.meas tran vdout0_15ck109 FIND v(dout0_15) AT=2200.1n

* CHECK dout0_0 Vdout0_0ck110 = 0 time = 2220
.meas tran vdout0_0ck110 FIND v(dout0_0) AT=2220.1n

* CHECK dout0_1 Vdout0_1ck110 = 1.8 time = 2220
.meas tran vdout0_1ck110 FIND v(dout0_1) AT=2220.1n

* CHECK dout0_2 Vdout0_2ck110 = 1.8 time = 2220
.meas tran vdout0_2ck110 FIND v(dout0_2) AT=2220.1n

* CHECK dout0_3 Vdout0_3ck110 = 1.8 time = 2220
.meas tran vdout0_3ck110 FIND v(dout0_3) AT=2220.1n

* CHECK dout0_4 Vdout0_4ck110 = 1.8 time = 2220
.meas tran vdout0_4ck110 FIND v(dout0_4) AT=2220.1n

* CHECK dout0_5 Vdout0_5ck110 = 0 time = 2220
.meas tran vdout0_5ck110 FIND v(dout0_5) AT=2220.1n

* CHECK dout0_6 Vdout0_6ck110 = 1.8 time = 2220
.meas tran vdout0_6ck110 FIND v(dout0_6) AT=2220.1n

* CHECK dout0_7 Vdout0_7ck110 = 0 time = 2220
.meas tran vdout0_7ck110 FIND v(dout0_7) AT=2220.1n

* CHECK dout0_8 Vdout0_8ck110 = 1.8 time = 2220
.meas tran vdout0_8ck110 FIND v(dout0_8) AT=2220.1n

* CHECK dout0_9 Vdout0_9ck110 = 0 time = 2220
.meas tran vdout0_9ck110 FIND v(dout0_9) AT=2220.1n

* CHECK dout0_10 Vdout0_10ck110 = 0 time = 2220
.meas tran vdout0_10ck110 FIND v(dout0_10) AT=2220.1n

* CHECK dout0_11 Vdout0_11ck110 = 0 time = 2220
.meas tran vdout0_11ck110 FIND v(dout0_11) AT=2220.1n

* CHECK dout0_12 Vdout0_12ck110 = 0 time = 2220
.meas tran vdout0_12ck110 FIND v(dout0_12) AT=2220.1n

* CHECK dout0_13 Vdout0_13ck110 = 1.8 time = 2220
.meas tran vdout0_13ck110 FIND v(dout0_13) AT=2220.1n

* CHECK dout0_14 Vdout0_14ck110 = 0 time = 2220
.meas tran vdout0_14ck110 FIND v(dout0_14) AT=2220.1n

* CHECK dout0_15 Vdout0_15ck110 = 0 time = 2220
.meas tran vdout0_15ck110 FIND v(dout0_15) AT=2220.1n

* CHECK dout0_0 Vdout0_0ck111 = 1.8 time = 2240
.meas tran vdout0_0ck111 FIND v(dout0_0) AT=2240.1n

* CHECK dout0_1 Vdout0_1ck111 = 1.8 time = 2240
.meas tran vdout0_1ck111 FIND v(dout0_1) AT=2240.1n

* CHECK dout0_2 Vdout0_2ck111 = 1.8 time = 2240
.meas tran vdout0_2ck111 FIND v(dout0_2) AT=2240.1n

* CHECK dout0_3 Vdout0_3ck111 = 1.8 time = 2240
.meas tran vdout0_3ck111 FIND v(dout0_3) AT=2240.1n

* CHECK dout0_4 Vdout0_4ck111 = 0 time = 2240
.meas tran vdout0_4ck111 FIND v(dout0_4) AT=2240.1n

* CHECK dout0_5 Vdout0_5ck111 = 0 time = 2240
.meas tran vdout0_5ck111 FIND v(dout0_5) AT=2240.1n

* CHECK dout0_6 Vdout0_6ck111 = 1.8 time = 2240
.meas tran vdout0_6ck111 FIND v(dout0_6) AT=2240.1n

* CHECK dout0_7 Vdout0_7ck111 = 1.8 time = 2240
.meas tran vdout0_7ck111 FIND v(dout0_7) AT=2240.1n

* CHECK dout0_8 Vdout0_8ck111 = 0 time = 2240
.meas tran vdout0_8ck111 FIND v(dout0_8) AT=2240.1n

* CHECK dout0_9 Vdout0_9ck111 = 0 time = 2240
.meas tran vdout0_9ck111 FIND v(dout0_9) AT=2240.1n

* CHECK dout0_10 Vdout0_10ck111 = 0 time = 2240
.meas tran vdout0_10ck111 FIND v(dout0_10) AT=2240.1n

* CHECK dout0_11 Vdout0_11ck111 = 0 time = 2240
.meas tran vdout0_11ck111 FIND v(dout0_11) AT=2240.1n

* CHECK dout0_12 Vdout0_12ck111 = 1.8 time = 2240
.meas tran vdout0_12ck111 FIND v(dout0_12) AT=2240.1n

* CHECK dout0_13 Vdout0_13ck111 = 0 time = 2240
.meas tran vdout0_13ck111 FIND v(dout0_13) AT=2240.1n

* CHECK dout0_14 Vdout0_14ck111 = 1.8 time = 2240
.meas tran vdout0_14ck111 FIND v(dout0_14) AT=2240.1n

* CHECK dout0_15 Vdout0_15ck111 = 1.8 time = 2240
.meas tran vdout0_15ck111 FIND v(dout0_15) AT=2240.1n

* CHECK dout0_0 Vdout0_0ck112 = 0 time = 2260
.meas tran vdout0_0ck112 FIND v(dout0_0) AT=2260.1n

* CHECK dout0_1 Vdout0_1ck112 = 1.8 time = 2260
.meas tran vdout0_1ck112 FIND v(dout0_1) AT=2260.1n

* CHECK dout0_2 Vdout0_2ck112 = 1.8 time = 2260
.meas tran vdout0_2ck112 FIND v(dout0_2) AT=2260.1n

* CHECK dout0_3 Vdout0_3ck112 = 0 time = 2260
.meas tran vdout0_3ck112 FIND v(dout0_3) AT=2260.1n

* CHECK dout0_4 Vdout0_4ck112 = 0 time = 2260
.meas tran vdout0_4ck112 FIND v(dout0_4) AT=2260.1n

* CHECK dout0_5 Vdout0_5ck112 = 0 time = 2260
.meas tran vdout0_5ck112 FIND v(dout0_5) AT=2260.1n

* CHECK dout0_6 Vdout0_6ck112 = 1.8 time = 2260
.meas tran vdout0_6ck112 FIND v(dout0_6) AT=2260.1n

* CHECK dout0_7 Vdout0_7ck112 = 0 time = 2260
.meas tran vdout0_7ck112 FIND v(dout0_7) AT=2260.1n

* CHECK dout0_8 Vdout0_8ck112 = 1.8 time = 2260
.meas tran vdout0_8ck112 FIND v(dout0_8) AT=2260.1n

* CHECK dout0_9 Vdout0_9ck112 = 0 time = 2260
.meas tran vdout0_9ck112 FIND v(dout0_9) AT=2260.1n

* CHECK dout0_10 Vdout0_10ck112 = 0 time = 2260
.meas tran vdout0_10ck112 FIND v(dout0_10) AT=2260.1n

* CHECK dout0_11 Vdout0_11ck112 = 0 time = 2260
.meas tran vdout0_11ck112 FIND v(dout0_11) AT=2260.1n

* CHECK dout0_12 Vdout0_12ck112 = 1.8 time = 2260
.meas tran vdout0_12ck112 FIND v(dout0_12) AT=2260.1n

* CHECK dout0_13 Vdout0_13ck112 = 1.8 time = 2260
.meas tran vdout0_13ck112 FIND v(dout0_13) AT=2260.1n

* CHECK dout0_14 Vdout0_14ck112 = 1.8 time = 2260
.meas tran vdout0_14ck112 FIND v(dout0_14) AT=2260.1n

* CHECK dout0_15 Vdout0_15ck112 = 1.8 time = 2260
.meas tran vdout0_15ck112 FIND v(dout0_15) AT=2260.1n

* CHECK dout0_0 Vdout0_0ck115 = 1.8 time = 2320
.meas tran vdout0_0ck115 FIND v(dout0_0) AT=2320.1n

* CHECK dout0_1 Vdout0_1ck115 = 0 time = 2320
.meas tran vdout0_1ck115 FIND v(dout0_1) AT=2320.1n

* CHECK dout0_2 Vdout0_2ck115 = 0 time = 2320
.meas tran vdout0_2ck115 FIND v(dout0_2) AT=2320.1n

* CHECK dout0_3 Vdout0_3ck115 = 1.8 time = 2320
.meas tran vdout0_3ck115 FIND v(dout0_3) AT=2320.1n

* CHECK dout0_4 Vdout0_4ck115 = 0 time = 2320
.meas tran vdout0_4ck115 FIND v(dout0_4) AT=2320.1n

* CHECK dout0_5 Vdout0_5ck115 = 1.8 time = 2320
.meas tran vdout0_5ck115 FIND v(dout0_5) AT=2320.1n

* CHECK dout0_6 Vdout0_6ck115 = 1.8 time = 2320
.meas tran vdout0_6ck115 FIND v(dout0_6) AT=2320.1n

* CHECK dout0_7 Vdout0_7ck115 = 1.8 time = 2320
.meas tran vdout0_7ck115 FIND v(dout0_7) AT=2320.1n

* CHECK dout0_8 Vdout0_8ck115 = 1.8 time = 2320
.meas tran vdout0_8ck115 FIND v(dout0_8) AT=2320.1n

* CHECK dout0_9 Vdout0_9ck115 = 1.8 time = 2320
.meas tran vdout0_9ck115 FIND v(dout0_9) AT=2320.1n

* CHECK dout0_10 Vdout0_10ck115 = 1.8 time = 2320
.meas tran vdout0_10ck115 FIND v(dout0_10) AT=2320.1n

* CHECK dout0_11 Vdout0_11ck115 = 0 time = 2320
.meas tran vdout0_11ck115 FIND v(dout0_11) AT=2320.1n

* CHECK dout0_12 Vdout0_12ck115 = 0 time = 2320
.meas tran vdout0_12ck115 FIND v(dout0_12) AT=2320.1n

* CHECK dout0_13 Vdout0_13ck115 = 0 time = 2320
.meas tran vdout0_13ck115 FIND v(dout0_13) AT=2320.1n

* CHECK dout0_14 Vdout0_14ck115 = 1.8 time = 2320
.meas tran vdout0_14ck115 FIND v(dout0_14) AT=2320.1n

* CHECK dout0_15 Vdout0_15ck115 = 1.8 time = 2320
.meas tran vdout0_15ck115 FIND v(dout0_15) AT=2320.1n

* CHECK dout0_0 Vdout0_0ck120 = 0 time = 2420
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=2420.1n

* CHECK dout0_1 Vdout0_1ck120 = 0 time = 2420
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=2420.1n

* CHECK dout0_2 Vdout0_2ck120 = 1.8 time = 2420
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=2420.1n

* CHECK dout0_3 Vdout0_3ck120 = 1.8 time = 2420
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=2420.1n

* CHECK dout0_4 Vdout0_4ck120 = 0 time = 2420
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=2420.1n

* CHECK dout0_5 Vdout0_5ck120 = 0 time = 2420
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=2420.1n

* CHECK dout0_6 Vdout0_6ck120 = 0 time = 2420
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=2420.1n

* CHECK dout0_7 Vdout0_7ck120 = 1.8 time = 2420
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=2420.1n

* CHECK dout0_8 Vdout0_8ck120 = 0 time = 2420
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=2420.1n

* CHECK dout0_9 Vdout0_9ck120 = 0 time = 2420
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=2420.1n

* CHECK dout0_10 Vdout0_10ck120 = 0 time = 2420
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=2420.1n

* CHECK dout0_11 Vdout0_11ck120 = 0 time = 2420
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=2420.1n

* CHECK dout0_12 Vdout0_12ck120 = 0 time = 2420
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=2420.1n

* CHECK dout0_13 Vdout0_13ck120 = 0 time = 2420
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=2420.1n

* CHECK dout0_14 Vdout0_14ck120 = 1.8 time = 2420
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=2420.1n

* CHECK dout0_15 Vdout0_15ck120 = 0 time = 2420
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=2420.1n

* CHECK dout0_0 Vdout0_0ck122 = 1.8 time = 2460
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=2460.1n

* CHECK dout0_1 Vdout0_1ck122 = 1.8 time = 2460
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=2460.1n

* CHECK dout0_2 Vdout0_2ck122 = 1.8 time = 2460
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=2460.1n

* CHECK dout0_3 Vdout0_3ck122 = 0 time = 2460
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=2460.1n

* CHECK dout0_4 Vdout0_4ck122 = 0 time = 2460
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=2460.1n

* CHECK dout0_5 Vdout0_5ck122 = 0 time = 2460
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=2460.1n

* CHECK dout0_6 Vdout0_6ck122 = 0 time = 2460
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=2460.1n

* CHECK dout0_7 Vdout0_7ck122 = 0 time = 2460
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=2460.1n

* CHECK dout0_8 Vdout0_8ck122 = 0 time = 2460
.meas tran vdout0_8ck122 FIND v(dout0_8) AT=2460.1n

* CHECK dout0_9 Vdout0_9ck122 = 1.8 time = 2460
.meas tran vdout0_9ck122 FIND v(dout0_9) AT=2460.1n

* CHECK dout0_10 Vdout0_10ck122 = 0 time = 2460
.meas tran vdout0_10ck122 FIND v(dout0_10) AT=2460.1n

* CHECK dout0_11 Vdout0_11ck122 = 1.8 time = 2460
.meas tran vdout0_11ck122 FIND v(dout0_11) AT=2460.1n

* CHECK dout0_12 Vdout0_12ck122 = 1.8 time = 2460
.meas tran vdout0_12ck122 FIND v(dout0_12) AT=2460.1n

* CHECK dout0_13 Vdout0_13ck122 = 0 time = 2460
.meas tran vdout0_13ck122 FIND v(dout0_13) AT=2460.1n

* CHECK dout0_14 Vdout0_14ck122 = 0 time = 2460
.meas tran vdout0_14ck122 FIND v(dout0_14) AT=2460.1n

* CHECK dout0_15 Vdout0_15ck122 = 0 time = 2460
.meas tran vdout0_15ck122 FIND v(dout0_15) AT=2460.1n

* CHECK dout0_0 Vdout0_0ck123 = 0 time = 2480
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=2480.1n

* CHECK dout0_1 Vdout0_1ck123 = 1.8 time = 2480
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=2480.1n

* CHECK dout0_2 Vdout0_2ck123 = 1.8 time = 2480
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=2480.1n

* CHECK dout0_3 Vdout0_3ck123 = 1.8 time = 2480
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=2480.1n

* CHECK dout0_4 Vdout0_4ck123 = 1.8 time = 2480
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=2480.1n

* CHECK dout0_5 Vdout0_5ck123 = 0 time = 2480
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=2480.1n

* CHECK dout0_6 Vdout0_6ck123 = 1.8 time = 2480
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=2480.1n

* CHECK dout0_7 Vdout0_7ck123 = 0 time = 2480
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=2480.1n

* CHECK dout0_8 Vdout0_8ck123 = 1.8 time = 2480
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=2480.1n

* CHECK dout0_9 Vdout0_9ck123 = 0 time = 2480
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=2480.1n

* CHECK dout0_10 Vdout0_10ck123 = 0 time = 2480
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=2480.1n

* CHECK dout0_11 Vdout0_11ck123 = 0 time = 2480
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=2480.1n

* CHECK dout0_12 Vdout0_12ck123 = 0 time = 2480
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=2480.1n

* CHECK dout0_13 Vdout0_13ck123 = 1.8 time = 2480
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=2480.1n

* CHECK dout0_14 Vdout0_14ck123 = 0 time = 2480
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=2480.1n

* CHECK dout0_15 Vdout0_15ck123 = 0 time = 2480
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=2480.1n

* CHECK dout0_0 Vdout0_0ck125 = 0 time = 2520
.meas tran vdout0_0ck125 FIND v(dout0_0) AT=2520.1n

* CHECK dout0_1 Vdout0_1ck125 = 1.8 time = 2520
.meas tran vdout0_1ck125 FIND v(dout0_1) AT=2520.1n

* CHECK dout0_2 Vdout0_2ck125 = 1.8 time = 2520
.meas tran vdout0_2ck125 FIND v(dout0_2) AT=2520.1n

* CHECK dout0_3 Vdout0_3ck125 = 0 time = 2520
.meas tran vdout0_3ck125 FIND v(dout0_3) AT=2520.1n

* CHECK dout0_4 Vdout0_4ck125 = 0 time = 2520
.meas tran vdout0_4ck125 FIND v(dout0_4) AT=2520.1n

* CHECK dout0_5 Vdout0_5ck125 = 0 time = 2520
.meas tran vdout0_5ck125 FIND v(dout0_5) AT=2520.1n

* CHECK dout0_6 Vdout0_6ck125 = 1.8 time = 2520
.meas tran vdout0_6ck125 FIND v(dout0_6) AT=2520.1n

* CHECK dout0_7 Vdout0_7ck125 = 0 time = 2520
.meas tran vdout0_7ck125 FIND v(dout0_7) AT=2520.1n

* CHECK dout0_8 Vdout0_8ck125 = 1.8 time = 2520
.meas tran vdout0_8ck125 FIND v(dout0_8) AT=2520.1n

* CHECK dout0_9 Vdout0_9ck125 = 0 time = 2520
.meas tran vdout0_9ck125 FIND v(dout0_9) AT=2520.1n

* CHECK dout0_10 Vdout0_10ck125 = 0 time = 2520
.meas tran vdout0_10ck125 FIND v(dout0_10) AT=2520.1n

* CHECK dout0_11 Vdout0_11ck125 = 0 time = 2520
.meas tran vdout0_11ck125 FIND v(dout0_11) AT=2520.1n

* CHECK dout0_12 Vdout0_12ck125 = 1.8 time = 2520
.meas tran vdout0_12ck125 FIND v(dout0_12) AT=2520.1n

* CHECK dout0_13 Vdout0_13ck125 = 1.8 time = 2520
.meas tran vdout0_13ck125 FIND v(dout0_13) AT=2520.1n

* CHECK dout0_14 Vdout0_14ck125 = 1.8 time = 2520
.meas tran vdout0_14ck125 FIND v(dout0_14) AT=2520.1n

* CHECK dout0_15 Vdout0_15ck125 = 1.8 time = 2520
.meas tran vdout0_15ck125 FIND v(dout0_15) AT=2520.1n

* CHECK dout0_0 Vdout0_0ck126 = 1.8 time = 2540
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=2540.1n

* CHECK dout0_1 Vdout0_1ck126 = 1.8 time = 2540
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=2540.1n

* CHECK dout0_2 Vdout0_2ck126 = 1.8 time = 2540
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=2540.1n

* CHECK dout0_3 Vdout0_3ck126 = 1.8 time = 2540
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=2540.1n

* CHECK dout0_4 Vdout0_4ck126 = 0 time = 2540
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=2540.1n

* CHECK dout0_5 Vdout0_5ck126 = 0 time = 2540
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=2540.1n

* CHECK dout0_6 Vdout0_6ck126 = 1.8 time = 2540
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=2540.1n

* CHECK dout0_7 Vdout0_7ck126 = 1.8 time = 2540
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=2540.1n

* CHECK dout0_8 Vdout0_8ck126 = 0 time = 2540
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=2540.1n

* CHECK dout0_9 Vdout0_9ck126 = 0 time = 2540
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=2540.1n

* CHECK dout0_10 Vdout0_10ck126 = 0 time = 2540
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=2540.1n

* CHECK dout0_11 Vdout0_11ck126 = 0 time = 2540
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=2540.1n

* CHECK dout0_12 Vdout0_12ck126 = 1.8 time = 2540
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=2540.1n

* CHECK dout0_13 Vdout0_13ck126 = 0 time = 2540
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=2540.1n

* CHECK dout0_14 Vdout0_14ck126 = 1.8 time = 2540
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=2540.1n

* CHECK dout0_15 Vdout0_15ck126 = 1.8 time = 2540
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=2540.1n

* CHECK dout0_0 Vdout0_0ck127 = 1.8 time = 2560
.meas tran vdout0_0ck127 FIND v(dout0_0) AT=2560.1n

* CHECK dout0_1 Vdout0_1ck127 = 0 time = 2560
.meas tran vdout0_1ck127 FIND v(dout0_1) AT=2560.1n

* CHECK dout0_2 Vdout0_2ck127 = 0 time = 2560
.meas tran vdout0_2ck127 FIND v(dout0_2) AT=2560.1n

* CHECK dout0_3 Vdout0_3ck127 = 1.8 time = 2560
.meas tran vdout0_3ck127 FIND v(dout0_3) AT=2560.1n

* CHECK dout0_4 Vdout0_4ck127 = 0 time = 2560
.meas tran vdout0_4ck127 FIND v(dout0_4) AT=2560.1n

* CHECK dout0_5 Vdout0_5ck127 = 1.8 time = 2560
.meas tran vdout0_5ck127 FIND v(dout0_5) AT=2560.1n

* CHECK dout0_6 Vdout0_6ck127 = 1.8 time = 2560
.meas tran vdout0_6ck127 FIND v(dout0_6) AT=2560.1n

* CHECK dout0_7 Vdout0_7ck127 = 1.8 time = 2560
.meas tran vdout0_7ck127 FIND v(dout0_7) AT=2560.1n

* CHECK dout0_8 Vdout0_8ck127 = 1.8 time = 2560
.meas tran vdout0_8ck127 FIND v(dout0_8) AT=2560.1n

* CHECK dout0_9 Vdout0_9ck127 = 1.8 time = 2560
.meas tran vdout0_9ck127 FIND v(dout0_9) AT=2560.1n

* CHECK dout0_10 Vdout0_10ck127 = 1.8 time = 2560
.meas tran vdout0_10ck127 FIND v(dout0_10) AT=2560.1n

* CHECK dout0_11 Vdout0_11ck127 = 0 time = 2560
.meas tran vdout0_11ck127 FIND v(dout0_11) AT=2560.1n

* CHECK dout0_12 Vdout0_12ck127 = 0 time = 2560
.meas tran vdout0_12ck127 FIND v(dout0_12) AT=2560.1n

* CHECK dout0_13 Vdout0_13ck127 = 0 time = 2560
.meas tran vdout0_13ck127 FIND v(dout0_13) AT=2560.1n

* CHECK dout0_14 Vdout0_14ck127 = 1.8 time = 2560
.meas tran vdout0_14ck127 FIND v(dout0_14) AT=2560.1n

* CHECK dout0_15 Vdout0_15ck127 = 1.8 time = 2560
.meas tran vdout0_15ck127 FIND v(dout0_15) AT=2560.1n

* CHECK dout0_0 Vdout0_0ck129 = 0 time = 2600
.meas tran vdout0_0ck129 FIND v(dout0_0) AT=2600.1n

* CHECK dout0_1 Vdout0_1ck129 = 0 time = 2600
.meas tran vdout0_1ck129 FIND v(dout0_1) AT=2600.1n

* CHECK dout0_2 Vdout0_2ck129 = 0 time = 2600
.meas tran vdout0_2ck129 FIND v(dout0_2) AT=2600.1n

* CHECK dout0_3 Vdout0_3ck129 = 1.8 time = 2600
.meas tran vdout0_3ck129 FIND v(dout0_3) AT=2600.1n

* CHECK dout0_4 Vdout0_4ck129 = 1.8 time = 2600
.meas tran vdout0_4ck129 FIND v(dout0_4) AT=2600.1n

* CHECK dout0_5 Vdout0_5ck129 = 0 time = 2600
.meas tran vdout0_5ck129 FIND v(dout0_5) AT=2600.1n

* CHECK dout0_6 Vdout0_6ck129 = 1.8 time = 2600
.meas tran vdout0_6ck129 FIND v(dout0_6) AT=2600.1n

* CHECK dout0_7 Vdout0_7ck129 = 1.8 time = 2600
.meas tran vdout0_7ck129 FIND v(dout0_7) AT=2600.1n

* CHECK dout0_8 Vdout0_8ck129 = 1.8 time = 2600
.meas tran vdout0_8ck129 FIND v(dout0_8) AT=2600.1n

* CHECK dout0_9 Vdout0_9ck129 = 0 time = 2600
.meas tran vdout0_9ck129 FIND v(dout0_9) AT=2600.1n

* CHECK dout0_10 Vdout0_10ck129 = 1.8 time = 2600
.meas tran vdout0_10ck129 FIND v(dout0_10) AT=2600.1n

* CHECK dout0_11 Vdout0_11ck129 = 1.8 time = 2600
.meas tran vdout0_11ck129 FIND v(dout0_11) AT=2600.1n

* CHECK dout0_12 Vdout0_12ck129 = 0 time = 2600
.meas tran vdout0_12ck129 FIND v(dout0_12) AT=2600.1n

* CHECK dout0_13 Vdout0_13ck129 = 0 time = 2600
.meas tran vdout0_13ck129 FIND v(dout0_13) AT=2600.1n

* CHECK dout0_14 Vdout0_14ck129 = 1.8 time = 2600
.meas tran vdout0_14ck129 FIND v(dout0_14) AT=2600.1n

* CHECK dout0_15 Vdout0_15ck129 = 0 time = 2600
.meas tran vdout0_15ck129 FIND v(dout0_15) AT=2600.1n

* CHECK dout0_0 Vdout0_0ck130 = 1.8 time = 2620
.meas tran vdout0_0ck130 FIND v(dout0_0) AT=2620.1n

* CHECK dout0_1 Vdout0_1ck130 = 0 time = 2620
.meas tran vdout0_1ck130 FIND v(dout0_1) AT=2620.1n

* CHECK dout0_2 Vdout0_2ck130 = 0 time = 2620
.meas tran vdout0_2ck130 FIND v(dout0_2) AT=2620.1n

* CHECK dout0_3 Vdout0_3ck130 = 1.8 time = 2620
.meas tran vdout0_3ck130 FIND v(dout0_3) AT=2620.1n

* CHECK dout0_4 Vdout0_4ck130 = 0 time = 2620
.meas tran vdout0_4ck130 FIND v(dout0_4) AT=2620.1n

* CHECK dout0_5 Vdout0_5ck130 = 1.8 time = 2620
.meas tran vdout0_5ck130 FIND v(dout0_5) AT=2620.1n

* CHECK dout0_6 Vdout0_6ck130 = 1.8 time = 2620
.meas tran vdout0_6ck130 FIND v(dout0_6) AT=2620.1n

* CHECK dout0_7 Vdout0_7ck130 = 1.8 time = 2620
.meas tran vdout0_7ck130 FIND v(dout0_7) AT=2620.1n

* CHECK dout0_8 Vdout0_8ck130 = 1.8 time = 2620
.meas tran vdout0_8ck130 FIND v(dout0_8) AT=2620.1n

* CHECK dout0_9 Vdout0_9ck130 = 1.8 time = 2620
.meas tran vdout0_9ck130 FIND v(dout0_9) AT=2620.1n

* CHECK dout0_10 Vdout0_10ck130 = 1.8 time = 2620
.meas tran vdout0_10ck130 FIND v(dout0_10) AT=2620.1n

* CHECK dout0_11 Vdout0_11ck130 = 0 time = 2620
.meas tran vdout0_11ck130 FIND v(dout0_11) AT=2620.1n

* CHECK dout0_12 Vdout0_12ck130 = 0 time = 2620
.meas tran vdout0_12ck130 FIND v(dout0_12) AT=2620.1n

* CHECK dout0_13 Vdout0_13ck130 = 0 time = 2620
.meas tran vdout0_13ck130 FIND v(dout0_13) AT=2620.1n

* CHECK dout0_14 Vdout0_14ck130 = 1.8 time = 2620
.meas tran vdout0_14ck130 FIND v(dout0_14) AT=2620.1n

* CHECK dout0_15 Vdout0_15ck130 = 1.8 time = 2620
.meas tran vdout0_15ck130 FIND v(dout0_15) AT=2620.1n

* CHECK dout0_0 Vdout0_0ck135 = 0 time = 2720
.meas tran vdout0_0ck135 FIND v(dout0_0) AT=2720.1n

* CHECK dout0_1 Vdout0_1ck135 = 0 time = 2720
.meas tran vdout0_1ck135 FIND v(dout0_1) AT=2720.1n

* CHECK dout0_2 Vdout0_2ck135 = 0 time = 2720
.meas tran vdout0_2ck135 FIND v(dout0_2) AT=2720.1n

* CHECK dout0_3 Vdout0_3ck135 = 1.8 time = 2720
.meas tran vdout0_3ck135 FIND v(dout0_3) AT=2720.1n

* CHECK dout0_4 Vdout0_4ck135 = 1.8 time = 2720
.meas tran vdout0_4ck135 FIND v(dout0_4) AT=2720.1n

* CHECK dout0_5 Vdout0_5ck135 = 0 time = 2720
.meas tran vdout0_5ck135 FIND v(dout0_5) AT=2720.1n

* CHECK dout0_6 Vdout0_6ck135 = 1.8 time = 2720
.meas tran vdout0_6ck135 FIND v(dout0_6) AT=2720.1n

* CHECK dout0_7 Vdout0_7ck135 = 1.8 time = 2720
.meas tran vdout0_7ck135 FIND v(dout0_7) AT=2720.1n

* CHECK dout0_8 Vdout0_8ck135 = 1.8 time = 2720
.meas tran vdout0_8ck135 FIND v(dout0_8) AT=2720.1n

* CHECK dout0_9 Vdout0_9ck135 = 0 time = 2720
.meas tran vdout0_9ck135 FIND v(dout0_9) AT=2720.1n

* CHECK dout0_10 Vdout0_10ck135 = 1.8 time = 2720
.meas tran vdout0_10ck135 FIND v(dout0_10) AT=2720.1n

* CHECK dout0_11 Vdout0_11ck135 = 1.8 time = 2720
.meas tran vdout0_11ck135 FIND v(dout0_11) AT=2720.1n

* CHECK dout0_12 Vdout0_12ck135 = 0 time = 2720
.meas tran vdout0_12ck135 FIND v(dout0_12) AT=2720.1n

* CHECK dout0_13 Vdout0_13ck135 = 0 time = 2720
.meas tran vdout0_13ck135 FIND v(dout0_13) AT=2720.1n

* CHECK dout0_14 Vdout0_14ck135 = 1.8 time = 2720
.meas tran vdout0_14ck135 FIND v(dout0_14) AT=2720.1n

* CHECK dout0_15 Vdout0_15ck135 = 0 time = 2720
.meas tran vdout0_15ck135 FIND v(dout0_15) AT=2720.1n

* CHECK dout0_0 Vdout0_0ck136 = 0 time = 2740
.meas tran vdout0_0ck136 FIND v(dout0_0) AT=2740.1n

* CHECK dout0_1 Vdout0_1ck136 = 0 time = 2740
.meas tran vdout0_1ck136 FIND v(dout0_1) AT=2740.1n

* CHECK dout0_2 Vdout0_2ck136 = 0 time = 2740
.meas tran vdout0_2ck136 FIND v(dout0_2) AT=2740.1n

* CHECK dout0_3 Vdout0_3ck136 = 1.8 time = 2740
.meas tran vdout0_3ck136 FIND v(dout0_3) AT=2740.1n

* CHECK dout0_4 Vdout0_4ck136 = 1.8 time = 2740
.meas tran vdout0_4ck136 FIND v(dout0_4) AT=2740.1n

* CHECK dout0_5 Vdout0_5ck136 = 0 time = 2740
.meas tran vdout0_5ck136 FIND v(dout0_5) AT=2740.1n

* CHECK dout0_6 Vdout0_6ck136 = 1.8 time = 2740
.meas tran vdout0_6ck136 FIND v(dout0_6) AT=2740.1n

* CHECK dout0_7 Vdout0_7ck136 = 1.8 time = 2740
.meas tran vdout0_7ck136 FIND v(dout0_7) AT=2740.1n

* CHECK dout0_8 Vdout0_8ck136 = 1.8 time = 2740
.meas tran vdout0_8ck136 FIND v(dout0_8) AT=2740.1n

* CHECK dout0_9 Vdout0_9ck136 = 0 time = 2740
.meas tran vdout0_9ck136 FIND v(dout0_9) AT=2740.1n

* CHECK dout0_10 Vdout0_10ck136 = 1.8 time = 2740
.meas tran vdout0_10ck136 FIND v(dout0_10) AT=2740.1n

* CHECK dout0_11 Vdout0_11ck136 = 1.8 time = 2740
.meas tran vdout0_11ck136 FIND v(dout0_11) AT=2740.1n

* CHECK dout0_12 Vdout0_12ck136 = 0 time = 2740
.meas tran vdout0_12ck136 FIND v(dout0_12) AT=2740.1n

* CHECK dout0_13 Vdout0_13ck136 = 0 time = 2740
.meas tran vdout0_13ck136 FIND v(dout0_13) AT=2740.1n

* CHECK dout0_14 Vdout0_14ck136 = 1.8 time = 2740
.meas tran vdout0_14ck136 FIND v(dout0_14) AT=2740.1n

* CHECK dout0_15 Vdout0_15ck136 = 0 time = 2740
.meas tran vdout0_15ck136 FIND v(dout0_15) AT=2740.1n

* CHECK dout0_0 Vdout0_0ck141 = 1.8 time = 2840
.meas tran vdout0_0ck141 FIND v(dout0_0) AT=2840.1n

* CHECK dout0_1 Vdout0_1ck141 = 1.8 time = 2840
.meas tran vdout0_1ck141 FIND v(dout0_1) AT=2840.1n

* CHECK dout0_2 Vdout0_2ck141 = 0 time = 2840
.meas tran vdout0_2ck141 FIND v(dout0_2) AT=2840.1n

* CHECK dout0_3 Vdout0_3ck141 = 0 time = 2840
.meas tran vdout0_3ck141 FIND v(dout0_3) AT=2840.1n

* CHECK dout0_4 Vdout0_4ck141 = 1.8 time = 2840
.meas tran vdout0_4ck141 FIND v(dout0_4) AT=2840.1n

* CHECK dout0_5 Vdout0_5ck141 = 1.8 time = 2840
.meas tran vdout0_5ck141 FIND v(dout0_5) AT=2840.1n

* CHECK dout0_6 Vdout0_6ck141 = 0 time = 2840
.meas tran vdout0_6ck141 FIND v(dout0_6) AT=2840.1n

* CHECK dout0_7 Vdout0_7ck141 = 1.8 time = 2840
.meas tran vdout0_7ck141 FIND v(dout0_7) AT=2840.1n

* CHECK dout0_8 Vdout0_8ck141 = 1.8 time = 2840
.meas tran vdout0_8ck141 FIND v(dout0_8) AT=2840.1n

* CHECK dout0_9 Vdout0_9ck141 = 1.8 time = 2840
.meas tran vdout0_9ck141 FIND v(dout0_9) AT=2840.1n

* CHECK dout0_10 Vdout0_10ck141 = 1.8 time = 2840
.meas tran vdout0_10ck141 FIND v(dout0_10) AT=2840.1n

* CHECK dout0_11 Vdout0_11ck141 = 0 time = 2840
.meas tran vdout0_11ck141 FIND v(dout0_11) AT=2840.1n

* CHECK dout0_12 Vdout0_12ck141 = 0 time = 2840
.meas tran vdout0_12ck141 FIND v(dout0_12) AT=2840.1n

* CHECK dout0_13 Vdout0_13ck141 = 1.8 time = 2840
.meas tran vdout0_13ck141 FIND v(dout0_13) AT=2840.1n

* CHECK dout0_14 Vdout0_14ck141 = 1.8 time = 2840
.meas tran vdout0_14ck141 FIND v(dout0_14) AT=2840.1n

* CHECK dout0_15 Vdout0_15ck141 = 1.8 time = 2840
.meas tran vdout0_15ck141 FIND v(dout0_15) AT=2840.1n

* CHECK dout0_0 Vdout0_0ck142 = 1.8 time = 2860
.meas tran vdout0_0ck142 FIND v(dout0_0) AT=2860.1n

* CHECK dout0_1 Vdout0_1ck142 = 1.8 time = 2860
.meas tran vdout0_1ck142 FIND v(dout0_1) AT=2860.1n

* CHECK dout0_2 Vdout0_2ck142 = 0 time = 2860
.meas tran vdout0_2ck142 FIND v(dout0_2) AT=2860.1n

* CHECK dout0_3 Vdout0_3ck142 = 0 time = 2860
.meas tran vdout0_3ck142 FIND v(dout0_3) AT=2860.1n

* CHECK dout0_4 Vdout0_4ck142 = 1.8 time = 2860
.meas tran vdout0_4ck142 FIND v(dout0_4) AT=2860.1n

* CHECK dout0_5 Vdout0_5ck142 = 1.8 time = 2860
.meas tran vdout0_5ck142 FIND v(dout0_5) AT=2860.1n

* CHECK dout0_6 Vdout0_6ck142 = 0 time = 2860
.meas tran vdout0_6ck142 FIND v(dout0_6) AT=2860.1n

* CHECK dout0_7 Vdout0_7ck142 = 1.8 time = 2860
.meas tran vdout0_7ck142 FIND v(dout0_7) AT=2860.1n

* CHECK dout0_8 Vdout0_8ck142 = 1.8 time = 2860
.meas tran vdout0_8ck142 FIND v(dout0_8) AT=2860.1n

* CHECK dout0_9 Vdout0_9ck142 = 1.8 time = 2860
.meas tran vdout0_9ck142 FIND v(dout0_9) AT=2860.1n

* CHECK dout0_10 Vdout0_10ck142 = 1.8 time = 2860
.meas tran vdout0_10ck142 FIND v(dout0_10) AT=2860.1n

* CHECK dout0_11 Vdout0_11ck142 = 0 time = 2860
.meas tran vdout0_11ck142 FIND v(dout0_11) AT=2860.1n

* CHECK dout0_12 Vdout0_12ck142 = 0 time = 2860
.meas tran vdout0_12ck142 FIND v(dout0_12) AT=2860.1n

* CHECK dout0_13 Vdout0_13ck142 = 1.8 time = 2860
.meas tran vdout0_13ck142 FIND v(dout0_13) AT=2860.1n

* CHECK dout0_14 Vdout0_14ck142 = 1.8 time = 2860
.meas tran vdout0_14ck142 FIND v(dout0_14) AT=2860.1n

* CHECK dout0_15 Vdout0_15ck142 = 1.8 time = 2860
.meas tran vdout0_15ck142 FIND v(dout0_15) AT=2860.1n

* CHECK dout0_0 Vdout0_0ck143 = 0 time = 2880
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=2880.1n

* CHECK dout0_1 Vdout0_1ck143 = 1.8 time = 2880
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=2880.1n

* CHECK dout0_2 Vdout0_2ck143 = 1.8 time = 2880
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=2880.1n

* CHECK dout0_3 Vdout0_3ck143 = 1.8 time = 2880
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=2880.1n

* CHECK dout0_4 Vdout0_4ck143 = 1.8 time = 2880
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=2880.1n

* CHECK dout0_5 Vdout0_5ck143 = 0 time = 2880
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=2880.1n

* CHECK dout0_6 Vdout0_6ck143 = 1.8 time = 2880
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=2880.1n

* CHECK dout0_7 Vdout0_7ck143 = 0 time = 2880
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=2880.1n

* CHECK dout0_8 Vdout0_8ck143 = 1.8 time = 2880
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=2880.1n

* CHECK dout0_9 Vdout0_9ck143 = 0 time = 2880
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=2880.1n

* CHECK dout0_10 Vdout0_10ck143 = 0 time = 2880
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=2880.1n

* CHECK dout0_11 Vdout0_11ck143 = 0 time = 2880
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=2880.1n

* CHECK dout0_12 Vdout0_12ck143 = 0 time = 2880
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=2880.1n

* CHECK dout0_13 Vdout0_13ck143 = 1.8 time = 2880
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=2880.1n

* CHECK dout0_14 Vdout0_14ck143 = 0 time = 2880
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=2880.1n

* CHECK dout0_15 Vdout0_15ck143 = 0 time = 2880
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=2880.1n

* CHECK dout0_0 Vdout0_0ck146 = 1.8 time = 2940
.meas tran vdout0_0ck146 FIND v(dout0_0) AT=2940.1n

* CHECK dout0_1 Vdout0_1ck146 = 1.8 time = 2940
.meas tran vdout0_1ck146 FIND v(dout0_1) AT=2940.1n

* CHECK dout0_2 Vdout0_2ck146 = 0 time = 2940
.meas tran vdout0_2ck146 FIND v(dout0_2) AT=2940.1n

* CHECK dout0_3 Vdout0_3ck146 = 0 time = 2940
.meas tran vdout0_3ck146 FIND v(dout0_3) AT=2940.1n

* CHECK dout0_4 Vdout0_4ck146 = 0 time = 2940
.meas tran vdout0_4ck146 FIND v(dout0_4) AT=2940.1n

* CHECK dout0_5 Vdout0_5ck146 = 1.8 time = 2940
.meas tran vdout0_5ck146 FIND v(dout0_5) AT=2940.1n

* CHECK dout0_6 Vdout0_6ck146 = 1.8 time = 2940
.meas tran vdout0_6ck146 FIND v(dout0_6) AT=2940.1n

* CHECK dout0_7 Vdout0_7ck146 = 0 time = 2940
.meas tran vdout0_7ck146 FIND v(dout0_7) AT=2940.1n

* CHECK dout0_8 Vdout0_8ck146 = 1.8 time = 2940
.meas tran vdout0_8ck146 FIND v(dout0_8) AT=2940.1n

* CHECK dout0_9 Vdout0_9ck146 = 1.8 time = 2940
.meas tran vdout0_9ck146 FIND v(dout0_9) AT=2940.1n

* CHECK dout0_10 Vdout0_10ck146 = 1.8 time = 2940
.meas tran vdout0_10ck146 FIND v(dout0_10) AT=2940.1n

* CHECK dout0_11 Vdout0_11ck146 = 0 time = 2940
.meas tran vdout0_11ck146 FIND v(dout0_11) AT=2940.1n

* CHECK dout0_12 Vdout0_12ck146 = 0 time = 2940
.meas tran vdout0_12ck146 FIND v(dout0_12) AT=2940.1n

* CHECK dout0_13 Vdout0_13ck146 = 1.8 time = 2940
.meas tran vdout0_13ck146 FIND v(dout0_13) AT=2940.1n

* CHECK dout0_14 Vdout0_14ck146 = 1.8 time = 2940
.meas tran vdout0_14ck146 FIND v(dout0_14) AT=2940.1n

* CHECK dout0_15 Vdout0_15ck146 = 1.8 time = 2940
.meas tran vdout0_15ck146 FIND v(dout0_15) AT=2940.1n

* CHECK dout0_0 Vdout0_0ck147 = 1.8 time = 2960
.meas tran vdout0_0ck147 FIND v(dout0_0) AT=2960.1n

* CHECK dout0_1 Vdout0_1ck147 = 0 time = 2960
.meas tran vdout0_1ck147 FIND v(dout0_1) AT=2960.1n

* CHECK dout0_2 Vdout0_2ck147 = 1.8 time = 2960
.meas tran vdout0_2ck147 FIND v(dout0_2) AT=2960.1n

* CHECK dout0_3 Vdout0_3ck147 = 1.8 time = 2960
.meas tran vdout0_3ck147 FIND v(dout0_3) AT=2960.1n

* CHECK dout0_4 Vdout0_4ck147 = 1.8 time = 2960
.meas tran vdout0_4ck147 FIND v(dout0_4) AT=2960.1n

* CHECK dout0_5 Vdout0_5ck147 = 1.8 time = 2960
.meas tran vdout0_5ck147 FIND v(dout0_5) AT=2960.1n

* CHECK dout0_6 Vdout0_6ck147 = 0 time = 2960
.meas tran vdout0_6ck147 FIND v(dout0_6) AT=2960.1n

* CHECK dout0_7 Vdout0_7ck147 = 0 time = 2960
.meas tran vdout0_7ck147 FIND v(dout0_7) AT=2960.1n

* CHECK dout0_8 Vdout0_8ck147 = 1.8 time = 2960
.meas tran vdout0_8ck147 FIND v(dout0_8) AT=2960.1n

* CHECK dout0_9 Vdout0_9ck147 = 0 time = 2960
.meas tran vdout0_9ck147 FIND v(dout0_9) AT=2960.1n

* CHECK dout0_10 Vdout0_10ck147 = 0 time = 2960
.meas tran vdout0_10ck147 FIND v(dout0_10) AT=2960.1n

* CHECK dout0_11 Vdout0_11ck147 = 1.8 time = 2960
.meas tran vdout0_11ck147 FIND v(dout0_11) AT=2960.1n

* CHECK dout0_12 Vdout0_12ck147 = 1.8 time = 2960
.meas tran vdout0_12ck147 FIND v(dout0_12) AT=2960.1n

* CHECK dout0_13 Vdout0_13ck147 = 0 time = 2960
.meas tran vdout0_13ck147 FIND v(dout0_13) AT=2960.1n

* CHECK dout0_14 Vdout0_14ck147 = 0 time = 2960
.meas tran vdout0_14ck147 FIND v(dout0_14) AT=2960.1n

* CHECK dout0_15 Vdout0_15ck147 = 0 time = 2960
.meas tran vdout0_15ck147 FIND v(dout0_15) AT=2960.1n

* CHECK dout0_0 Vdout0_0ck149 = 1.8 time = 3000
.meas tran vdout0_0ck149 FIND v(dout0_0) AT=3000.1n

* CHECK dout0_1 Vdout0_1ck149 = 1.8 time = 3000
.meas tran vdout0_1ck149 FIND v(dout0_1) AT=3000.1n

* CHECK dout0_2 Vdout0_2ck149 = 0 time = 3000
.meas tran vdout0_2ck149 FIND v(dout0_2) AT=3000.1n

* CHECK dout0_3 Vdout0_3ck149 = 0 time = 3000
.meas tran vdout0_3ck149 FIND v(dout0_3) AT=3000.1n

* CHECK dout0_4 Vdout0_4ck149 = 0 time = 3000
.meas tran vdout0_4ck149 FIND v(dout0_4) AT=3000.1n

* CHECK dout0_5 Vdout0_5ck149 = 1.8 time = 3000
.meas tran vdout0_5ck149 FIND v(dout0_5) AT=3000.1n

* CHECK dout0_6 Vdout0_6ck149 = 1.8 time = 3000
.meas tran vdout0_6ck149 FIND v(dout0_6) AT=3000.1n

* CHECK dout0_7 Vdout0_7ck149 = 0 time = 3000
.meas tran vdout0_7ck149 FIND v(dout0_7) AT=3000.1n

* CHECK dout0_8 Vdout0_8ck149 = 1.8 time = 3000
.meas tran vdout0_8ck149 FIND v(dout0_8) AT=3000.1n

* CHECK dout0_9 Vdout0_9ck149 = 1.8 time = 3000
.meas tran vdout0_9ck149 FIND v(dout0_9) AT=3000.1n

* CHECK dout0_10 Vdout0_10ck149 = 1.8 time = 3000
.meas tran vdout0_10ck149 FIND v(dout0_10) AT=3000.1n

* CHECK dout0_11 Vdout0_11ck149 = 0 time = 3000
.meas tran vdout0_11ck149 FIND v(dout0_11) AT=3000.1n

* CHECK dout0_12 Vdout0_12ck149 = 0 time = 3000
.meas tran vdout0_12ck149 FIND v(dout0_12) AT=3000.1n

* CHECK dout0_13 Vdout0_13ck149 = 1.8 time = 3000
.meas tran vdout0_13ck149 FIND v(dout0_13) AT=3000.1n

* CHECK dout0_14 Vdout0_14ck149 = 1.8 time = 3000
.meas tran vdout0_14ck149 FIND v(dout0_14) AT=3000.1n

* CHECK dout0_15 Vdout0_15ck149 = 1.8 time = 3000
.meas tran vdout0_15ck149 FIND v(dout0_15) AT=3000.1n

* CHECK dout0_0 Vdout0_0ck150 = 0 time = 3020
.meas tran vdout0_0ck150 FIND v(dout0_0) AT=3020.1n

* CHECK dout0_1 Vdout0_1ck150 = 0 time = 3020
.meas tran vdout0_1ck150 FIND v(dout0_1) AT=3020.1n

* CHECK dout0_2 Vdout0_2ck150 = 0 time = 3020
.meas tran vdout0_2ck150 FIND v(dout0_2) AT=3020.1n

* CHECK dout0_3 Vdout0_3ck150 = 1.8 time = 3020
.meas tran vdout0_3ck150 FIND v(dout0_3) AT=3020.1n

* CHECK dout0_4 Vdout0_4ck150 = 0 time = 3020
.meas tran vdout0_4ck150 FIND v(dout0_4) AT=3020.1n

* CHECK dout0_5 Vdout0_5ck150 = 1.8 time = 3020
.meas tran vdout0_5ck150 FIND v(dout0_5) AT=3020.1n

* CHECK dout0_6 Vdout0_6ck150 = 0 time = 3020
.meas tran vdout0_6ck150 FIND v(dout0_6) AT=3020.1n

* CHECK dout0_7 Vdout0_7ck150 = 0 time = 3020
.meas tran vdout0_7ck150 FIND v(dout0_7) AT=3020.1n

* CHECK dout0_8 Vdout0_8ck150 = 0 time = 3020
.meas tran vdout0_8ck150 FIND v(dout0_8) AT=3020.1n

* CHECK dout0_9 Vdout0_9ck150 = 0 time = 3020
.meas tran vdout0_9ck150 FIND v(dout0_9) AT=3020.1n

* CHECK dout0_10 Vdout0_10ck150 = 1.8 time = 3020
.meas tran vdout0_10ck150 FIND v(dout0_10) AT=3020.1n

* CHECK dout0_11 Vdout0_11ck150 = 1.8 time = 3020
.meas tran vdout0_11ck150 FIND v(dout0_11) AT=3020.1n

* CHECK dout0_12 Vdout0_12ck150 = 1.8 time = 3020
.meas tran vdout0_12ck150 FIND v(dout0_12) AT=3020.1n

* CHECK dout0_13 Vdout0_13ck150 = 1.8 time = 3020
.meas tran vdout0_13ck150 FIND v(dout0_13) AT=3020.1n

* CHECK dout0_14 Vdout0_14ck150 = 1.8 time = 3020
.meas tran vdout0_14ck150 FIND v(dout0_14) AT=3020.1n

* CHECK dout0_15 Vdout0_15ck150 = 0 time = 3020
.meas tran vdout0_15ck150 FIND v(dout0_15) AT=3020.1n

* CHECK dout0_0 Vdout0_0ck151 = 1.8 time = 3040
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=3040.1n

* CHECK dout0_1 Vdout0_1ck151 = 1.8 time = 3040
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=3040.1n

* CHECK dout0_2 Vdout0_2ck151 = 0 time = 3040
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=3040.1n

* CHECK dout0_3 Vdout0_3ck151 = 0 time = 3040
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=3040.1n

* CHECK dout0_4 Vdout0_4ck151 = 0 time = 3040
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=3040.1n

* CHECK dout0_5 Vdout0_5ck151 = 1.8 time = 3040
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=3040.1n

* CHECK dout0_6 Vdout0_6ck151 = 1.8 time = 3040
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=3040.1n

* CHECK dout0_7 Vdout0_7ck151 = 0 time = 3040
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=3040.1n

* CHECK dout0_8 Vdout0_8ck151 = 1.8 time = 3040
.meas tran vdout0_8ck151 FIND v(dout0_8) AT=3040.1n

* CHECK dout0_9 Vdout0_9ck151 = 1.8 time = 3040
.meas tran vdout0_9ck151 FIND v(dout0_9) AT=3040.1n

* CHECK dout0_10 Vdout0_10ck151 = 1.8 time = 3040
.meas tran vdout0_10ck151 FIND v(dout0_10) AT=3040.1n

* CHECK dout0_11 Vdout0_11ck151 = 0 time = 3040
.meas tran vdout0_11ck151 FIND v(dout0_11) AT=3040.1n

* CHECK dout0_12 Vdout0_12ck151 = 0 time = 3040
.meas tran vdout0_12ck151 FIND v(dout0_12) AT=3040.1n

* CHECK dout0_13 Vdout0_13ck151 = 1.8 time = 3040
.meas tran vdout0_13ck151 FIND v(dout0_13) AT=3040.1n

* CHECK dout0_14 Vdout0_14ck151 = 1.8 time = 3040
.meas tran vdout0_14ck151 FIND v(dout0_14) AT=3040.1n

* CHECK dout0_15 Vdout0_15ck151 = 1.8 time = 3040
.meas tran vdout0_15ck151 FIND v(dout0_15) AT=3040.1n

* CHECK dout0_0 Vdout0_0ck155 = 0 time = 3120
.meas tran vdout0_0ck155 FIND v(dout0_0) AT=3120.1n

* CHECK dout0_1 Vdout0_1ck155 = 1.8 time = 3120
.meas tran vdout0_1ck155 FIND v(dout0_1) AT=3120.1n

* CHECK dout0_2 Vdout0_2ck155 = 0 time = 3120
.meas tran vdout0_2ck155 FIND v(dout0_2) AT=3120.1n

* CHECK dout0_3 Vdout0_3ck155 = 1.8 time = 3120
.meas tran vdout0_3ck155 FIND v(dout0_3) AT=3120.1n

* CHECK dout0_4 Vdout0_4ck155 = 1.8 time = 3120
.meas tran vdout0_4ck155 FIND v(dout0_4) AT=3120.1n

* CHECK dout0_5 Vdout0_5ck155 = 1.8 time = 3120
.meas tran vdout0_5ck155 FIND v(dout0_5) AT=3120.1n

* CHECK dout0_6 Vdout0_6ck155 = 0 time = 3120
.meas tran vdout0_6ck155 FIND v(dout0_6) AT=3120.1n

* CHECK dout0_7 Vdout0_7ck155 = 1.8 time = 3120
.meas tran vdout0_7ck155 FIND v(dout0_7) AT=3120.1n

* CHECK dout0_8 Vdout0_8ck155 = 0 time = 3120
.meas tran vdout0_8ck155 FIND v(dout0_8) AT=3120.1n

* CHECK dout0_9 Vdout0_9ck155 = 1.8 time = 3120
.meas tran vdout0_9ck155 FIND v(dout0_9) AT=3120.1n

* CHECK dout0_10 Vdout0_10ck155 = 1.8 time = 3120
.meas tran vdout0_10ck155 FIND v(dout0_10) AT=3120.1n

* CHECK dout0_11 Vdout0_11ck155 = 1.8 time = 3120
.meas tran vdout0_11ck155 FIND v(dout0_11) AT=3120.1n

* CHECK dout0_12 Vdout0_12ck155 = 0 time = 3120
.meas tran vdout0_12ck155 FIND v(dout0_12) AT=3120.1n

* CHECK dout0_13 Vdout0_13ck155 = 1.8 time = 3120
.meas tran vdout0_13ck155 FIND v(dout0_13) AT=3120.1n

* CHECK dout0_14 Vdout0_14ck155 = 0 time = 3120
.meas tran vdout0_14ck155 FIND v(dout0_14) AT=3120.1n

* CHECK dout0_15 Vdout0_15ck155 = 1.8 time = 3120
.meas tran vdout0_15ck155 FIND v(dout0_15) AT=3120.1n

* CHECK dout0_0 Vdout0_0ck157 = 0 time = 3160
.meas tran vdout0_0ck157 FIND v(dout0_0) AT=3160.1n

* CHECK dout0_1 Vdout0_1ck157 = 0 time = 3160
.meas tran vdout0_1ck157 FIND v(dout0_1) AT=3160.1n

* CHECK dout0_2 Vdout0_2ck157 = 0 time = 3160
.meas tran vdout0_2ck157 FIND v(dout0_2) AT=3160.1n

* CHECK dout0_3 Vdout0_3ck157 = 1.8 time = 3160
.meas tran vdout0_3ck157 FIND v(dout0_3) AT=3160.1n

* CHECK dout0_4 Vdout0_4ck157 = 1.8 time = 3160
.meas tran vdout0_4ck157 FIND v(dout0_4) AT=3160.1n

* CHECK dout0_5 Vdout0_5ck157 = 0 time = 3160
.meas tran vdout0_5ck157 FIND v(dout0_5) AT=3160.1n

* CHECK dout0_6 Vdout0_6ck157 = 1.8 time = 3160
.meas tran vdout0_6ck157 FIND v(dout0_6) AT=3160.1n

* CHECK dout0_7 Vdout0_7ck157 = 1.8 time = 3160
.meas tran vdout0_7ck157 FIND v(dout0_7) AT=3160.1n

* CHECK dout0_8 Vdout0_8ck157 = 1.8 time = 3160
.meas tran vdout0_8ck157 FIND v(dout0_8) AT=3160.1n

* CHECK dout0_9 Vdout0_9ck157 = 0 time = 3160
.meas tran vdout0_9ck157 FIND v(dout0_9) AT=3160.1n

* CHECK dout0_10 Vdout0_10ck157 = 1.8 time = 3160
.meas tran vdout0_10ck157 FIND v(dout0_10) AT=3160.1n

* CHECK dout0_11 Vdout0_11ck157 = 1.8 time = 3160
.meas tran vdout0_11ck157 FIND v(dout0_11) AT=3160.1n

* CHECK dout0_12 Vdout0_12ck157 = 0 time = 3160
.meas tran vdout0_12ck157 FIND v(dout0_12) AT=3160.1n

* CHECK dout0_13 Vdout0_13ck157 = 0 time = 3160
.meas tran vdout0_13ck157 FIND v(dout0_13) AT=3160.1n

* CHECK dout0_14 Vdout0_14ck157 = 1.8 time = 3160
.meas tran vdout0_14ck157 FIND v(dout0_14) AT=3160.1n

* CHECK dout0_15 Vdout0_15ck157 = 0 time = 3160
.meas tran vdout0_15ck157 FIND v(dout0_15) AT=3160.1n

* CHECK dout0_0 Vdout0_0ck159 = 0 time = 3200
.meas tran vdout0_0ck159 FIND v(dout0_0) AT=3200.1n

* CHECK dout0_1 Vdout0_1ck159 = 1.8 time = 3200
.meas tran vdout0_1ck159 FIND v(dout0_1) AT=3200.1n

* CHECK dout0_2 Vdout0_2ck159 = 0 time = 3200
.meas tran vdout0_2ck159 FIND v(dout0_2) AT=3200.1n

* CHECK dout0_3 Vdout0_3ck159 = 1.8 time = 3200
.meas tran vdout0_3ck159 FIND v(dout0_3) AT=3200.1n

* CHECK dout0_4 Vdout0_4ck159 = 1.8 time = 3200
.meas tran vdout0_4ck159 FIND v(dout0_4) AT=3200.1n

* CHECK dout0_5 Vdout0_5ck159 = 1.8 time = 3200
.meas tran vdout0_5ck159 FIND v(dout0_5) AT=3200.1n

* CHECK dout0_6 Vdout0_6ck159 = 0 time = 3200
.meas tran vdout0_6ck159 FIND v(dout0_6) AT=3200.1n

* CHECK dout0_7 Vdout0_7ck159 = 1.8 time = 3200
.meas tran vdout0_7ck159 FIND v(dout0_7) AT=3200.1n

* CHECK dout0_8 Vdout0_8ck159 = 0 time = 3200
.meas tran vdout0_8ck159 FIND v(dout0_8) AT=3200.1n

* CHECK dout0_9 Vdout0_9ck159 = 1.8 time = 3200
.meas tran vdout0_9ck159 FIND v(dout0_9) AT=3200.1n

* CHECK dout0_10 Vdout0_10ck159 = 1.8 time = 3200
.meas tran vdout0_10ck159 FIND v(dout0_10) AT=3200.1n

* CHECK dout0_11 Vdout0_11ck159 = 1.8 time = 3200
.meas tran vdout0_11ck159 FIND v(dout0_11) AT=3200.1n

* CHECK dout0_12 Vdout0_12ck159 = 0 time = 3200
.meas tran vdout0_12ck159 FIND v(dout0_12) AT=3200.1n

* CHECK dout0_13 Vdout0_13ck159 = 1.8 time = 3200
.meas tran vdout0_13ck159 FIND v(dout0_13) AT=3200.1n

* CHECK dout0_14 Vdout0_14ck159 = 0 time = 3200
.meas tran vdout0_14ck159 FIND v(dout0_14) AT=3200.1n

* CHECK dout0_15 Vdout0_15ck159 = 1.8 time = 3200
.meas tran vdout0_15ck159 FIND v(dout0_15) AT=3200.1n

* CHECK dout0_0 Vdout0_0ck160 = 1.8 time = 3220
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=3220.1n

* CHECK dout0_1 Vdout0_1ck160 = 1.8 time = 3220
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=3220.1n

* CHECK dout0_2 Vdout0_2ck160 = 1.8 time = 3220
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=3220.1n

* CHECK dout0_3 Vdout0_3ck160 = 0 time = 3220
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=3220.1n

* CHECK dout0_4 Vdout0_4ck160 = 0 time = 3220
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=3220.1n

* CHECK dout0_5 Vdout0_5ck160 = 0 time = 3220
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=3220.1n

* CHECK dout0_6 Vdout0_6ck160 = 0 time = 3220
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=3220.1n

* CHECK dout0_7 Vdout0_7ck160 = 0 time = 3220
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=3220.1n

* CHECK dout0_8 Vdout0_8ck160 = 1.8 time = 3220
.meas tran vdout0_8ck160 FIND v(dout0_8) AT=3220.1n

* CHECK dout0_9 Vdout0_9ck160 = 1.8 time = 3220
.meas tran vdout0_9ck160 FIND v(dout0_9) AT=3220.1n

* CHECK dout0_10 Vdout0_10ck160 = 1.8 time = 3220
.meas tran vdout0_10ck160 FIND v(dout0_10) AT=3220.1n

* CHECK dout0_11 Vdout0_11ck160 = 1.8 time = 3220
.meas tran vdout0_11ck160 FIND v(dout0_11) AT=3220.1n

* CHECK dout0_12 Vdout0_12ck160 = 1.8 time = 3220
.meas tran vdout0_12ck160 FIND v(dout0_12) AT=3220.1n

* CHECK dout0_13 Vdout0_13ck160 = 0 time = 3220
.meas tran vdout0_13ck160 FIND v(dout0_13) AT=3220.1n

* CHECK dout0_14 Vdout0_14ck160 = 0 time = 3220
.meas tran vdout0_14ck160 FIND v(dout0_14) AT=3220.1n

* CHECK dout0_15 Vdout0_15ck160 = 0 time = 3220
.meas tran vdout0_15ck160 FIND v(dout0_15) AT=3220.1n

* CHECK dout0_0 Vdout0_0ck169 = 0 time = 3400
.meas tran vdout0_0ck169 FIND v(dout0_0) AT=3400.1n

* CHECK dout0_1 Vdout0_1ck169 = 0 time = 3400
.meas tran vdout0_1ck169 FIND v(dout0_1) AT=3400.1n

* CHECK dout0_2 Vdout0_2ck169 = 1.8 time = 3400
.meas tran vdout0_2ck169 FIND v(dout0_2) AT=3400.1n

* CHECK dout0_3 Vdout0_3ck169 = 1.8 time = 3400
.meas tran vdout0_3ck169 FIND v(dout0_3) AT=3400.1n

* CHECK dout0_4 Vdout0_4ck169 = 0 time = 3400
.meas tran vdout0_4ck169 FIND v(dout0_4) AT=3400.1n

* CHECK dout0_5 Vdout0_5ck169 = 0 time = 3400
.meas tran vdout0_5ck169 FIND v(dout0_5) AT=3400.1n

* CHECK dout0_6 Vdout0_6ck169 = 1.8 time = 3400
.meas tran vdout0_6ck169 FIND v(dout0_6) AT=3400.1n

* CHECK dout0_7 Vdout0_7ck169 = 1.8 time = 3400
.meas tran vdout0_7ck169 FIND v(dout0_7) AT=3400.1n

* CHECK dout0_8 Vdout0_8ck169 = 0 time = 3400
.meas tran vdout0_8ck169 FIND v(dout0_8) AT=3400.1n

* CHECK dout0_9 Vdout0_9ck169 = 1.8 time = 3400
.meas tran vdout0_9ck169 FIND v(dout0_9) AT=3400.1n

* CHECK dout0_10 Vdout0_10ck169 = 0 time = 3400
.meas tran vdout0_10ck169 FIND v(dout0_10) AT=3400.1n

* CHECK dout0_11 Vdout0_11ck169 = 0 time = 3400
.meas tran vdout0_11ck169 FIND v(dout0_11) AT=3400.1n

* CHECK dout0_12 Vdout0_12ck169 = 0 time = 3400
.meas tran vdout0_12ck169 FIND v(dout0_12) AT=3400.1n

* CHECK dout0_13 Vdout0_13ck169 = 1.8 time = 3400
.meas tran vdout0_13ck169 FIND v(dout0_13) AT=3400.1n

* CHECK dout0_14 Vdout0_14ck169 = 0 time = 3400
.meas tran vdout0_14ck169 FIND v(dout0_14) AT=3400.1n

* CHECK dout0_15 Vdout0_15ck169 = 0 time = 3400
.meas tran vdout0_15ck169 FIND v(dout0_15) AT=3400.1n

* CHECK dout0_0 Vdout0_0ck170 = 1.8 time = 3420
.meas tran vdout0_0ck170 FIND v(dout0_0) AT=3420.1n

* CHECK dout0_1 Vdout0_1ck170 = 0 time = 3420
.meas tran vdout0_1ck170 FIND v(dout0_1) AT=3420.1n

* CHECK dout0_2 Vdout0_2ck170 = 1.8 time = 3420
.meas tran vdout0_2ck170 FIND v(dout0_2) AT=3420.1n

* CHECK dout0_3 Vdout0_3ck170 = 1.8 time = 3420
.meas tran vdout0_3ck170 FIND v(dout0_3) AT=3420.1n

* CHECK dout0_4 Vdout0_4ck170 = 1.8 time = 3420
.meas tran vdout0_4ck170 FIND v(dout0_4) AT=3420.1n

* CHECK dout0_5 Vdout0_5ck170 = 1.8 time = 3420
.meas tran vdout0_5ck170 FIND v(dout0_5) AT=3420.1n

* CHECK dout0_6 Vdout0_6ck170 = 0 time = 3420
.meas tran vdout0_6ck170 FIND v(dout0_6) AT=3420.1n

* CHECK dout0_7 Vdout0_7ck170 = 0 time = 3420
.meas tran vdout0_7ck170 FIND v(dout0_7) AT=3420.1n

* CHECK dout0_8 Vdout0_8ck170 = 1.8 time = 3420
.meas tran vdout0_8ck170 FIND v(dout0_8) AT=3420.1n

* CHECK dout0_9 Vdout0_9ck170 = 0 time = 3420
.meas tran vdout0_9ck170 FIND v(dout0_9) AT=3420.1n

* CHECK dout0_10 Vdout0_10ck170 = 0 time = 3420
.meas tran vdout0_10ck170 FIND v(dout0_10) AT=3420.1n

* CHECK dout0_11 Vdout0_11ck170 = 1.8 time = 3420
.meas tran vdout0_11ck170 FIND v(dout0_11) AT=3420.1n

* CHECK dout0_12 Vdout0_12ck170 = 1.8 time = 3420
.meas tran vdout0_12ck170 FIND v(dout0_12) AT=3420.1n

* CHECK dout0_13 Vdout0_13ck170 = 0 time = 3420
.meas tran vdout0_13ck170 FIND v(dout0_13) AT=3420.1n

* CHECK dout0_14 Vdout0_14ck170 = 0 time = 3420
.meas tran vdout0_14ck170 FIND v(dout0_14) AT=3420.1n

* CHECK dout0_15 Vdout0_15ck170 = 0 time = 3420
.meas tran vdout0_15ck170 FIND v(dout0_15) AT=3420.1n

* CHECK dout0_0 Vdout0_0ck171 = 0 time = 3440
.meas tran vdout0_0ck171 FIND v(dout0_0) AT=3440.1n

* CHECK dout0_1 Vdout0_1ck171 = 0 time = 3440
.meas tran vdout0_1ck171 FIND v(dout0_1) AT=3440.1n

* CHECK dout0_2 Vdout0_2ck171 = 1.8 time = 3440
.meas tran vdout0_2ck171 FIND v(dout0_2) AT=3440.1n

* CHECK dout0_3 Vdout0_3ck171 = 1.8 time = 3440
.meas tran vdout0_3ck171 FIND v(dout0_3) AT=3440.1n

* CHECK dout0_4 Vdout0_4ck171 = 0 time = 3440
.meas tran vdout0_4ck171 FIND v(dout0_4) AT=3440.1n

* CHECK dout0_5 Vdout0_5ck171 = 0 time = 3440
.meas tran vdout0_5ck171 FIND v(dout0_5) AT=3440.1n

* CHECK dout0_6 Vdout0_6ck171 = 1.8 time = 3440
.meas tran vdout0_6ck171 FIND v(dout0_6) AT=3440.1n

* CHECK dout0_7 Vdout0_7ck171 = 1.8 time = 3440
.meas tran vdout0_7ck171 FIND v(dout0_7) AT=3440.1n

* CHECK dout0_8 Vdout0_8ck171 = 0 time = 3440
.meas tran vdout0_8ck171 FIND v(dout0_8) AT=3440.1n

* CHECK dout0_9 Vdout0_9ck171 = 1.8 time = 3440
.meas tran vdout0_9ck171 FIND v(dout0_9) AT=3440.1n

* CHECK dout0_10 Vdout0_10ck171 = 0 time = 3440
.meas tran vdout0_10ck171 FIND v(dout0_10) AT=3440.1n

* CHECK dout0_11 Vdout0_11ck171 = 0 time = 3440
.meas tran vdout0_11ck171 FIND v(dout0_11) AT=3440.1n

* CHECK dout0_12 Vdout0_12ck171 = 0 time = 3440
.meas tran vdout0_12ck171 FIND v(dout0_12) AT=3440.1n

* CHECK dout0_13 Vdout0_13ck171 = 1.8 time = 3440
.meas tran vdout0_13ck171 FIND v(dout0_13) AT=3440.1n

* CHECK dout0_14 Vdout0_14ck171 = 0 time = 3440
.meas tran vdout0_14ck171 FIND v(dout0_14) AT=3440.1n

* CHECK dout0_15 Vdout0_15ck171 = 0 time = 3440
.meas tran vdout0_15ck171 FIND v(dout0_15) AT=3440.1n

* CHECK dout0_0 Vdout0_0ck173 = 1.8 time = 3480
.meas tran vdout0_0ck173 FIND v(dout0_0) AT=3480.1n

* CHECK dout0_1 Vdout0_1ck173 = 0 time = 3480
.meas tran vdout0_1ck173 FIND v(dout0_1) AT=3480.1n

* CHECK dout0_2 Vdout0_2ck173 = 1.8 time = 3480
.meas tran vdout0_2ck173 FIND v(dout0_2) AT=3480.1n

* CHECK dout0_3 Vdout0_3ck173 = 0 time = 3480
.meas tran vdout0_3ck173 FIND v(dout0_3) AT=3480.1n

* CHECK dout0_4 Vdout0_4ck173 = 1.8 time = 3480
.meas tran vdout0_4ck173 FIND v(dout0_4) AT=3480.1n

* CHECK dout0_5 Vdout0_5ck173 = 0 time = 3480
.meas tran vdout0_5ck173 FIND v(dout0_5) AT=3480.1n

* CHECK dout0_6 Vdout0_6ck173 = 1.8 time = 3480
.meas tran vdout0_6ck173 FIND v(dout0_6) AT=3480.1n

* CHECK dout0_7 Vdout0_7ck173 = 0 time = 3480
.meas tran vdout0_7ck173 FIND v(dout0_7) AT=3480.1n

* CHECK dout0_8 Vdout0_8ck173 = 0 time = 3480
.meas tran vdout0_8ck173 FIND v(dout0_8) AT=3480.1n

* CHECK dout0_9 Vdout0_9ck173 = 0 time = 3480
.meas tran vdout0_9ck173 FIND v(dout0_9) AT=3480.1n

* CHECK dout0_10 Vdout0_10ck173 = 0 time = 3480
.meas tran vdout0_10ck173 FIND v(dout0_10) AT=3480.1n

* CHECK dout0_11 Vdout0_11ck173 = 1.8 time = 3480
.meas tran vdout0_11ck173 FIND v(dout0_11) AT=3480.1n

* CHECK dout0_12 Vdout0_12ck173 = 1.8 time = 3480
.meas tran vdout0_12ck173 FIND v(dout0_12) AT=3480.1n

* CHECK dout0_13 Vdout0_13ck173 = 0 time = 3480
.meas tran vdout0_13ck173 FIND v(dout0_13) AT=3480.1n

* CHECK dout0_14 Vdout0_14ck173 = 1.8 time = 3480
.meas tran vdout0_14ck173 FIND v(dout0_14) AT=3480.1n

* CHECK dout0_15 Vdout0_15ck173 = 0 time = 3480
.meas tran vdout0_15ck173 FIND v(dout0_15) AT=3480.1n

* CHECK dout0_0 Vdout0_0ck175 = 0 time = 3520
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=3520.1n

* CHECK dout0_1 Vdout0_1ck175 = 1.8 time = 3520
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=3520.1n

* CHECK dout0_2 Vdout0_2ck175 = 1.8 time = 3520
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=3520.1n

* CHECK dout0_3 Vdout0_3ck175 = 1.8 time = 3520
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=3520.1n

* CHECK dout0_4 Vdout0_4ck175 = 0 time = 3520
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=3520.1n

* CHECK dout0_5 Vdout0_5ck175 = 0 time = 3520
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=3520.1n

* CHECK dout0_6 Vdout0_6ck175 = 0 time = 3520
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=3520.1n

* CHECK dout0_7 Vdout0_7ck175 = 0 time = 3520
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=3520.1n

* CHECK dout0_8 Vdout0_8ck175 = 1.8 time = 3520
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=3520.1n

* CHECK dout0_9 Vdout0_9ck175 = 0 time = 3520
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=3520.1n

* CHECK dout0_10 Vdout0_10ck175 = 0 time = 3520
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=3520.1n

* CHECK dout0_11 Vdout0_11ck175 = 1.8 time = 3520
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=3520.1n

* CHECK dout0_12 Vdout0_12ck175 = 1.8 time = 3520
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=3520.1n

* CHECK dout0_13 Vdout0_13ck175 = 1.8 time = 3520
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=3520.1n

* CHECK dout0_14 Vdout0_14ck175 = 0 time = 3520
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=3520.1n

* CHECK dout0_15 Vdout0_15ck175 = 0 time = 3520
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=3520.1n

* CHECK dout0_0 Vdout0_0ck178 = 1.8 time = 3580
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=3580.1n

* CHECK dout0_1 Vdout0_1ck178 = 1.8 time = 3580
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=3580.1n

* CHECK dout0_2 Vdout0_2ck178 = 0 time = 3580
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=3580.1n

* CHECK dout0_3 Vdout0_3ck178 = 0 time = 3580
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=3580.1n

* CHECK dout0_4 Vdout0_4ck178 = 1.8 time = 3580
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=3580.1n

* CHECK dout0_5 Vdout0_5ck178 = 1.8 time = 3580
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=3580.1n

* CHECK dout0_6 Vdout0_6ck178 = 0 time = 3580
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=3580.1n

* CHECK dout0_7 Vdout0_7ck178 = 1.8 time = 3580
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=3580.1n

* CHECK dout0_8 Vdout0_8ck178 = 1.8 time = 3580
.meas tran vdout0_8ck178 FIND v(dout0_8) AT=3580.1n

* CHECK dout0_9 Vdout0_9ck178 = 1.8 time = 3580
.meas tran vdout0_9ck178 FIND v(dout0_9) AT=3580.1n

* CHECK dout0_10 Vdout0_10ck178 = 1.8 time = 3580
.meas tran vdout0_10ck178 FIND v(dout0_10) AT=3580.1n

* CHECK dout0_11 Vdout0_11ck178 = 0 time = 3580
.meas tran vdout0_11ck178 FIND v(dout0_11) AT=3580.1n

* CHECK dout0_12 Vdout0_12ck178 = 0 time = 3580
.meas tran vdout0_12ck178 FIND v(dout0_12) AT=3580.1n

* CHECK dout0_13 Vdout0_13ck178 = 1.8 time = 3580
.meas tran vdout0_13ck178 FIND v(dout0_13) AT=3580.1n

* CHECK dout0_14 Vdout0_14ck178 = 1.8 time = 3580
.meas tran vdout0_14ck178 FIND v(dout0_14) AT=3580.1n

* CHECK dout0_15 Vdout0_15ck178 = 1.8 time = 3580
.meas tran vdout0_15ck178 FIND v(dout0_15) AT=3580.1n

* CHECK dout0_0 Vdout0_0ck179 = 1.8 time = 3600
.meas tran vdout0_0ck179 FIND v(dout0_0) AT=3600.1n

* CHECK dout0_1 Vdout0_1ck179 = 1.8 time = 3600
.meas tran vdout0_1ck179 FIND v(dout0_1) AT=3600.1n

* CHECK dout0_2 Vdout0_2ck179 = 1.8 time = 3600
.meas tran vdout0_2ck179 FIND v(dout0_2) AT=3600.1n

* CHECK dout0_3 Vdout0_3ck179 = 0 time = 3600
.meas tran vdout0_3ck179 FIND v(dout0_3) AT=3600.1n

* CHECK dout0_4 Vdout0_4ck179 = 0 time = 3600
.meas tran vdout0_4ck179 FIND v(dout0_4) AT=3600.1n

* CHECK dout0_5 Vdout0_5ck179 = 0 time = 3600
.meas tran vdout0_5ck179 FIND v(dout0_5) AT=3600.1n

* CHECK dout0_6 Vdout0_6ck179 = 0 time = 3600
.meas tran vdout0_6ck179 FIND v(dout0_6) AT=3600.1n

* CHECK dout0_7 Vdout0_7ck179 = 0 time = 3600
.meas tran vdout0_7ck179 FIND v(dout0_7) AT=3600.1n

* CHECK dout0_8 Vdout0_8ck179 = 1.8 time = 3600
.meas tran vdout0_8ck179 FIND v(dout0_8) AT=3600.1n

* CHECK dout0_9 Vdout0_9ck179 = 1.8 time = 3600
.meas tran vdout0_9ck179 FIND v(dout0_9) AT=3600.1n

* CHECK dout0_10 Vdout0_10ck179 = 1.8 time = 3600
.meas tran vdout0_10ck179 FIND v(dout0_10) AT=3600.1n

* CHECK dout0_11 Vdout0_11ck179 = 1.8 time = 3600
.meas tran vdout0_11ck179 FIND v(dout0_11) AT=3600.1n

* CHECK dout0_12 Vdout0_12ck179 = 1.8 time = 3600
.meas tran vdout0_12ck179 FIND v(dout0_12) AT=3600.1n

* CHECK dout0_13 Vdout0_13ck179 = 0 time = 3600
.meas tran vdout0_13ck179 FIND v(dout0_13) AT=3600.1n

* CHECK dout0_14 Vdout0_14ck179 = 0 time = 3600
.meas tran vdout0_14ck179 FIND v(dout0_14) AT=3600.1n

* CHECK dout0_15 Vdout0_15ck179 = 0 time = 3600
.meas tran vdout0_15ck179 FIND v(dout0_15) AT=3600.1n

* CHECK dout0_0 Vdout0_0ck186 = 1.8 time = 3740
.meas tran vdout0_0ck186 FIND v(dout0_0) AT=3740.1n

* CHECK dout0_1 Vdout0_1ck186 = 1.8 time = 3740
.meas tran vdout0_1ck186 FIND v(dout0_1) AT=3740.1n

* CHECK dout0_2 Vdout0_2ck186 = 0 time = 3740
.meas tran vdout0_2ck186 FIND v(dout0_2) AT=3740.1n

* CHECK dout0_3 Vdout0_3ck186 = 1.8 time = 3740
.meas tran vdout0_3ck186 FIND v(dout0_3) AT=3740.1n

* CHECK dout0_4 Vdout0_4ck186 = 1.8 time = 3740
.meas tran vdout0_4ck186 FIND v(dout0_4) AT=3740.1n

* CHECK dout0_5 Vdout0_5ck186 = 0 time = 3740
.meas tran vdout0_5ck186 FIND v(dout0_5) AT=3740.1n

* CHECK dout0_6 Vdout0_6ck186 = 1.8 time = 3740
.meas tran vdout0_6ck186 FIND v(dout0_6) AT=3740.1n

* CHECK dout0_7 Vdout0_7ck186 = 1.8 time = 3740
.meas tran vdout0_7ck186 FIND v(dout0_7) AT=3740.1n

* CHECK dout0_8 Vdout0_8ck186 = 1.8 time = 3740
.meas tran vdout0_8ck186 FIND v(dout0_8) AT=3740.1n

* CHECK dout0_9 Vdout0_9ck186 = 1.8 time = 3740
.meas tran vdout0_9ck186 FIND v(dout0_9) AT=3740.1n

* CHECK dout0_10 Vdout0_10ck186 = 0 time = 3740
.meas tran vdout0_10ck186 FIND v(dout0_10) AT=3740.1n

* CHECK dout0_11 Vdout0_11ck186 = 1.8 time = 3740
.meas tran vdout0_11ck186 FIND v(dout0_11) AT=3740.1n

* CHECK dout0_12 Vdout0_12ck186 = 0 time = 3740
.meas tran vdout0_12ck186 FIND v(dout0_12) AT=3740.1n

* CHECK dout0_13 Vdout0_13ck186 = 0 time = 3740
.meas tran vdout0_13ck186 FIND v(dout0_13) AT=3740.1n

* CHECK dout0_14 Vdout0_14ck186 = 1.8 time = 3740
.meas tran vdout0_14ck186 FIND v(dout0_14) AT=3740.1n

* CHECK dout0_15 Vdout0_15ck186 = 1.8 time = 3740
.meas tran vdout0_15ck186 FIND v(dout0_15) AT=3740.1n

* CHECK dout0_0 Vdout0_0ck193 = 1.8 time = 3880
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=3880.1n

* CHECK dout0_1 Vdout0_1ck193 = 1.8 time = 3880
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=3880.1n

* CHECK dout0_2 Vdout0_2ck193 = 1.8 time = 3880
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=3880.1n

* CHECK dout0_3 Vdout0_3ck193 = 1.8 time = 3880
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=3880.1n

* CHECK dout0_4 Vdout0_4ck193 = 0 time = 3880
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=3880.1n

* CHECK dout0_5 Vdout0_5ck193 = 0 time = 3880
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=3880.1n

* CHECK dout0_6 Vdout0_6ck193 = 1.8 time = 3880
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=3880.1n

* CHECK dout0_7 Vdout0_7ck193 = 0 time = 3880
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=3880.1n

* CHECK dout0_8 Vdout0_8ck193 = 1.8 time = 3880
.meas tran vdout0_8ck193 FIND v(dout0_8) AT=3880.1n

* CHECK dout0_9 Vdout0_9ck193 = 0 time = 3880
.meas tran vdout0_9ck193 FIND v(dout0_9) AT=3880.1n

* CHECK dout0_10 Vdout0_10ck193 = 0 time = 3880
.meas tran vdout0_10ck193 FIND v(dout0_10) AT=3880.1n

* CHECK dout0_11 Vdout0_11ck193 = 1.8 time = 3880
.meas tran vdout0_11ck193 FIND v(dout0_11) AT=3880.1n

* CHECK dout0_12 Vdout0_12ck193 = 0 time = 3880
.meas tran vdout0_12ck193 FIND v(dout0_12) AT=3880.1n

* CHECK dout0_13 Vdout0_13ck193 = 1.8 time = 3880
.meas tran vdout0_13ck193 FIND v(dout0_13) AT=3880.1n

* CHECK dout0_14 Vdout0_14ck193 = 1.8 time = 3880
.meas tran vdout0_14ck193 FIND v(dout0_14) AT=3880.1n

* CHECK dout0_15 Vdout0_15ck193 = 1.8 time = 3880
.meas tran vdout0_15ck193 FIND v(dout0_15) AT=3880.1n

* CHECK dout0_0 Vdout0_0ck195 = 1.8 time = 3920
.meas tran vdout0_0ck195 FIND v(dout0_0) AT=3920.1n

* CHECK dout0_1 Vdout0_1ck195 = 0 time = 3920
.meas tran vdout0_1ck195 FIND v(dout0_1) AT=3920.1n

* CHECK dout0_2 Vdout0_2ck195 = 0 time = 3920
.meas tran vdout0_2ck195 FIND v(dout0_2) AT=3920.1n

* CHECK dout0_3 Vdout0_3ck195 = 1.8 time = 3920
.meas tran vdout0_3ck195 FIND v(dout0_3) AT=3920.1n

* CHECK dout0_4 Vdout0_4ck195 = 1.8 time = 3920
.meas tran vdout0_4ck195 FIND v(dout0_4) AT=3920.1n

* CHECK dout0_5 Vdout0_5ck195 = 1.8 time = 3920
.meas tran vdout0_5ck195 FIND v(dout0_5) AT=3920.1n

* CHECK dout0_6 Vdout0_6ck195 = 1.8 time = 3920
.meas tran vdout0_6ck195 FIND v(dout0_6) AT=3920.1n

* CHECK dout0_7 Vdout0_7ck195 = 0 time = 3920
.meas tran vdout0_7ck195 FIND v(dout0_7) AT=3920.1n

* CHECK dout0_8 Vdout0_8ck195 = 0 time = 3920
.meas tran vdout0_8ck195 FIND v(dout0_8) AT=3920.1n

* CHECK dout0_9 Vdout0_9ck195 = 1.8 time = 3920
.meas tran vdout0_9ck195 FIND v(dout0_9) AT=3920.1n

* CHECK dout0_10 Vdout0_10ck195 = 1.8 time = 3920
.meas tran vdout0_10ck195 FIND v(dout0_10) AT=3920.1n

* CHECK dout0_11 Vdout0_11ck195 = 1.8 time = 3920
.meas tran vdout0_11ck195 FIND v(dout0_11) AT=3920.1n

* CHECK dout0_12 Vdout0_12ck195 = 1.8 time = 3920
.meas tran vdout0_12ck195 FIND v(dout0_12) AT=3920.1n

* CHECK dout0_13 Vdout0_13ck195 = 1.8 time = 3920
.meas tran vdout0_13ck195 FIND v(dout0_13) AT=3920.1n

* CHECK dout0_14 Vdout0_14ck195 = 0 time = 3920
.meas tran vdout0_14ck195 FIND v(dout0_14) AT=3920.1n

* CHECK dout0_15 Vdout0_15ck195 = 1.8 time = 3920
.meas tran vdout0_15ck195 FIND v(dout0_15) AT=3920.1n

* CHECK dout0_0 Vdout0_0ck198 = 1.8 time = 3980
.meas tran vdout0_0ck198 FIND v(dout0_0) AT=3980.1n

* CHECK dout0_1 Vdout0_1ck198 = 1.8 time = 3980
.meas tran vdout0_1ck198 FIND v(dout0_1) AT=3980.1n

* CHECK dout0_2 Vdout0_2ck198 = 1.8 time = 3980
.meas tran vdout0_2ck198 FIND v(dout0_2) AT=3980.1n

* CHECK dout0_3 Vdout0_3ck198 = 0 time = 3980
.meas tran vdout0_3ck198 FIND v(dout0_3) AT=3980.1n

* CHECK dout0_4 Vdout0_4ck198 = 0 time = 3980
.meas tran vdout0_4ck198 FIND v(dout0_4) AT=3980.1n

* CHECK dout0_5 Vdout0_5ck198 = 1.8 time = 3980
.meas tran vdout0_5ck198 FIND v(dout0_5) AT=3980.1n

* CHECK dout0_6 Vdout0_6ck198 = 1.8 time = 3980
.meas tran vdout0_6ck198 FIND v(dout0_6) AT=3980.1n

* CHECK dout0_7 Vdout0_7ck198 = 0 time = 3980
.meas tran vdout0_7ck198 FIND v(dout0_7) AT=3980.1n

* CHECK dout0_8 Vdout0_8ck198 = 0 time = 3980
.meas tran vdout0_8ck198 FIND v(dout0_8) AT=3980.1n

* CHECK dout0_9 Vdout0_9ck198 = 0 time = 3980
.meas tran vdout0_9ck198 FIND v(dout0_9) AT=3980.1n

* CHECK dout0_10 Vdout0_10ck198 = 1.8 time = 3980
.meas tran vdout0_10ck198 FIND v(dout0_10) AT=3980.1n

* CHECK dout0_11 Vdout0_11ck198 = 1.8 time = 3980
.meas tran vdout0_11ck198 FIND v(dout0_11) AT=3980.1n

* CHECK dout0_12 Vdout0_12ck198 = 0 time = 3980
.meas tran vdout0_12ck198 FIND v(dout0_12) AT=3980.1n

* CHECK dout0_13 Vdout0_13ck198 = 0 time = 3980
.meas tran vdout0_13ck198 FIND v(dout0_13) AT=3980.1n

* CHECK dout0_14 Vdout0_14ck198 = 0 time = 3980
.meas tran vdout0_14ck198 FIND v(dout0_14) AT=3980.1n

* CHECK dout0_15 Vdout0_15ck198 = 0 time = 3980
.meas tran vdout0_15ck198 FIND v(dout0_15) AT=3980.1n

* CHECK dout0_0 Vdout0_0ck199 = 1.8 time = 4000
.meas tran vdout0_0ck199 FIND v(dout0_0) AT=4000.1n

* CHECK dout0_1 Vdout0_1ck199 = 1.8 time = 4000
.meas tran vdout0_1ck199 FIND v(dout0_1) AT=4000.1n

* CHECK dout0_2 Vdout0_2ck199 = 0 time = 4000
.meas tran vdout0_2ck199 FIND v(dout0_2) AT=4000.1n

* CHECK dout0_3 Vdout0_3ck199 = 0 time = 4000
.meas tran vdout0_3ck199 FIND v(dout0_3) AT=4000.1n

* CHECK dout0_4 Vdout0_4ck199 = 1.8 time = 4000
.meas tran vdout0_4ck199 FIND v(dout0_4) AT=4000.1n

* CHECK dout0_5 Vdout0_5ck199 = 0 time = 4000
.meas tran vdout0_5ck199 FIND v(dout0_5) AT=4000.1n

* CHECK dout0_6 Vdout0_6ck199 = 0 time = 4000
.meas tran vdout0_6ck199 FIND v(dout0_6) AT=4000.1n

* CHECK dout0_7 Vdout0_7ck199 = 0 time = 4000
.meas tran vdout0_7ck199 FIND v(dout0_7) AT=4000.1n

* CHECK dout0_8 Vdout0_8ck199 = 0 time = 4000
.meas tran vdout0_8ck199 FIND v(dout0_8) AT=4000.1n

* CHECK dout0_9 Vdout0_9ck199 = 0 time = 4000
.meas tran vdout0_9ck199 FIND v(dout0_9) AT=4000.1n

* CHECK dout0_10 Vdout0_10ck199 = 1.8 time = 4000
.meas tran vdout0_10ck199 FIND v(dout0_10) AT=4000.1n

* CHECK dout0_11 Vdout0_11ck199 = 0 time = 4000
.meas tran vdout0_11ck199 FIND v(dout0_11) AT=4000.1n

* CHECK dout0_12 Vdout0_12ck199 = 0 time = 4000
.meas tran vdout0_12ck199 FIND v(dout0_12) AT=4000.1n

* CHECK dout0_13 Vdout0_13ck199 = 0 time = 4000
.meas tran vdout0_13ck199 FIND v(dout0_13) AT=4000.1n

* CHECK dout0_14 Vdout0_14ck199 = 0 time = 4000
.meas tran vdout0_14ck199 FIND v(dout0_14) AT=4000.1n

* CHECK dout0_15 Vdout0_15ck199 = 1.8 time = 4000
.meas tran vdout0_15ck199 FIND v(dout0_15) AT=4000.1n

* CHECK dout0_0 Vdout0_0ck201 = 1.8 time = 4040
.meas tran vdout0_0ck201 FIND v(dout0_0) AT=4040.1n

* CHECK dout0_1 Vdout0_1ck201 = 1.8 time = 4040
.meas tran vdout0_1ck201 FIND v(dout0_1) AT=4040.1n

* CHECK dout0_2 Vdout0_2ck201 = 0 time = 4040
.meas tran vdout0_2ck201 FIND v(dout0_2) AT=4040.1n

* CHECK dout0_3 Vdout0_3ck201 = 0 time = 4040
.meas tran vdout0_3ck201 FIND v(dout0_3) AT=4040.1n

* CHECK dout0_4 Vdout0_4ck201 = 1.8 time = 4040
.meas tran vdout0_4ck201 FIND v(dout0_4) AT=4040.1n

* CHECK dout0_5 Vdout0_5ck201 = 0 time = 4040
.meas tran vdout0_5ck201 FIND v(dout0_5) AT=4040.1n

* CHECK dout0_6 Vdout0_6ck201 = 1.8 time = 4040
.meas tran vdout0_6ck201 FIND v(dout0_6) AT=4040.1n

* CHECK dout0_7 Vdout0_7ck201 = 0 time = 4040
.meas tran vdout0_7ck201 FIND v(dout0_7) AT=4040.1n

* CHECK dout0_8 Vdout0_8ck201 = 0 time = 4040
.meas tran vdout0_8ck201 FIND v(dout0_8) AT=4040.1n

* CHECK dout0_9 Vdout0_9ck201 = 0 time = 4040
.meas tran vdout0_9ck201 FIND v(dout0_9) AT=4040.1n

* CHECK dout0_10 Vdout0_10ck201 = 0 time = 4040
.meas tran vdout0_10ck201 FIND v(dout0_10) AT=4040.1n

* CHECK dout0_11 Vdout0_11ck201 = 0 time = 4040
.meas tran vdout0_11ck201 FIND v(dout0_11) AT=4040.1n

* CHECK dout0_12 Vdout0_12ck201 = 0 time = 4040
.meas tran vdout0_12ck201 FIND v(dout0_12) AT=4040.1n

* CHECK dout0_13 Vdout0_13ck201 = 0 time = 4040
.meas tran vdout0_13ck201 FIND v(dout0_13) AT=4040.1n

* CHECK dout0_14 Vdout0_14ck201 = 1.8 time = 4040
.meas tran vdout0_14ck201 FIND v(dout0_14) AT=4040.1n

* CHECK dout0_15 Vdout0_15ck201 = 1.8 time = 4040
.meas tran vdout0_15ck201 FIND v(dout0_15) AT=4040.1n

* CHECK dout0_0 Vdout0_0ck202 = 1.8 time = 4060
.meas tran vdout0_0ck202 FIND v(dout0_0) AT=4060.1n

* CHECK dout0_1 Vdout0_1ck202 = 1.8 time = 4060
.meas tran vdout0_1ck202 FIND v(dout0_1) AT=4060.1n

* CHECK dout0_2 Vdout0_2ck202 = 0 time = 4060
.meas tran vdout0_2ck202 FIND v(dout0_2) AT=4060.1n

* CHECK dout0_3 Vdout0_3ck202 = 0 time = 4060
.meas tran vdout0_3ck202 FIND v(dout0_3) AT=4060.1n

* CHECK dout0_4 Vdout0_4ck202 = 1.8 time = 4060
.meas tran vdout0_4ck202 FIND v(dout0_4) AT=4060.1n

* CHECK dout0_5 Vdout0_5ck202 = 0 time = 4060
.meas tran vdout0_5ck202 FIND v(dout0_5) AT=4060.1n

* CHECK dout0_6 Vdout0_6ck202 = 0 time = 4060
.meas tran vdout0_6ck202 FIND v(dout0_6) AT=4060.1n

* CHECK dout0_7 Vdout0_7ck202 = 0 time = 4060
.meas tran vdout0_7ck202 FIND v(dout0_7) AT=4060.1n

* CHECK dout0_8 Vdout0_8ck202 = 0 time = 4060
.meas tran vdout0_8ck202 FIND v(dout0_8) AT=4060.1n

* CHECK dout0_9 Vdout0_9ck202 = 0 time = 4060
.meas tran vdout0_9ck202 FIND v(dout0_9) AT=4060.1n

* CHECK dout0_10 Vdout0_10ck202 = 1.8 time = 4060
.meas tran vdout0_10ck202 FIND v(dout0_10) AT=4060.1n

* CHECK dout0_11 Vdout0_11ck202 = 0 time = 4060
.meas tran vdout0_11ck202 FIND v(dout0_11) AT=4060.1n

* CHECK dout0_12 Vdout0_12ck202 = 0 time = 4060
.meas tran vdout0_12ck202 FIND v(dout0_12) AT=4060.1n

* CHECK dout0_13 Vdout0_13ck202 = 0 time = 4060
.meas tran vdout0_13ck202 FIND v(dout0_13) AT=4060.1n

* CHECK dout0_14 Vdout0_14ck202 = 0 time = 4060
.meas tran vdout0_14ck202 FIND v(dout0_14) AT=4060.1n

* CHECK dout0_15 Vdout0_15ck202 = 1.8 time = 4060
.meas tran vdout0_15ck202 FIND v(dout0_15) AT=4060.1n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
