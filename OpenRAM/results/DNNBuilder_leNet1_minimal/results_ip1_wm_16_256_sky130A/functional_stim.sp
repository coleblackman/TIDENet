* Functional test stimulus file for 20ns period

* TT process corner
.include "/home/mm4uz/Documents/openram/vsdsram_sky130/OpenRAM/technology/sky130A/models/tt.sp"
.include "ip1_wm_sram_16_256_sky130A.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xip1_wm_sram_16_256_sky130A din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 vdd gnd ip1_wm_sram_16_256_sky130A

* SRAM output loads
CD00 dout0_0  0 39.2968f
CD01 dout0_1  0 39.2968f
CD02 dout0_2  0 39.2968f
CD03 dout0_3  0 39.2968f
CD04 dout0_4  0 39.2968f
CD05 dout0_5  0 39.2968f
CD06 dout0_6  0 39.2968f
CD07 dout0_7  0 39.2968f
CD08 dout0_8  0 39.2968f
CD09 dout0_9  0 39.2968f
CD010 dout0_10  0 39.2968f
CD011 dout0_11  0 39.2968f
CD012 dout0_12  0 39.2968f
CD013 dout0_13  0 39.2968f
CD014 dout0_14  0 39.2968f
CD015 dout0_15  0 39.2968f

* Important signals for debug
* bl:	xip1_wm_sram_16_256_sky130a.xbank0.bl_0_0
* br:	xip1_wm_sram_16_256_sky130a.xbank0.br_0_0
* s_en:	xip1_wm_sram_16_256_sky130a.s_en
* q:	xip1_wm_sram_16_256_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xip1_wm_sram_16_256_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 20ns)
*	Writing 1111000010001011  to  address 00000001 (from port 0) during cycle 1 (20ns - 40ns)
*	Writing 1010001011000100  to  address 00000001 (from port 0) during cycle 2 (40ns - 60ns)
*	Writing 0000001001110101  to  address 11111011 (from port 0) during cycle 3 (60ns - 80ns)
*	Reading 0000001001110101 from address 11111011 (from port 0) during cycle 4 (80ns - 100ns)
*	Writing 1001011000101100  to  address 11111011 (from port 0) during cycle 5 (100ns - 120ns)
*	Reading 1010001011000100 from address 00000001 (from port 0) during cycle 6 (120ns - 140ns)
*	Reading 1001011000101100 from address 11111011 (from port 0) during cycle 7 (140ns - 160ns)
*	Writing 0110001110110001  to  address 00000000 (from port 0) during cycle 8 (160ns - 180ns)
*	Writing 0101010111111000  to  address 00000010 (from port 0) during cycle 9 (180ns - 200ns)
*	Reading 1001011000101100 from address 11111011 (from port 0) during cycle 10 (200ns - 220ns)
*	Writing 0010001001100000  to  address 00000000 (from port 0) during cycle 12 (240ns - 260ns)
*	Reading 0101010111111000 from address 00000010 (from port 0) during cycle 13 (260ns - 280ns)
*	Writing 1101111111101100  to  address 00000010 (from port 0) during cycle 14 (280ns - 300ns)
*	Reading 1010001011000100 from address 00000001 (from port 0) during cycle 15 (300ns - 320ns)
*	Writing 0000101111100100  to  address 11111100 (from port 0) during cycle 16 (320ns - 340ns)
*	Reading 0000101111100100 from address 11111100 (from port 0) during cycle 20 (400ns - 420ns)
*	Reading 0010001001100000 from address 00000000 (from port 0) during cycle 21 (420ns - 440ns)
*	Reading 0010001001100000 from address 00000000 (from port 0) during cycle 24 (480ns - 500ns)
*	Writing 1010001101110111  to  address 00000001 (from port 0) during cycle 25 (500ns - 520ns)
*	Reading 1101111111101100 from address 00000010 (from port 0) during cycle 29 (580ns - 600ns)
*	Writing 1010000100010000  to  address 11111100 (from port 0) during cycle 30 (600ns - 620ns)
*	Reading 1010000100010000 from address 11111100 (from port 0) during cycle 32 (640ns - 660ns)
*	Writing 0110000011110100  to  address 00000010 (from port 0) during cycle 33 (660ns - 680ns)
*	Reading 1010000100010000 from address 11111100 (from port 0) during cycle 34 (680ns - 700ns)
*	Writing 0001001000101110  to  address 00000010 (from port 0) during cycle 35 (700ns - 720ns)
*	Writing 0100101111110111  to  address 11111110 (from port 0) during cycle 36 (720ns - 740ns)
*	Reading 1010000100010000 from address 11111100 (from port 0) during cycle 37 (740ns - 760ns)
*	Writing 0100001011100011  to  address 00000000 (from port 0) during cycle 38 (760ns - 780ns)
*	Writing 0100110110110100  to  address 00000000 (from port 0) during cycle 39 (780ns - 800ns)
*	Writing 0100000111000110  to  address 00000010 (from port 0) during cycle 41 (820ns - 840ns)
*	Reading 1001011000101100 from address 11111011 (from port 0) during cycle 43 (860ns - 880ns)
*	Reading 0100000111000110 from address 00000010 (from port 0) during cycle 45 (900ns - 920ns)
*	Writing 1110100101101001  to  address 11111101 (from port 0) during cycle 47 (940ns - 960ns)
*	Reading 1010001101110111 from address 00000001 (from port 0) during cycle 48 (960ns - 980ns)
*	Reading 1010000100010000 from address 11111100 (from port 0) during cycle 49 (980ns - 1000ns)
*	Writing 1100010010100110  to  address 11111110 (from port 0) during cycle 50 (1000ns - 1020ns)
*	Writing 0101010111010111  to  address 11111100 (from port 0) during cycle 51 (1020ns - 1040ns)
*	Reading 1110100101101001 from address 11111101 (from port 0) during cycle 52 (1040ns - 1060ns)
*	Reading 0100000111000110 from address 00000010 (from port 0) during cycle 54 (1080ns - 1100ns)
*	Reading 1001011000101100 from address 11111011 (from port 0) during cycle 56 (1120ns - 1140ns)
*	Reading 1010001101110111 from address 00000001 (from port 0) during cycle 58 (1160ns - 1180ns)
*	Writing 1010100000101001  to  address 11111101 (from port 0) during cycle 60 (1200ns - 1220ns)
*	Reading 1010100000101001 from address 11111101 (from port 0) during cycle 61 (1220ns - 1240ns)
*	Writing 0101011100001000  to  address 11111101 (from port 0) during cycle 62 (1240ns - 1260ns)
*	Reading 1100010010100110 from address 11111110 (from port 0) during cycle 63 (1260ns - 1280ns)
*	Reading 1100010010100110 from address 11111110 (from port 0) during cycle 64 (1280ns - 1300ns)
*	Writing 1010011011000111  to  address 00000011 (from port 0) during cycle 65 (1300ns - 1320ns)
*	Reading 1010011011000111 from address 00000011 (from port 0) during cycle 67 (1340ns - 1360ns)
*	Writing 0011011011011011  to  address 00000001 (from port 0) during cycle 68 (1360ns - 1380ns)
*	Writing 0000101110000110  to  address 00000001 (from port 0) during cycle 71 (1420ns - 1440ns)
*	Writing 0010111110110110  to  address 00000010 (from port 0) during cycle 72 (1440ns - 1460ns)
*	Reading 1001011000101100 from address 11111011 (from port 0) during cycle 74 (1480ns - 1500ns)
*	Writing 0110110010101100  to  address 00000000 (from port 0) during cycle 75 (1500ns - 1520ns)
*	Writing 0100111110111101  to  address 11111100 (from port 0) during cycle 76 (1520ns - 1540ns)
*	Reading 0101011100001000 from address 11111101 (from port 0) during cycle 77 (1540ns - 1560ns)
*	Reading 0101011100001000 from address 11111101 (from port 0) during cycle 78 (1560ns - 1580ns)
*	Reading 0100111110111101 from address 11111100 (from port 0) during cycle 80 (1600ns - 1620ns)
*	Reading 0000101110000110 from address 00000001 (from port 0) during cycle 81 (1620ns - 1640ns)
*	Reading 1001011000101100 from address 11111011 (from port 0) during cycle 82 (1640ns - 1660ns)
*	Reading 0100111110111101 from address 11111100 (from port 0) during cycle 83 (1660ns - 1680ns)
*	Writing 1011101001110110  to  address 00000001 (from port 0) during cycle 84 (1680ns - 1700ns)
*	Writing 1001111010111010  to  address 00000011 (from port 0) during cycle 85 (1700ns - 1720ns)
*	Reading 1100010010100110 from address 11111110 (from port 0) during cycle 86 (1720ns - 1740ns)
*	Reading 0110110010101100 from address 00000000 (from port 0) during cycle 87 (1740ns - 1760ns)
*	Writing 0011100011100011  to  address 00000011 (from port 0) during cycle 88 (1760ns - 1780ns)
*	Reading 0110110010101100 from address 00000000 (from port 0) during cycle 89 (1780ns - 1800ns)
*	Writing 1110000111011010  to  address 00000011 (from port 0) during cycle 90 (1800ns - 1820ns)
*	Writing 0110111101110011  to  address 11111110 (from port 0) during cycle 93 (1860ns - 1880ns)
*	Writing 1010001001110110  to  address 11111011 (from port 0) during cycle 94 (1880ns - 1900ns)
*	Writing 0111100111000111  to  address 11111100 (from port 0) during cycle 95 (1900ns - 1920ns)
*	Writing 1110000111101000  to  address 00000001 (from port 0) during cycle 96 (1920ns - 1940ns)
*	Reading 0110110010101100 from address 00000000 (from port 0) during cycle 97 (1940ns - 1960ns)
*	Reading 0110111101110011 from address 11111110 (from port 0) during cycle 98 (1960ns - 1980ns)
*	Writing 1011001111010100  to  address 11111011 (from port 0) during cycle 100 (2000ns - 2020ns)
*	Reading 1110000111011010 from address 00000011 (from port 0) during cycle 101 (2020ns - 2040ns)
*	Reading 0101011100001000 from address 11111101 (from port 0) during cycle 102 (2040ns - 2060ns)
*	Writing 1011010110110010  to  address 00000010 (from port 0) during cycle 103 (2060ns - 2080ns)
*	Reading 1110000111101000 from address 00000001 (from port 0) during cycle 104 (2080ns - 2100ns)
*	Reading 1011001111010100 from address 11111011 (from port 0) during cycle 105 (2100ns - 2120ns)
*	Reading 0110110010101100 from address 00000000 (from port 0) during cycle 106 (2120ns - 2140ns)
*	Writing 0010110000101011  to  address 11111110 (from port 0) during cycle 109 (2180ns - 2200ns)
*	Reading 0110110010101100 from address 00000000 (from port 0) during cycle 110 (2200ns - 2220ns)
*	Reading 0010110000101011 from address 11111110 (from port 0) during cycle 111 (2220ns - 2240ns)
*	Writing 0100101000011101  to  address 00000011 (from port 0) during cycle 112 (2240ns - 2260ns)
*	Writing 1110010001001111  to  address 00000000 (from port 0) during cycle 113 (2260ns - 2280ns)
*	Reading 0111100111000111 from address 11111100 (from port 0) during cycle 114 (2280ns - 2300ns)
*	Reading 0100101000011101 from address 00000011 (from port 0) during cycle 116 (2320ns - 2340ns)
*	Reading 0010110000101011 from address 11111110 (from port 0) during cycle 117 (2340ns - 2360ns)
*	Reading 0100101000011101 from address 00000011 (from port 0) during cycle 119 (2380ns - 2400ns)
*	Reading 1011001111010100 from address 11111011 (from port 0) during cycle 120 (2400ns - 2420ns)
*	Reading 1110010001001111 from address 00000000 (from port 0) during cycle 121 (2420ns - 2440ns)
*	Reading 1011001111010100 from address 11111011 (from port 0) during cycle 122 (2440ns - 2460ns)
*	Reading 1110000111101000 from address 00000001 (from port 0) during cycle 124 (2480ns - 2500ns)
*	Reading 1110010001001111 from address 00000000 (from port 0) during cycle 125 (2500ns - 2520ns)
*	Reading 0101011100001000 from address 11111101 (from port 0) during cycle 126 (2520ns - 2540ns)
*	Writing 0011010010110110  to  address 00000001 (from port 0) during cycle 127 (2540ns - 2560ns)
*	Reading 1110010001001111 from address 00000000 (from port 0) during cycle 128 (2560ns - 2580ns)
*	Reading 1011010110110010 from address 00000010 (from port 0) during cycle 132 (2640ns - 2660ns)
*	Writing 0101010110011010  to  address 00000011 (from port 0) during cycle 133 (2660ns - 2680ns)
*	Reading 0101010110011010 from address 00000011 (from port 0) during cycle 134 (2680ns - 2700ns)
*	Writing 1011001111100101  to  address 00000000 (from port 0) during cycle 135 (2700ns - 2720ns)
*	Writing 1100011111010101  to  address 11111100 (from port 0) during cycle 136 (2720ns - 2740ns)
*	Writing 0100010100001001  to  address 11111110 (from port 0) during cycle 139 (2780ns - 2800ns)
*	Writing 0101001011110110  to  address 11111011 (from port 0) during cycle 140 (2800ns - 2820ns)
*	Writing 0010011101110111  to  address 00000010 (from port 0) during cycle 142 (2840ns - 2860ns)
*	Reading 1011001111100101 from address 00000000 (from port 0) during cycle 143 (2860ns - 2880ns)
*	Reading 1100011111010101 from address 11111100 (from port 0) during cycle 144 (2880ns - 2900ns)
*	Reading 1100011111010101 from address 11111100 (from port 0) during cycle 146 (2920ns - 2940ns)
*	Reading 0101011100001000 from address 11111101 (from port 0) during cycle 147 (2940ns - 2960ns)
*	Reading 0100010100001001 from address 11111110 (from port 0) during cycle 150 (3000ns - 3020ns)
*	Reading 0101010110011010 from address 00000011 (from port 0) during cycle 151 (3020ns - 3040ns)
*	Writing 1110100011101110  to  address 11111011 (from port 0) during cycle 152 (3040ns - 3060ns)
*	Writing 1111100110001010  to  address 00000000 (from port 0) during cycle 153 (3060ns - 3080ns)
*	Reading 0011010010110110 from address 00000001 (from port 0) during cycle 154 (3080ns - 3100ns)
*	Reading 0100010100001001 from address 11111110 (from port 0) during cycle 157 (3140ns - 3160ns)
*	Reading 0100010100001001 from address 11111110 (from port 0) during cycle 160 (3200ns - 3220ns)
*	Reading 1100011111010101 from address 11111100 (from port 0) during cycle 161 (3220ns - 3240ns)
*	Reading 1110100011101110 from address 11111011 (from port 0) during cycle 162 (3240ns - 3260ns)
*	Writing 1111111110100100  to  address 11111101 (from port 0) during cycle 164 (3280ns - 3300ns)
*	Reading 0011010010110110 from address 00000001 (from port 0) during cycle 165 (3300ns - 3320ns)
*	Reading 0101010110011010 from address 00000011 (from port 0) during cycle 166 (3320ns - 3340ns)
*	Writing 0010001111111110  to  address 00000011 (from port 0) during cycle 168 (3360ns - 3380ns)
*	Reading 0100010100001001 from address 11111110 (from port 0) during cycle 170 (3400ns - 3420ns)
*	Writing 1101011101010000  to  address 00000011 (from port 0) during cycle 171 (3420ns - 3440ns)
*	Writing 1100111001111101  to  address 00000001 (from port 0) during cycle 173 (3460ns - 3480ns)
*	Reading 1111100110001010 from address 00000000 (from port 0) during cycle 174 (3480ns - 3500ns)
*	Reading 1111111110100100 from address 11111101 (from port 0) during cycle 175 (3500ns - 3520ns)
*	Reading 1101011101010000 from address 00000011 (from port 0) during cycle 176 (3520ns - 3540ns)
*	Reading 0100010100001001 from address 11111110 (from port 0) during cycle 177 (3540ns - 3560ns)
*	Reading 1100011111010101 from address 11111100 (from port 0) during cycle 178 (3560ns - 3580ns)
*	Reading 1110100011101110 from address 11111011 (from port 0) during cycle 180 (3600ns - 3620ns)
*	Reading 1100111001111101 from address 00000001 (from port 0) during cycle 181 (3620ns - 3640ns)
*	Writing 0011010000100110  to  address 11111100 (from port 0) during cycle 182 (3640ns - 3660ns)
*	Reading 1110100011101110 from address 11111011 (from port 0) during cycle 184 (3680ns - 3700ns)
*	Reading 1101011101010000 from address 00000011 (from port 0) during cycle 185 (3700ns - 3720ns)
*	Writing 0011010011111010  to  address 00000010 (from port 0) during cycle 186 (3720ns - 3740ns)
*	Reading 0100010100001001 from address 11111110 (from port 0) during cycle 188 (3760ns - 3780ns)
*	Reading 0011010011111010 from address 00000010 (from port 0) during cycle 189 (3780ns - 3800ns)
*	Reading 1101011101010000 from address 00000011 (from port 0) during cycle 190 (3800ns - 3820ns)
*	Reading 0011010011111010 from address 00000010 (from port 0) during cycle 191 (3820ns - 3840ns)
*	Reading 1101011101010000 from address 00000011 (from port 0) during cycle 192 (3840ns - 3860ns)
*	Writing 0001000010011011  to  address 00000011 (from port 0) during cycle 194 (3880ns - 3900ns)
*	Writing 1111100010111100  to  address 11111100 (from port 0) during cycle 195 (3900ns - 3920ns)
*	Reading 1111100010111100 from address 11111100 (from port 0) during cycle 196 (3920ns - 3940ns)
*	Reading 1111111110100100 from address 11111101 (from port 0) during cycle 197 (3940ns - 3960ns)
*	Reading 1110100011101110 from address 11111011 (from port 0) during cycle 198 (3960ns - 3980ns)
*	Reading 1111111110100100 from address 11111101 (from port 0) during cycle 199 (3980ns - 4000ns)
*	Writing 0101110101101000  to  address 00000010 (from port 0) during cycle 200 (4000ns - 4020ns)
*	Reading 1111111110100100 from address 11111101 (from port 0) during cycle 202 (4040ns - 4060ns)
*	Writing 0100101101000001  to  address 11111011 (from port 0) during cycle 203 (4060ns - 4080ns)
*	Idle during cycle 205 (4100ns - 4120ns)

* Generation of data and address signals
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 0), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 0), (180, 1), (200, 1), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 0), (720, 1), (740, 1), (760, 0), (780, 1), (800, 1), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 1), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 0), (2020, 0), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 0), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 0), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 0), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 0), (680, 0), (700, 0), (720, 1), (740, 1), (760, 0), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 0), (180, 1), (200, 1), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 1), (740, 1), (760, 0), (780, 1), (800, 1), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 0), (180, 1), (200, 1), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 0), (200, 0), (220, 0), (240, 1), (260, 1), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 0), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 0), (260, 0), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 0), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 1), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 1), (220, 1), (240, 0), (260, 0), (280, 0), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 0), (1040, 1), (1060, 1), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 1), (1500, 0), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 0), (1620, 1), (1640, 1), (1660, 0), (1680, 1), (1700, 1), (1720, 0), (1740, 0), (1760, 1), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 0), (1880, 1), (1900, 0), (1920, 1), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 0), (2280, 0), (2300, 0), (2320, 1), (2340, 0), (2360, 0), (2380, 1), (2400, 1), (2420, 0), (2440, 1), (2460, 1), (2480, 1), (2500, 0), (2520, 1), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 1), (3000, 0), (3020, 1), (3040, 1), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 0), (3420, 1), (3440, 1), (3460, 1), (3480, 0), (3500, 1), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 1), (3820, 0), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 0), (140, 1), (160, 0), (180, 1), (200, 1), (220, 1), (240, 0), (260, 1), (280, 1), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 1), (600, 0), (620, 0), (640, 0), (660, 1), (680, 0), (700, 1), (720, 1), (740, 0), (760, 0), (780, 0), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 1), (1660, 0), (1680, 0), (1700, 1), (1720, 1), (1740, 0), (1760, 1), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 1), (2080, 0), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 1), (2240, 1), (2260, 0), (2280, 0), (2300, 0), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 0), (3580, 0), (3600, 1), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 0), (4000, 1), (4020, 1), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 0.0v 138.95n 0.0v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 1), (660, 0), (680, 1), (700, 0), (720, 1), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 1), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 1), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 0), (2020, 0), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 1), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 0), (3260, 0), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 0), (3540, 1), (3560, 1), (3580, 1), (3600, 0), (3620, 0), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 0), (140, 1), (160, 0), (180, 0), (200, 1), (220, 1), (240, 0), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 1), (660, 0), (680, 1), (700, 0), (720, 1), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 1), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 1), (1500, 0), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 0), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 1), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 1), (2420, 0), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 0), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 0), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 0.0v 138.95n 0.0v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 0), (140, 1), (160, 0), (180, 0), (200, 1), (220, 1), (240, 0), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 1), (660, 0), (680, 1), (700, 0), (720, 1), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 1), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 1), (1500, 0), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 0), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 1), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 1), (2420, 0), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 0), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 0), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_4  a0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 0.0v 138.95n 0.0v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 0), (140, 1), (160, 0), (180, 0), (200, 1), (220, 1), (240, 0), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 1), (660, 0), (680, 1), (700, 0), (720, 1), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 1), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 1), (1500, 0), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 0), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 1), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 1), (2420, 0), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 0), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 0), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_5  a0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 0.0v 138.95n 0.0v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 0), (140, 1), (160, 0), (180, 0), (200, 1), (220, 1), (240, 0), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 1), (660, 0), (680, 1), (700, 0), (720, 1), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 1), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 1), (1500, 0), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 0), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 1), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 1), (2420, 0), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 0), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 0), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_6  a0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 0.0v 138.95n 0.0v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 0), (140, 1), (160, 0), (180, 0), (200, 1), (220, 1), (240, 0), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 1), (660, 0), (680, 1), (700, 0), (720, 1), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 1), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 1), (1500, 0), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 0), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 1), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 1), (2420, 0), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 0), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 0), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_7  a0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 0.0v 138.95n 0.0v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )

 * Generation of control signals
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 1), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 1), (360, 1), (380, 1), (400, 0), (420, 0), (440, 1), (460, 1), (480, 0), (500, 0), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 1), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 1), (820, 0), (840, 1), (860, 0), (880, 1), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 1), (1080, 0), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 1), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 0), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 1), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 1), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 1), (1840, 1), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 1), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 1), (2320, 0), (2340, 0), (2360, 1), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 1), (2600, 1), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 1), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 0), (2940, 0), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 1), (3120, 1), (3140, 0), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 0), (3380, 1), (3400, 0), (3420, 0), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 0), (3620, 0), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 1.8v 638.95n 1.8v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 1), (100, 0), (120, 1), (140, 1), (160, 0), (180, 0), (200, 1), (220, 1), (240, 0), (260, 1), (280, 0), (300, 1), (320, 0), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 0), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 1), (640, 1), (660, 0), (680, 1), (700, 0), (720, 0), (740, 1), (760, 0), (780, 0), (800, 1), (820, 0), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 0), (960, 1), (980, 1), (1000, 0), (1020, 0), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 1), (1240, 0), (1260, 1), (1280, 1), (1300, 0), (1320, 1), (1340, 1), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 1), (1760, 0), (1780, 1), (1800, 0), (1820, 1), (1840, 1), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 1), (1960, 1), (1980, 1), (2000, 0), (2020, 1), (2040, 1), (2060, 0), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 1), (2220, 1), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 1), (2700, 0), (2720, 0), (2740, 1), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 0), (3380, 1), (3400, 1), (3420, 0), (3440, 1), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 1), (3680, 1), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 0), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 1), (4040, 1), (4060, 0), (4080, 1), (4100, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* PULSE: period=20
Vclk0 clk0 0 PULSE (0 1.8 19.95n 0.1n 0.1n 9.899999999999999n 20n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 1.8 time = 100
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=100.1n

* CHECK dout0_1 Vdout0_1ck4 = 0 time = 100
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=100.1n

* CHECK dout0_2 Vdout0_2ck4 = 1.8 time = 100
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=100.1n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 100
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=100.1n

* CHECK dout0_4 Vdout0_4ck4 = 1.8 time = 100
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=100.1n

* CHECK dout0_5 Vdout0_5ck4 = 1.8 time = 100
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=100.1n

* CHECK dout0_6 Vdout0_6ck4 = 1.8 time = 100
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=100.1n

* CHECK dout0_7 Vdout0_7ck4 = 0 time = 100
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=100.1n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 100
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=100.1n

* CHECK dout0_9 Vdout0_9ck4 = 1.8 time = 100
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=100.1n

* CHECK dout0_10 Vdout0_10ck4 = 0 time = 100
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=100.1n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 100
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=100.1n

* CHECK dout0_12 Vdout0_12ck4 = 0 time = 100
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=100.1n

* CHECK dout0_13 Vdout0_13ck4 = 0 time = 100
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=100.1n

* CHECK dout0_14 Vdout0_14ck4 = 0 time = 100
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=100.1n

* CHECK dout0_15 Vdout0_15ck4 = 0 time = 100
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=100.1n

* CHECK dout0_0 Vdout0_0ck6 = 0 time = 140
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=140.1n

* CHECK dout0_1 Vdout0_1ck6 = 0 time = 140
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=140.1n

* CHECK dout0_2 Vdout0_2ck6 = 1.8 time = 140
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=140.1n

* CHECK dout0_3 Vdout0_3ck6 = 0 time = 140
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=140.1n

* CHECK dout0_4 Vdout0_4ck6 = 0 time = 140
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=140.1n

* CHECK dout0_5 Vdout0_5ck6 = 0 time = 140
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=140.1n

* CHECK dout0_6 Vdout0_6ck6 = 1.8 time = 140
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=140.1n

* CHECK dout0_7 Vdout0_7ck6 = 1.8 time = 140
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=140.1n

* CHECK dout0_8 Vdout0_8ck6 = 0 time = 140
.meas tran vdout0_8ck6 FIND v(dout0_8) AT=140.1n

* CHECK dout0_9 Vdout0_9ck6 = 1.8 time = 140
.meas tran vdout0_9ck6 FIND v(dout0_9) AT=140.1n

* CHECK dout0_10 Vdout0_10ck6 = 0 time = 140
.meas tran vdout0_10ck6 FIND v(dout0_10) AT=140.1n

* CHECK dout0_11 Vdout0_11ck6 = 0 time = 140
.meas tran vdout0_11ck6 FIND v(dout0_11) AT=140.1n

* CHECK dout0_12 Vdout0_12ck6 = 0 time = 140
.meas tran vdout0_12ck6 FIND v(dout0_12) AT=140.1n

* CHECK dout0_13 Vdout0_13ck6 = 1.8 time = 140
.meas tran vdout0_13ck6 FIND v(dout0_13) AT=140.1n

* CHECK dout0_14 Vdout0_14ck6 = 0 time = 140
.meas tran vdout0_14ck6 FIND v(dout0_14) AT=140.1n

* CHECK dout0_15 Vdout0_15ck6 = 1.8 time = 140
.meas tran vdout0_15ck6 FIND v(dout0_15) AT=140.1n

* CHECK dout0_0 Vdout0_0ck7 = 0 time = 160
.meas tran vdout0_0ck7 FIND v(dout0_0) AT=160.1n

* CHECK dout0_1 Vdout0_1ck7 = 0 time = 160
.meas tran vdout0_1ck7 FIND v(dout0_1) AT=160.1n

* CHECK dout0_2 Vdout0_2ck7 = 1.8 time = 160
.meas tran vdout0_2ck7 FIND v(dout0_2) AT=160.1n

* CHECK dout0_3 Vdout0_3ck7 = 1.8 time = 160
.meas tran vdout0_3ck7 FIND v(dout0_3) AT=160.1n

* CHECK dout0_4 Vdout0_4ck7 = 0 time = 160
.meas tran vdout0_4ck7 FIND v(dout0_4) AT=160.1n

* CHECK dout0_5 Vdout0_5ck7 = 1.8 time = 160
.meas tran vdout0_5ck7 FIND v(dout0_5) AT=160.1n

* CHECK dout0_6 Vdout0_6ck7 = 0 time = 160
.meas tran vdout0_6ck7 FIND v(dout0_6) AT=160.1n

* CHECK dout0_7 Vdout0_7ck7 = 0 time = 160
.meas tran vdout0_7ck7 FIND v(dout0_7) AT=160.1n

* CHECK dout0_8 Vdout0_8ck7 = 0 time = 160
.meas tran vdout0_8ck7 FIND v(dout0_8) AT=160.1n

* CHECK dout0_9 Vdout0_9ck7 = 1.8 time = 160
.meas tran vdout0_9ck7 FIND v(dout0_9) AT=160.1n

* CHECK dout0_10 Vdout0_10ck7 = 1.8 time = 160
.meas tran vdout0_10ck7 FIND v(dout0_10) AT=160.1n

* CHECK dout0_11 Vdout0_11ck7 = 0 time = 160
.meas tran vdout0_11ck7 FIND v(dout0_11) AT=160.1n

* CHECK dout0_12 Vdout0_12ck7 = 1.8 time = 160
.meas tran vdout0_12ck7 FIND v(dout0_12) AT=160.1n

* CHECK dout0_13 Vdout0_13ck7 = 0 time = 160
.meas tran vdout0_13ck7 FIND v(dout0_13) AT=160.1n

* CHECK dout0_14 Vdout0_14ck7 = 0 time = 160
.meas tran vdout0_14ck7 FIND v(dout0_14) AT=160.1n

* CHECK dout0_15 Vdout0_15ck7 = 1.8 time = 160
.meas tran vdout0_15ck7 FIND v(dout0_15) AT=160.1n

* CHECK dout0_0 Vdout0_0ck10 = 0 time = 220
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=220.1n

* CHECK dout0_1 Vdout0_1ck10 = 0 time = 220
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=220.1n

* CHECK dout0_2 Vdout0_2ck10 = 1.8 time = 220
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=220.1n

* CHECK dout0_3 Vdout0_3ck10 = 1.8 time = 220
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=220.1n

* CHECK dout0_4 Vdout0_4ck10 = 0 time = 220
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=220.1n

* CHECK dout0_5 Vdout0_5ck10 = 1.8 time = 220
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=220.1n

* CHECK dout0_6 Vdout0_6ck10 = 0 time = 220
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=220.1n

* CHECK dout0_7 Vdout0_7ck10 = 0 time = 220
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=220.1n

* CHECK dout0_8 Vdout0_8ck10 = 0 time = 220
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=220.1n

* CHECK dout0_9 Vdout0_9ck10 = 1.8 time = 220
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=220.1n

* CHECK dout0_10 Vdout0_10ck10 = 1.8 time = 220
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=220.1n

* CHECK dout0_11 Vdout0_11ck10 = 0 time = 220
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=220.1n

* CHECK dout0_12 Vdout0_12ck10 = 1.8 time = 220
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=220.1n

* CHECK dout0_13 Vdout0_13ck10 = 0 time = 220
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=220.1n

* CHECK dout0_14 Vdout0_14ck10 = 0 time = 220
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=220.1n

* CHECK dout0_15 Vdout0_15ck10 = 1.8 time = 220
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=220.1n

* CHECK dout0_0 Vdout0_0ck13 = 0 time = 280
.meas tran vdout0_0ck13 FIND v(dout0_0) AT=280.1n

* CHECK dout0_1 Vdout0_1ck13 = 0 time = 280
.meas tran vdout0_1ck13 FIND v(dout0_1) AT=280.1n

* CHECK dout0_2 Vdout0_2ck13 = 0 time = 280
.meas tran vdout0_2ck13 FIND v(dout0_2) AT=280.1n

* CHECK dout0_3 Vdout0_3ck13 = 1.8 time = 280
.meas tran vdout0_3ck13 FIND v(dout0_3) AT=280.1n

* CHECK dout0_4 Vdout0_4ck13 = 1.8 time = 280
.meas tran vdout0_4ck13 FIND v(dout0_4) AT=280.1n

* CHECK dout0_5 Vdout0_5ck13 = 1.8 time = 280
.meas tran vdout0_5ck13 FIND v(dout0_5) AT=280.1n

* CHECK dout0_6 Vdout0_6ck13 = 1.8 time = 280
.meas tran vdout0_6ck13 FIND v(dout0_6) AT=280.1n

* CHECK dout0_7 Vdout0_7ck13 = 1.8 time = 280
.meas tran vdout0_7ck13 FIND v(dout0_7) AT=280.1n

* CHECK dout0_8 Vdout0_8ck13 = 1.8 time = 280
.meas tran vdout0_8ck13 FIND v(dout0_8) AT=280.1n

* CHECK dout0_9 Vdout0_9ck13 = 0 time = 280
.meas tran vdout0_9ck13 FIND v(dout0_9) AT=280.1n

* CHECK dout0_10 Vdout0_10ck13 = 1.8 time = 280
.meas tran vdout0_10ck13 FIND v(dout0_10) AT=280.1n

* CHECK dout0_11 Vdout0_11ck13 = 0 time = 280
.meas tran vdout0_11ck13 FIND v(dout0_11) AT=280.1n

* CHECK dout0_12 Vdout0_12ck13 = 1.8 time = 280
.meas tran vdout0_12ck13 FIND v(dout0_12) AT=280.1n

* CHECK dout0_13 Vdout0_13ck13 = 0 time = 280
.meas tran vdout0_13ck13 FIND v(dout0_13) AT=280.1n

* CHECK dout0_14 Vdout0_14ck13 = 1.8 time = 280
.meas tran vdout0_14ck13 FIND v(dout0_14) AT=280.1n

* CHECK dout0_15 Vdout0_15ck13 = 0 time = 280
.meas tran vdout0_15ck13 FIND v(dout0_15) AT=280.1n

* CHECK dout0_0 Vdout0_0ck15 = 0 time = 320
.meas tran vdout0_0ck15 FIND v(dout0_0) AT=320.1n

* CHECK dout0_1 Vdout0_1ck15 = 0 time = 320
.meas tran vdout0_1ck15 FIND v(dout0_1) AT=320.1n

* CHECK dout0_2 Vdout0_2ck15 = 1.8 time = 320
.meas tran vdout0_2ck15 FIND v(dout0_2) AT=320.1n

* CHECK dout0_3 Vdout0_3ck15 = 0 time = 320
.meas tran vdout0_3ck15 FIND v(dout0_3) AT=320.1n

* CHECK dout0_4 Vdout0_4ck15 = 0 time = 320
.meas tran vdout0_4ck15 FIND v(dout0_4) AT=320.1n

* CHECK dout0_5 Vdout0_5ck15 = 0 time = 320
.meas tran vdout0_5ck15 FIND v(dout0_5) AT=320.1n

* CHECK dout0_6 Vdout0_6ck15 = 1.8 time = 320
.meas tran vdout0_6ck15 FIND v(dout0_6) AT=320.1n

* CHECK dout0_7 Vdout0_7ck15 = 1.8 time = 320
.meas tran vdout0_7ck15 FIND v(dout0_7) AT=320.1n

* CHECK dout0_8 Vdout0_8ck15 = 0 time = 320
.meas tran vdout0_8ck15 FIND v(dout0_8) AT=320.1n

* CHECK dout0_9 Vdout0_9ck15 = 1.8 time = 320
.meas tran vdout0_9ck15 FIND v(dout0_9) AT=320.1n

* CHECK dout0_10 Vdout0_10ck15 = 0 time = 320
.meas tran vdout0_10ck15 FIND v(dout0_10) AT=320.1n

* CHECK dout0_11 Vdout0_11ck15 = 0 time = 320
.meas tran vdout0_11ck15 FIND v(dout0_11) AT=320.1n

* CHECK dout0_12 Vdout0_12ck15 = 0 time = 320
.meas tran vdout0_12ck15 FIND v(dout0_12) AT=320.1n

* CHECK dout0_13 Vdout0_13ck15 = 1.8 time = 320
.meas tran vdout0_13ck15 FIND v(dout0_13) AT=320.1n

* CHECK dout0_14 Vdout0_14ck15 = 0 time = 320
.meas tran vdout0_14ck15 FIND v(dout0_14) AT=320.1n

* CHECK dout0_15 Vdout0_15ck15 = 1.8 time = 320
.meas tran vdout0_15ck15 FIND v(dout0_15) AT=320.1n

* CHECK dout0_0 Vdout0_0ck20 = 0 time = 420
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=420.1n

* CHECK dout0_1 Vdout0_1ck20 = 0 time = 420
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=420.1n

* CHECK dout0_2 Vdout0_2ck20 = 1.8 time = 420
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=420.1n

* CHECK dout0_3 Vdout0_3ck20 = 0 time = 420
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=420.1n

* CHECK dout0_4 Vdout0_4ck20 = 0 time = 420
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=420.1n

* CHECK dout0_5 Vdout0_5ck20 = 1.8 time = 420
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=420.1n

* CHECK dout0_6 Vdout0_6ck20 = 1.8 time = 420
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=420.1n

* CHECK dout0_7 Vdout0_7ck20 = 1.8 time = 420
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=420.1n

* CHECK dout0_8 Vdout0_8ck20 = 1.8 time = 420
.meas tran vdout0_8ck20 FIND v(dout0_8) AT=420.1n

* CHECK dout0_9 Vdout0_9ck20 = 1.8 time = 420
.meas tran vdout0_9ck20 FIND v(dout0_9) AT=420.1n

* CHECK dout0_10 Vdout0_10ck20 = 0 time = 420
.meas tran vdout0_10ck20 FIND v(dout0_10) AT=420.1n

* CHECK dout0_11 Vdout0_11ck20 = 1.8 time = 420
.meas tran vdout0_11ck20 FIND v(dout0_11) AT=420.1n

* CHECK dout0_12 Vdout0_12ck20 = 0 time = 420
.meas tran vdout0_12ck20 FIND v(dout0_12) AT=420.1n

* CHECK dout0_13 Vdout0_13ck20 = 0 time = 420
.meas tran vdout0_13ck20 FIND v(dout0_13) AT=420.1n

* CHECK dout0_14 Vdout0_14ck20 = 0 time = 420
.meas tran vdout0_14ck20 FIND v(dout0_14) AT=420.1n

* CHECK dout0_15 Vdout0_15ck20 = 0 time = 420
.meas tran vdout0_15ck20 FIND v(dout0_15) AT=420.1n

* CHECK dout0_0 Vdout0_0ck21 = 0 time = 440
.meas tran vdout0_0ck21 FIND v(dout0_0) AT=440.1n

* CHECK dout0_1 Vdout0_1ck21 = 0 time = 440
.meas tran vdout0_1ck21 FIND v(dout0_1) AT=440.1n

* CHECK dout0_2 Vdout0_2ck21 = 0 time = 440
.meas tran vdout0_2ck21 FIND v(dout0_2) AT=440.1n

* CHECK dout0_3 Vdout0_3ck21 = 0 time = 440
.meas tran vdout0_3ck21 FIND v(dout0_3) AT=440.1n

* CHECK dout0_4 Vdout0_4ck21 = 0 time = 440
.meas tran vdout0_4ck21 FIND v(dout0_4) AT=440.1n

* CHECK dout0_5 Vdout0_5ck21 = 1.8 time = 440
.meas tran vdout0_5ck21 FIND v(dout0_5) AT=440.1n

* CHECK dout0_6 Vdout0_6ck21 = 1.8 time = 440
.meas tran vdout0_6ck21 FIND v(dout0_6) AT=440.1n

* CHECK dout0_7 Vdout0_7ck21 = 0 time = 440
.meas tran vdout0_7ck21 FIND v(dout0_7) AT=440.1n

* CHECK dout0_8 Vdout0_8ck21 = 0 time = 440
.meas tran vdout0_8ck21 FIND v(dout0_8) AT=440.1n

* CHECK dout0_9 Vdout0_9ck21 = 1.8 time = 440
.meas tran vdout0_9ck21 FIND v(dout0_9) AT=440.1n

* CHECK dout0_10 Vdout0_10ck21 = 0 time = 440
.meas tran vdout0_10ck21 FIND v(dout0_10) AT=440.1n

* CHECK dout0_11 Vdout0_11ck21 = 0 time = 440
.meas tran vdout0_11ck21 FIND v(dout0_11) AT=440.1n

* CHECK dout0_12 Vdout0_12ck21 = 0 time = 440
.meas tran vdout0_12ck21 FIND v(dout0_12) AT=440.1n

* CHECK dout0_13 Vdout0_13ck21 = 1.8 time = 440
.meas tran vdout0_13ck21 FIND v(dout0_13) AT=440.1n

* CHECK dout0_14 Vdout0_14ck21 = 0 time = 440
.meas tran vdout0_14ck21 FIND v(dout0_14) AT=440.1n

* CHECK dout0_15 Vdout0_15ck21 = 0 time = 440
.meas tran vdout0_15ck21 FIND v(dout0_15) AT=440.1n

* CHECK dout0_0 Vdout0_0ck24 = 0 time = 500
.meas tran vdout0_0ck24 FIND v(dout0_0) AT=500.1n

* CHECK dout0_1 Vdout0_1ck24 = 0 time = 500
.meas tran vdout0_1ck24 FIND v(dout0_1) AT=500.1n

* CHECK dout0_2 Vdout0_2ck24 = 0 time = 500
.meas tran vdout0_2ck24 FIND v(dout0_2) AT=500.1n

* CHECK dout0_3 Vdout0_3ck24 = 0 time = 500
.meas tran vdout0_3ck24 FIND v(dout0_3) AT=500.1n

* CHECK dout0_4 Vdout0_4ck24 = 0 time = 500
.meas tran vdout0_4ck24 FIND v(dout0_4) AT=500.1n

* CHECK dout0_5 Vdout0_5ck24 = 1.8 time = 500
.meas tran vdout0_5ck24 FIND v(dout0_5) AT=500.1n

* CHECK dout0_6 Vdout0_6ck24 = 1.8 time = 500
.meas tran vdout0_6ck24 FIND v(dout0_6) AT=500.1n

* CHECK dout0_7 Vdout0_7ck24 = 0 time = 500
.meas tran vdout0_7ck24 FIND v(dout0_7) AT=500.1n

* CHECK dout0_8 Vdout0_8ck24 = 0 time = 500
.meas tran vdout0_8ck24 FIND v(dout0_8) AT=500.1n

* CHECK dout0_9 Vdout0_9ck24 = 1.8 time = 500
.meas tran vdout0_9ck24 FIND v(dout0_9) AT=500.1n

* CHECK dout0_10 Vdout0_10ck24 = 0 time = 500
.meas tran vdout0_10ck24 FIND v(dout0_10) AT=500.1n

* CHECK dout0_11 Vdout0_11ck24 = 0 time = 500
.meas tran vdout0_11ck24 FIND v(dout0_11) AT=500.1n

* CHECK dout0_12 Vdout0_12ck24 = 0 time = 500
.meas tran vdout0_12ck24 FIND v(dout0_12) AT=500.1n

* CHECK dout0_13 Vdout0_13ck24 = 1.8 time = 500
.meas tran vdout0_13ck24 FIND v(dout0_13) AT=500.1n

* CHECK dout0_14 Vdout0_14ck24 = 0 time = 500
.meas tran vdout0_14ck24 FIND v(dout0_14) AT=500.1n

* CHECK dout0_15 Vdout0_15ck24 = 0 time = 500
.meas tran vdout0_15ck24 FIND v(dout0_15) AT=500.1n

* CHECK dout0_0 Vdout0_0ck29 = 0 time = 600
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=600.1n

* CHECK dout0_1 Vdout0_1ck29 = 0 time = 600
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=600.1n

* CHECK dout0_2 Vdout0_2ck29 = 1.8 time = 600
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=600.1n

* CHECK dout0_3 Vdout0_3ck29 = 1.8 time = 600
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=600.1n

* CHECK dout0_4 Vdout0_4ck29 = 0 time = 600
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=600.1n

* CHECK dout0_5 Vdout0_5ck29 = 1.8 time = 600
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=600.1n

* CHECK dout0_6 Vdout0_6ck29 = 1.8 time = 600
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=600.1n

* CHECK dout0_7 Vdout0_7ck29 = 1.8 time = 600
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=600.1n

* CHECK dout0_8 Vdout0_8ck29 = 1.8 time = 600
.meas tran vdout0_8ck29 FIND v(dout0_8) AT=600.1n

* CHECK dout0_9 Vdout0_9ck29 = 1.8 time = 600
.meas tran vdout0_9ck29 FIND v(dout0_9) AT=600.1n

* CHECK dout0_10 Vdout0_10ck29 = 1.8 time = 600
.meas tran vdout0_10ck29 FIND v(dout0_10) AT=600.1n

* CHECK dout0_11 Vdout0_11ck29 = 1.8 time = 600
.meas tran vdout0_11ck29 FIND v(dout0_11) AT=600.1n

* CHECK dout0_12 Vdout0_12ck29 = 1.8 time = 600
.meas tran vdout0_12ck29 FIND v(dout0_12) AT=600.1n

* CHECK dout0_13 Vdout0_13ck29 = 0 time = 600
.meas tran vdout0_13ck29 FIND v(dout0_13) AT=600.1n

* CHECK dout0_14 Vdout0_14ck29 = 1.8 time = 600
.meas tran vdout0_14ck29 FIND v(dout0_14) AT=600.1n

* CHECK dout0_15 Vdout0_15ck29 = 1.8 time = 600
.meas tran vdout0_15ck29 FIND v(dout0_15) AT=600.1n

* CHECK dout0_0 Vdout0_0ck32 = 0 time = 660
.meas tran vdout0_0ck32 FIND v(dout0_0) AT=660.1n

* CHECK dout0_1 Vdout0_1ck32 = 0 time = 660
.meas tran vdout0_1ck32 FIND v(dout0_1) AT=660.1n

* CHECK dout0_2 Vdout0_2ck32 = 0 time = 660
.meas tran vdout0_2ck32 FIND v(dout0_2) AT=660.1n

* CHECK dout0_3 Vdout0_3ck32 = 0 time = 660
.meas tran vdout0_3ck32 FIND v(dout0_3) AT=660.1n

* CHECK dout0_4 Vdout0_4ck32 = 1.8 time = 660
.meas tran vdout0_4ck32 FIND v(dout0_4) AT=660.1n

* CHECK dout0_5 Vdout0_5ck32 = 0 time = 660
.meas tran vdout0_5ck32 FIND v(dout0_5) AT=660.1n

* CHECK dout0_6 Vdout0_6ck32 = 0 time = 660
.meas tran vdout0_6ck32 FIND v(dout0_6) AT=660.1n

* CHECK dout0_7 Vdout0_7ck32 = 0 time = 660
.meas tran vdout0_7ck32 FIND v(dout0_7) AT=660.1n

* CHECK dout0_8 Vdout0_8ck32 = 1.8 time = 660
.meas tran vdout0_8ck32 FIND v(dout0_8) AT=660.1n

* CHECK dout0_9 Vdout0_9ck32 = 0 time = 660
.meas tran vdout0_9ck32 FIND v(dout0_9) AT=660.1n

* CHECK dout0_10 Vdout0_10ck32 = 0 time = 660
.meas tran vdout0_10ck32 FIND v(dout0_10) AT=660.1n

* CHECK dout0_11 Vdout0_11ck32 = 0 time = 660
.meas tran vdout0_11ck32 FIND v(dout0_11) AT=660.1n

* CHECK dout0_12 Vdout0_12ck32 = 0 time = 660
.meas tran vdout0_12ck32 FIND v(dout0_12) AT=660.1n

* CHECK dout0_13 Vdout0_13ck32 = 1.8 time = 660
.meas tran vdout0_13ck32 FIND v(dout0_13) AT=660.1n

* CHECK dout0_14 Vdout0_14ck32 = 0 time = 660
.meas tran vdout0_14ck32 FIND v(dout0_14) AT=660.1n

* CHECK dout0_15 Vdout0_15ck32 = 1.8 time = 660
.meas tran vdout0_15ck32 FIND v(dout0_15) AT=660.1n

* CHECK dout0_0 Vdout0_0ck34 = 0 time = 700
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=700.1n

* CHECK dout0_1 Vdout0_1ck34 = 0 time = 700
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=700.1n

* CHECK dout0_2 Vdout0_2ck34 = 0 time = 700
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=700.1n

* CHECK dout0_3 Vdout0_3ck34 = 0 time = 700
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=700.1n

* CHECK dout0_4 Vdout0_4ck34 = 1.8 time = 700
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=700.1n

* CHECK dout0_5 Vdout0_5ck34 = 0 time = 700
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=700.1n

* CHECK dout0_6 Vdout0_6ck34 = 0 time = 700
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=700.1n

* CHECK dout0_7 Vdout0_7ck34 = 0 time = 700
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=700.1n

* CHECK dout0_8 Vdout0_8ck34 = 1.8 time = 700
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=700.1n

* CHECK dout0_9 Vdout0_9ck34 = 0 time = 700
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=700.1n

* CHECK dout0_10 Vdout0_10ck34 = 0 time = 700
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=700.1n

* CHECK dout0_11 Vdout0_11ck34 = 0 time = 700
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=700.1n

* CHECK dout0_12 Vdout0_12ck34 = 0 time = 700
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=700.1n

* CHECK dout0_13 Vdout0_13ck34 = 1.8 time = 700
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=700.1n

* CHECK dout0_14 Vdout0_14ck34 = 0 time = 700
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=700.1n

* CHECK dout0_15 Vdout0_15ck34 = 1.8 time = 700
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=700.1n

* CHECK dout0_0 Vdout0_0ck37 = 0 time = 760
.meas tran vdout0_0ck37 FIND v(dout0_0) AT=760.1n

* CHECK dout0_1 Vdout0_1ck37 = 0 time = 760
.meas tran vdout0_1ck37 FIND v(dout0_1) AT=760.1n

* CHECK dout0_2 Vdout0_2ck37 = 0 time = 760
.meas tran vdout0_2ck37 FIND v(dout0_2) AT=760.1n

* CHECK dout0_3 Vdout0_3ck37 = 0 time = 760
.meas tran vdout0_3ck37 FIND v(dout0_3) AT=760.1n

* CHECK dout0_4 Vdout0_4ck37 = 1.8 time = 760
.meas tran vdout0_4ck37 FIND v(dout0_4) AT=760.1n

* CHECK dout0_5 Vdout0_5ck37 = 0 time = 760
.meas tran vdout0_5ck37 FIND v(dout0_5) AT=760.1n

* CHECK dout0_6 Vdout0_6ck37 = 0 time = 760
.meas tran vdout0_6ck37 FIND v(dout0_6) AT=760.1n

* CHECK dout0_7 Vdout0_7ck37 = 0 time = 760
.meas tran vdout0_7ck37 FIND v(dout0_7) AT=760.1n

* CHECK dout0_8 Vdout0_8ck37 = 1.8 time = 760
.meas tran vdout0_8ck37 FIND v(dout0_8) AT=760.1n

* CHECK dout0_9 Vdout0_9ck37 = 0 time = 760
.meas tran vdout0_9ck37 FIND v(dout0_9) AT=760.1n

* CHECK dout0_10 Vdout0_10ck37 = 0 time = 760
.meas tran vdout0_10ck37 FIND v(dout0_10) AT=760.1n

* CHECK dout0_11 Vdout0_11ck37 = 0 time = 760
.meas tran vdout0_11ck37 FIND v(dout0_11) AT=760.1n

* CHECK dout0_12 Vdout0_12ck37 = 0 time = 760
.meas tran vdout0_12ck37 FIND v(dout0_12) AT=760.1n

* CHECK dout0_13 Vdout0_13ck37 = 1.8 time = 760
.meas tran vdout0_13ck37 FIND v(dout0_13) AT=760.1n

* CHECK dout0_14 Vdout0_14ck37 = 0 time = 760
.meas tran vdout0_14ck37 FIND v(dout0_14) AT=760.1n

* CHECK dout0_15 Vdout0_15ck37 = 1.8 time = 760
.meas tran vdout0_15ck37 FIND v(dout0_15) AT=760.1n

* CHECK dout0_0 Vdout0_0ck43 = 0 time = 880
.meas tran vdout0_0ck43 FIND v(dout0_0) AT=880.1n

* CHECK dout0_1 Vdout0_1ck43 = 0 time = 880
.meas tran vdout0_1ck43 FIND v(dout0_1) AT=880.1n

* CHECK dout0_2 Vdout0_2ck43 = 1.8 time = 880
.meas tran vdout0_2ck43 FIND v(dout0_2) AT=880.1n

* CHECK dout0_3 Vdout0_3ck43 = 1.8 time = 880
.meas tran vdout0_3ck43 FIND v(dout0_3) AT=880.1n

* CHECK dout0_4 Vdout0_4ck43 = 0 time = 880
.meas tran vdout0_4ck43 FIND v(dout0_4) AT=880.1n

* CHECK dout0_5 Vdout0_5ck43 = 1.8 time = 880
.meas tran vdout0_5ck43 FIND v(dout0_5) AT=880.1n

* CHECK dout0_6 Vdout0_6ck43 = 0 time = 880
.meas tran vdout0_6ck43 FIND v(dout0_6) AT=880.1n

* CHECK dout0_7 Vdout0_7ck43 = 0 time = 880
.meas tran vdout0_7ck43 FIND v(dout0_7) AT=880.1n

* CHECK dout0_8 Vdout0_8ck43 = 0 time = 880
.meas tran vdout0_8ck43 FIND v(dout0_8) AT=880.1n

* CHECK dout0_9 Vdout0_9ck43 = 1.8 time = 880
.meas tran vdout0_9ck43 FIND v(dout0_9) AT=880.1n

* CHECK dout0_10 Vdout0_10ck43 = 1.8 time = 880
.meas tran vdout0_10ck43 FIND v(dout0_10) AT=880.1n

* CHECK dout0_11 Vdout0_11ck43 = 0 time = 880
.meas tran vdout0_11ck43 FIND v(dout0_11) AT=880.1n

* CHECK dout0_12 Vdout0_12ck43 = 1.8 time = 880
.meas tran vdout0_12ck43 FIND v(dout0_12) AT=880.1n

* CHECK dout0_13 Vdout0_13ck43 = 0 time = 880
.meas tran vdout0_13ck43 FIND v(dout0_13) AT=880.1n

* CHECK dout0_14 Vdout0_14ck43 = 0 time = 880
.meas tran vdout0_14ck43 FIND v(dout0_14) AT=880.1n

* CHECK dout0_15 Vdout0_15ck43 = 1.8 time = 880
.meas tran vdout0_15ck43 FIND v(dout0_15) AT=880.1n

* CHECK dout0_0 Vdout0_0ck45 = 0 time = 920
.meas tran vdout0_0ck45 FIND v(dout0_0) AT=920.1n

* CHECK dout0_1 Vdout0_1ck45 = 1.8 time = 920
.meas tran vdout0_1ck45 FIND v(dout0_1) AT=920.1n

* CHECK dout0_2 Vdout0_2ck45 = 1.8 time = 920
.meas tran vdout0_2ck45 FIND v(dout0_2) AT=920.1n

* CHECK dout0_3 Vdout0_3ck45 = 0 time = 920
.meas tran vdout0_3ck45 FIND v(dout0_3) AT=920.1n

* CHECK dout0_4 Vdout0_4ck45 = 0 time = 920
.meas tran vdout0_4ck45 FIND v(dout0_4) AT=920.1n

* CHECK dout0_5 Vdout0_5ck45 = 0 time = 920
.meas tran vdout0_5ck45 FIND v(dout0_5) AT=920.1n

* CHECK dout0_6 Vdout0_6ck45 = 1.8 time = 920
.meas tran vdout0_6ck45 FIND v(dout0_6) AT=920.1n

* CHECK dout0_7 Vdout0_7ck45 = 1.8 time = 920
.meas tran vdout0_7ck45 FIND v(dout0_7) AT=920.1n

* CHECK dout0_8 Vdout0_8ck45 = 1.8 time = 920
.meas tran vdout0_8ck45 FIND v(dout0_8) AT=920.1n

* CHECK dout0_9 Vdout0_9ck45 = 0 time = 920
.meas tran vdout0_9ck45 FIND v(dout0_9) AT=920.1n

* CHECK dout0_10 Vdout0_10ck45 = 0 time = 920
.meas tran vdout0_10ck45 FIND v(dout0_10) AT=920.1n

* CHECK dout0_11 Vdout0_11ck45 = 0 time = 920
.meas tran vdout0_11ck45 FIND v(dout0_11) AT=920.1n

* CHECK dout0_12 Vdout0_12ck45 = 0 time = 920
.meas tran vdout0_12ck45 FIND v(dout0_12) AT=920.1n

* CHECK dout0_13 Vdout0_13ck45 = 0 time = 920
.meas tran vdout0_13ck45 FIND v(dout0_13) AT=920.1n

* CHECK dout0_14 Vdout0_14ck45 = 1.8 time = 920
.meas tran vdout0_14ck45 FIND v(dout0_14) AT=920.1n

* CHECK dout0_15 Vdout0_15ck45 = 0 time = 920
.meas tran vdout0_15ck45 FIND v(dout0_15) AT=920.1n

* CHECK dout0_0 Vdout0_0ck48 = 1.8 time = 980
.meas tran vdout0_0ck48 FIND v(dout0_0) AT=980.1n

* CHECK dout0_1 Vdout0_1ck48 = 1.8 time = 980
.meas tran vdout0_1ck48 FIND v(dout0_1) AT=980.1n

* CHECK dout0_2 Vdout0_2ck48 = 1.8 time = 980
.meas tran vdout0_2ck48 FIND v(dout0_2) AT=980.1n

* CHECK dout0_3 Vdout0_3ck48 = 0 time = 980
.meas tran vdout0_3ck48 FIND v(dout0_3) AT=980.1n

* CHECK dout0_4 Vdout0_4ck48 = 1.8 time = 980
.meas tran vdout0_4ck48 FIND v(dout0_4) AT=980.1n

* CHECK dout0_5 Vdout0_5ck48 = 1.8 time = 980
.meas tran vdout0_5ck48 FIND v(dout0_5) AT=980.1n

* CHECK dout0_6 Vdout0_6ck48 = 1.8 time = 980
.meas tran vdout0_6ck48 FIND v(dout0_6) AT=980.1n

* CHECK dout0_7 Vdout0_7ck48 = 0 time = 980
.meas tran vdout0_7ck48 FIND v(dout0_7) AT=980.1n

* CHECK dout0_8 Vdout0_8ck48 = 1.8 time = 980
.meas tran vdout0_8ck48 FIND v(dout0_8) AT=980.1n

* CHECK dout0_9 Vdout0_9ck48 = 1.8 time = 980
.meas tran vdout0_9ck48 FIND v(dout0_9) AT=980.1n

* CHECK dout0_10 Vdout0_10ck48 = 0 time = 980
.meas tran vdout0_10ck48 FIND v(dout0_10) AT=980.1n

* CHECK dout0_11 Vdout0_11ck48 = 0 time = 980
.meas tran vdout0_11ck48 FIND v(dout0_11) AT=980.1n

* CHECK dout0_12 Vdout0_12ck48 = 0 time = 980
.meas tran vdout0_12ck48 FIND v(dout0_12) AT=980.1n

* CHECK dout0_13 Vdout0_13ck48 = 1.8 time = 980
.meas tran vdout0_13ck48 FIND v(dout0_13) AT=980.1n

* CHECK dout0_14 Vdout0_14ck48 = 0 time = 980
.meas tran vdout0_14ck48 FIND v(dout0_14) AT=980.1n

* CHECK dout0_15 Vdout0_15ck48 = 1.8 time = 980
.meas tran vdout0_15ck48 FIND v(dout0_15) AT=980.1n

* CHECK dout0_0 Vdout0_0ck49 = 0 time = 1000
.meas tran vdout0_0ck49 FIND v(dout0_0) AT=1000.1n

* CHECK dout0_1 Vdout0_1ck49 = 0 time = 1000
.meas tran vdout0_1ck49 FIND v(dout0_1) AT=1000.1n

* CHECK dout0_2 Vdout0_2ck49 = 0 time = 1000
.meas tran vdout0_2ck49 FIND v(dout0_2) AT=1000.1n

* CHECK dout0_3 Vdout0_3ck49 = 0 time = 1000
.meas tran vdout0_3ck49 FIND v(dout0_3) AT=1000.1n

* CHECK dout0_4 Vdout0_4ck49 = 1.8 time = 1000
.meas tran vdout0_4ck49 FIND v(dout0_4) AT=1000.1n

* CHECK dout0_5 Vdout0_5ck49 = 0 time = 1000
.meas tran vdout0_5ck49 FIND v(dout0_5) AT=1000.1n

* CHECK dout0_6 Vdout0_6ck49 = 0 time = 1000
.meas tran vdout0_6ck49 FIND v(dout0_6) AT=1000.1n

* CHECK dout0_7 Vdout0_7ck49 = 0 time = 1000
.meas tran vdout0_7ck49 FIND v(dout0_7) AT=1000.1n

* CHECK dout0_8 Vdout0_8ck49 = 1.8 time = 1000
.meas tran vdout0_8ck49 FIND v(dout0_8) AT=1000.1n

* CHECK dout0_9 Vdout0_9ck49 = 0 time = 1000
.meas tran vdout0_9ck49 FIND v(dout0_9) AT=1000.1n

* CHECK dout0_10 Vdout0_10ck49 = 0 time = 1000
.meas tran vdout0_10ck49 FIND v(dout0_10) AT=1000.1n

* CHECK dout0_11 Vdout0_11ck49 = 0 time = 1000
.meas tran vdout0_11ck49 FIND v(dout0_11) AT=1000.1n

* CHECK dout0_12 Vdout0_12ck49 = 0 time = 1000
.meas tran vdout0_12ck49 FIND v(dout0_12) AT=1000.1n

* CHECK dout0_13 Vdout0_13ck49 = 1.8 time = 1000
.meas tran vdout0_13ck49 FIND v(dout0_13) AT=1000.1n

* CHECK dout0_14 Vdout0_14ck49 = 0 time = 1000
.meas tran vdout0_14ck49 FIND v(dout0_14) AT=1000.1n

* CHECK dout0_15 Vdout0_15ck49 = 1.8 time = 1000
.meas tran vdout0_15ck49 FIND v(dout0_15) AT=1000.1n

* CHECK dout0_0 Vdout0_0ck52 = 1.8 time = 1060
.meas tran vdout0_0ck52 FIND v(dout0_0) AT=1060.1n

* CHECK dout0_1 Vdout0_1ck52 = 0 time = 1060
.meas tran vdout0_1ck52 FIND v(dout0_1) AT=1060.1n

* CHECK dout0_2 Vdout0_2ck52 = 0 time = 1060
.meas tran vdout0_2ck52 FIND v(dout0_2) AT=1060.1n

* CHECK dout0_3 Vdout0_3ck52 = 1.8 time = 1060
.meas tran vdout0_3ck52 FIND v(dout0_3) AT=1060.1n

* CHECK dout0_4 Vdout0_4ck52 = 0 time = 1060
.meas tran vdout0_4ck52 FIND v(dout0_4) AT=1060.1n

* CHECK dout0_5 Vdout0_5ck52 = 1.8 time = 1060
.meas tran vdout0_5ck52 FIND v(dout0_5) AT=1060.1n

* CHECK dout0_6 Vdout0_6ck52 = 1.8 time = 1060
.meas tran vdout0_6ck52 FIND v(dout0_6) AT=1060.1n

* CHECK dout0_7 Vdout0_7ck52 = 0 time = 1060
.meas tran vdout0_7ck52 FIND v(dout0_7) AT=1060.1n

* CHECK dout0_8 Vdout0_8ck52 = 1.8 time = 1060
.meas tran vdout0_8ck52 FIND v(dout0_8) AT=1060.1n

* CHECK dout0_9 Vdout0_9ck52 = 0 time = 1060
.meas tran vdout0_9ck52 FIND v(dout0_9) AT=1060.1n

* CHECK dout0_10 Vdout0_10ck52 = 0 time = 1060
.meas tran vdout0_10ck52 FIND v(dout0_10) AT=1060.1n

* CHECK dout0_11 Vdout0_11ck52 = 1.8 time = 1060
.meas tran vdout0_11ck52 FIND v(dout0_11) AT=1060.1n

* CHECK dout0_12 Vdout0_12ck52 = 0 time = 1060
.meas tran vdout0_12ck52 FIND v(dout0_12) AT=1060.1n

* CHECK dout0_13 Vdout0_13ck52 = 1.8 time = 1060
.meas tran vdout0_13ck52 FIND v(dout0_13) AT=1060.1n

* CHECK dout0_14 Vdout0_14ck52 = 1.8 time = 1060
.meas tran vdout0_14ck52 FIND v(dout0_14) AT=1060.1n

* CHECK dout0_15 Vdout0_15ck52 = 1.8 time = 1060
.meas tran vdout0_15ck52 FIND v(dout0_15) AT=1060.1n

* CHECK dout0_0 Vdout0_0ck54 = 0 time = 1100
.meas tran vdout0_0ck54 FIND v(dout0_0) AT=1100.1n

* CHECK dout0_1 Vdout0_1ck54 = 1.8 time = 1100
.meas tran vdout0_1ck54 FIND v(dout0_1) AT=1100.1n

* CHECK dout0_2 Vdout0_2ck54 = 1.8 time = 1100
.meas tran vdout0_2ck54 FIND v(dout0_2) AT=1100.1n

* CHECK dout0_3 Vdout0_3ck54 = 0 time = 1100
.meas tran vdout0_3ck54 FIND v(dout0_3) AT=1100.1n

* CHECK dout0_4 Vdout0_4ck54 = 0 time = 1100
.meas tran vdout0_4ck54 FIND v(dout0_4) AT=1100.1n

* CHECK dout0_5 Vdout0_5ck54 = 0 time = 1100
.meas tran vdout0_5ck54 FIND v(dout0_5) AT=1100.1n

* CHECK dout0_6 Vdout0_6ck54 = 1.8 time = 1100
.meas tran vdout0_6ck54 FIND v(dout0_6) AT=1100.1n

* CHECK dout0_7 Vdout0_7ck54 = 1.8 time = 1100
.meas tran vdout0_7ck54 FIND v(dout0_7) AT=1100.1n

* CHECK dout0_8 Vdout0_8ck54 = 1.8 time = 1100
.meas tran vdout0_8ck54 FIND v(dout0_8) AT=1100.1n

* CHECK dout0_9 Vdout0_9ck54 = 0 time = 1100
.meas tran vdout0_9ck54 FIND v(dout0_9) AT=1100.1n

* CHECK dout0_10 Vdout0_10ck54 = 0 time = 1100
.meas tran vdout0_10ck54 FIND v(dout0_10) AT=1100.1n

* CHECK dout0_11 Vdout0_11ck54 = 0 time = 1100
.meas tran vdout0_11ck54 FIND v(dout0_11) AT=1100.1n

* CHECK dout0_12 Vdout0_12ck54 = 0 time = 1100
.meas tran vdout0_12ck54 FIND v(dout0_12) AT=1100.1n

* CHECK dout0_13 Vdout0_13ck54 = 0 time = 1100
.meas tran vdout0_13ck54 FIND v(dout0_13) AT=1100.1n

* CHECK dout0_14 Vdout0_14ck54 = 1.8 time = 1100
.meas tran vdout0_14ck54 FIND v(dout0_14) AT=1100.1n

* CHECK dout0_15 Vdout0_15ck54 = 0 time = 1100
.meas tran vdout0_15ck54 FIND v(dout0_15) AT=1100.1n

* CHECK dout0_0 Vdout0_0ck56 = 0 time = 1140
.meas tran vdout0_0ck56 FIND v(dout0_0) AT=1140.1n

* CHECK dout0_1 Vdout0_1ck56 = 0 time = 1140
.meas tran vdout0_1ck56 FIND v(dout0_1) AT=1140.1n

* CHECK dout0_2 Vdout0_2ck56 = 1.8 time = 1140
.meas tran vdout0_2ck56 FIND v(dout0_2) AT=1140.1n

* CHECK dout0_3 Vdout0_3ck56 = 1.8 time = 1140
.meas tran vdout0_3ck56 FIND v(dout0_3) AT=1140.1n

* CHECK dout0_4 Vdout0_4ck56 = 0 time = 1140
.meas tran vdout0_4ck56 FIND v(dout0_4) AT=1140.1n

* CHECK dout0_5 Vdout0_5ck56 = 1.8 time = 1140
.meas tran vdout0_5ck56 FIND v(dout0_5) AT=1140.1n

* CHECK dout0_6 Vdout0_6ck56 = 0 time = 1140
.meas tran vdout0_6ck56 FIND v(dout0_6) AT=1140.1n

* CHECK dout0_7 Vdout0_7ck56 = 0 time = 1140
.meas tran vdout0_7ck56 FIND v(dout0_7) AT=1140.1n

* CHECK dout0_8 Vdout0_8ck56 = 0 time = 1140
.meas tran vdout0_8ck56 FIND v(dout0_8) AT=1140.1n

* CHECK dout0_9 Vdout0_9ck56 = 1.8 time = 1140
.meas tran vdout0_9ck56 FIND v(dout0_9) AT=1140.1n

* CHECK dout0_10 Vdout0_10ck56 = 1.8 time = 1140
.meas tran vdout0_10ck56 FIND v(dout0_10) AT=1140.1n

* CHECK dout0_11 Vdout0_11ck56 = 0 time = 1140
.meas tran vdout0_11ck56 FIND v(dout0_11) AT=1140.1n

* CHECK dout0_12 Vdout0_12ck56 = 1.8 time = 1140
.meas tran vdout0_12ck56 FIND v(dout0_12) AT=1140.1n

* CHECK dout0_13 Vdout0_13ck56 = 0 time = 1140
.meas tran vdout0_13ck56 FIND v(dout0_13) AT=1140.1n

* CHECK dout0_14 Vdout0_14ck56 = 0 time = 1140
.meas tran vdout0_14ck56 FIND v(dout0_14) AT=1140.1n

* CHECK dout0_15 Vdout0_15ck56 = 1.8 time = 1140
.meas tran vdout0_15ck56 FIND v(dout0_15) AT=1140.1n

* CHECK dout0_0 Vdout0_0ck58 = 1.8 time = 1180
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=1180.1n

* CHECK dout0_1 Vdout0_1ck58 = 1.8 time = 1180
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=1180.1n

* CHECK dout0_2 Vdout0_2ck58 = 1.8 time = 1180
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=1180.1n

* CHECK dout0_3 Vdout0_3ck58 = 0 time = 1180
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=1180.1n

* CHECK dout0_4 Vdout0_4ck58 = 1.8 time = 1180
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=1180.1n

* CHECK dout0_5 Vdout0_5ck58 = 1.8 time = 1180
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=1180.1n

* CHECK dout0_6 Vdout0_6ck58 = 1.8 time = 1180
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=1180.1n

* CHECK dout0_7 Vdout0_7ck58 = 0 time = 1180
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=1180.1n

* CHECK dout0_8 Vdout0_8ck58 = 1.8 time = 1180
.meas tran vdout0_8ck58 FIND v(dout0_8) AT=1180.1n

* CHECK dout0_9 Vdout0_9ck58 = 1.8 time = 1180
.meas tran vdout0_9ck58 FIND v(dout0_9) AT=1180.1n

* CHECK dout0_10 Vdout0_10ck58 = 0 time = 1180
.meas tran vdout0_10ck58 FIND v(dout0_10) AT=1180.1n

* CHECK dout0_11 Vdout0_11ck58 = 0 time = 1180
.meas tran vdout0_11ck58 FIND v(dout0_11) AT=1180.1n

* CHECK dout0_12 Vdout0_12ck58 = 0 time = 1180
.meas tran vdout0_12ck58 FIND v(dout0_12) AT=1180.1n

* CHECK dout0_13 Vdout0_13ck58 = 1.8 time = 1180
.meas tran vdout0_13ck58 FIND v(dout0_13) AT=1180.1n

* CHECK dout0_14 Vdout0_14ck58 = 0 time = 1180
.meas tran vdout0_14ck58 FIND v(dout0_14) AT=1180.1n

* CHECK dout0_15 Vdout0_15ck58 = 1.8 time = 1180
.meas tran vdout0_15ck58 FIND v(dout0_15) AT=1180.1n

* CHECK dout0_0 Vdout0_0ck61 = 1.8 time = 1240
.meas tran vdout0_0ck61 FIND v(dout0_0) AT=1240.1n

* CHECK dout0_1 Vdout0_1ck61 = 0 time = 1240
.meas tran vdout0_1ck61 FIND v(dout0_1) AT=1240.1n

* CHECK dout0_2 Vdout0_2ck61 = 0 time = 1240
.meas tran vdout0_2ck61 FIND v(dout0_2) AT=1240.1n

* CHECK dout0_3 Vdout0_3ck61 = 1.8 time = 1240
.meas tran vdout0_3ck61 FIND v(dout0_3) AT=1240.1n

* CHECK dout0_4 Vdout0_4ck61 = 0 time = 1240
.meas tran vdout0_4ck61 FIND v(dout0_4) AT=1240.1n

* CHECK dout0_5 Vdout0_5ck61 = 1.8 time = 1240
.meas tran vdout0_5ck61 FIND v(dout0_5) AT=1240.1n

* CHECK dout0_6 Vdout0_6ck61 = 0 time = 1240
.meas tran vdout0_6ck61 FIND v(dout0_6) AT=1240.1n

* CHECK dout0_7 Vdout0_7ck61 = 0 time = 1240
.meas tran vdout0_7ck61 FIND v(dout0_7) AT=1240.1n

* CHECK dout0_8 Vdout0_8ck61 = 0 time = 1240
.meas tran vdout0_8ck61 FIND v(dout0_8) AT=1240.1n

* CHECK dout0_9 Vdout0_9ck61 = 0 time = 1240
.meas tran vdout0_9ck61 FIND v(dout0_9) AT=1240.1n

* CHECK dout0_10 Vdout0_10ck61 = 0 time = 1240
.meas tran vdout0_10ck61 FIND v(dout0_10) AT=1240.1n

* CHECK dout0_11 Vdout0_11ck61 = 1.8 time = 1240
.meas tran vdout0_11ck61 FIND v(dout0_11) AT=1240.1n

* CHECK dout0_12 Vdout0_12ck61 = 0 time = 1240
.meas tran vdout0_12ck61 FIND v(dout0_12) AT=1240.1n

* CHECK dout0_13 Vdout0_13ck61 = 1.8 time = 1240
.meas tran vdout0_13ck61 FIND v(dout0_13) AT=1240.1n

* CHECK dout0_14 Vdout0_14ck61 = 0 time = 1240
.meas tran vdout0_14ck61 FIND v(dout0_14) AT=1240.1n

* CHECK dout0_15 Vdout0_15ck61 = 1.8 time = 1240
.meas tran vdout0_15ck61 FIND v(dout0_15) AT=1240.1n

* CHECK dout0_0 Vdout0_0ck63 = 0 time = 1280
.meas tran vdout0_0ck63 FIND v(dout0_0) AT=1280.1n

* CHECK dout0_1 Vdout0_1ck63 = 1.8 time = 1280
.meas tran vdout0_1ck63 FIND v(dout0_1) AT=1280.1n

* CHECK dout0_2 Vdout0_2ck63 = 1.8 time = 1280
.meas tran vdout0_2ck63 FIND v(dout0_2) AT=1280.1n

* CHECK dout0_3 Vdout0_3ck63 = 0 time = 1280
.meas tran vdout0_3ck63 FIND v(dout0_3) AT=1280.1n

* CHECK dout0_4 Vdout0_4ck63 = 0 time = 1280
.meas tran vdout0_4ck63 FIND v(dout0_4) AT=1280.1n

* CHECK dout0_5 Vdout0_5ck63 = 1.8 time = 1280
.meas tran vdout0_5ck63 FIND v(dout0_5) AT=1280.1n

* CHECK dout0_6 Vdout0_6ck63 = 0 time = 1280
.meas tran vdout0_6ck63 FIND v(dout0_6) AT=1280.1n

* CHECK dout0_7 Vdout0_7ck63 = 1.8 time = 1280
.meas tran vdout0_7ck63 FIND v(dout0_7) AT=1280.1n

* CHECK dout0_8 Vdout0_8ck63 = 0 time = 1280
.meas tran vdout0_8ck63 FIND v(dout0_8) AT=1280.1n

* CHECK dout0_9 Vdout0_9ck63 = 0 time = 1280
.meas tran vdout0_9ck63 FIND v(dout0_9) AT=1280.1n

* CHECK dout0_10 Vdout0_10ck63 = 1.8 time = 1280
.meas tran vdout0_10ck63 FIND v(dout0_10) AT=1280.1n

* CHECK dout0_11 Vdout0_11ck63 = 0 time = 1280
.meas tran vdout0_11ck63 FIND v(dout0_11) AT=1280.1n

* CHECK dout0_12 Vdout0_12ck63 = 0 time = 1280
.meas tran vdout0_12ck63 FIND v(dout0_12) AT=1280.1n

* CHECK dout0_13 Vdout0_13ck63 = 0 time = 1280
.meas tran vdout0_13ck63 FIND v(dout0_13) AT=1280.1n

* CHECK dout0_14 Vdout0_14ck63 = 1.8 time = 1280
.meas tran vdout0_14ck63 FIND v(dout0_14) AT=1280.1n

* CHECK dout0_15 Vdout0_15ck63 = 1.8 time = 1280
.meas tran vdout0_15ck63 FIND v(dout0_15) AT=1280.1n

* CHECK dout0_0 Vdout0_0ck64 = 0 time = 1300
.meas tran vdout0_0ck64 FIND v(dout0_0) AT=1300.1n

* CHECK dout0_1 Vdout0_1ck64 = 1.8 time = 1300
.meas tran vdout0_1ck64 FIND v(dout0_1) AT=1300.1n

* CHECK dout0_2 Vdout0_2ck64 = 1.8 time = 1300
.meas tran vdout0_2ck64 FIND v(dout0_2) AT=1300.1n

* CHECK dout0_3 Vdout0_3ck64 = 0 time = 1300
.meas tran vdout0_3ck64 FIND v(dout0_3) AT=1300.1n

* CHECK dout0_4 Vdout0_4ck64 = 0 time = 1300
.meas tran vdout0_4ck64 FIND v(dout0_4) AT=1300.1n

* CHECK dout0_5 Vdout0_5ck64 = 1.8 time = 1300
.meas tran vdout0_5ck64 FIND v(dout0_5) AT=1300.1n

* CHECK dout0_6 Vdout0_6ck64 = 0 time = 1300
.meas tran vdout0_6ck64 FIND v(dout0_6) AT=1300.1n

* CHECK dout0_7 Vdout0_7ck64 = 1.8 time = 1300
.meas tran vdout0_7ck64 FIND v(dout0_7) AT=1300.1n

* CHECK dout0_8 Vdout0_8ck64 = 0 time = 1300
.meas tran vdout0_8ck64 FIND v(dout0_8) AT=1300.1n

* CHECK dout0_9 Vdout0_9ck64 = 0 time = 1300
.meas tran vdout0_9ck64 FIND v(dout0_9) AT=1300.1n

* CHECK dout0_10 Vdout0_10ck64 = 1.8 time = 1300
.meas tran vdout0_10ck64 FIND v(dout0_10) AT=1300.1n

* CHECK dout0_11 Vdout0_11ck64 = 0 time = 1300
.meas tran vdout0_11ck64 FIND v(dout0_11) AT=1300.1n

* CHECK dout0_12 Vdout0_12ck64 = 0 time = 1300
.meas tran vdout0_12ck64 FIND v(dout0_12) AT=1300.1n

* CHECK dout0_13 Vdout0_13ck64 = 0 time = 1300
.meas tran vdout0_13ck64 FIND v(dout0_13) AT=1300.1n

* CHECK dout0_14 Vdout0_14ck64 = 1.8 time = 1300
.meas tran vdout0_14ck64 FIND v(dout0_14) AT=1300.1n

* CHECK dout0_15 Vdout0_15ck64 = 1.8 time = 1300
.meas tran vdout0_15ck64 FIND v(dout0_15) AT=1300.1n

* CHECK dout0_0 Vdout0_0ck67 = 1.8 time = 1360
.meas tran vdout0_0ck67 FIND v(dout0_0) AT=1360.1n

* CHECK dout0_1 Vdout0_1ck67 = 1.8 time = 1360
.meas tran vdout0_1ck67 FIND v(dout0_1) AT=1360.1n

* CHECK dout0_2 Vdout0_2ck67 = 1.8 time = 1360
.meas tran vdout0_2ck67 FIND v(dout0_2) AT=1360.1n

* CHECK dout0_3 Vdout0_3ck67 = 0 time = 1360
.meas tran vdout0_3ck67 FIND v(dout0_3) AT=1360.1n

* CHECK dout0_4 Vdout0_4ck67 = 0 time = 1360
.meas tran vdout0_4ck67 FIND v(dout0_4) AT=1360.1n

* CHECK dout0_5 Vdout0_5ck67 = 0 time = 1360
.meas tran vdout0_5ck67 FIND v(dout0_5) AT=1360.1n

* CHECK dout0_6 Vdout0_6ck67 = 1.8 time = 1360
.meas tran vdout0_6ck67 FIND v(dout0_6) AT=1360.1n

* CHECK dout0_7 Vdout0_7ck67 = 1.8 time = 1360
.meas tran vdout0_7ck67 FIND v(dout0_7) AT=1360.1n

* CHECK dout0_8 Vdout0_8ck67 = 0 time = 1360
.meas tran vdout0_8ck67 FIND v(dout0_8) AT=1360.1n

* CHECK dout0_9 Vdout0_9ck67 = 1.8 time = 1360
.meas tran vdout0_9ck67 FIND v(dout0_9) AT=1360.1n

* CHECK dout0_10 Vdout0_10ck67 = 1.8 time = 1360
.meas tran vdout0_10ck67 FIND v(dout0_10) AT=1360.1n

* CHECK dout0_11 Vdout0_11ck67 = 0 time = 1360
.meas tran vdout0_11ck67 FIND v(dout0_11) AT=1360.1n

* CHECK dout0_12 Vdout0_12ck67 = 0 time = 1360
.meas tran vdout0_12ck67 FIND v(dout0_12) AT=1360.1n

* CHECK dout0_13 Vdout0_13ck67 = 1.8 time = 1360
.meas tran vdout0_13ck67 FIND v(dout0_13) AT=1360.1n

* CHECK dout0_14 Vdout0_14ck67 = 0 time = 1360
.meas tran vdout0_14ck67 FIND v(dout0_14) AT=1360.1n

* CHECK dout0_15 Vdout0_15ck67 = 1.8 time = 1360
.meas tran vdout0_15ck67 FIND v(dout0_15) AT=1360.1n

* CHECK dout0_0 Vdout0_0ck74 = 0 time = 1500
.meas tran vdout0_0ck74 FIND v(dout0_0) AT=1500.1n

* CHECK dout0_1 Vdout0_1ck74 = 0 time = 1500
.meas tran vdout0_1ck74 FIND v(dout0_1) AT=1500.1n

* CHECK dout0_2 Vdout0_2ck74 = 1.8 time = 1500
.meas tran vdout0_2ck74 FIND v(dout0_2) AT=1500.1n

* CHECK dout0_3 Vdout0_3ck74 = 1.8 time = 1500
.meas tran vdout0_3ck74 FIND v(dout0_3) AT=1500.1n

* CHECK dout0_4 Vdout0_4ck74 = 0 time = 1500
.meas tran vdout0_4ck74 FIND v(dout0_4) AT=1500.1n

* CHECK dout0_5 Vdout0_5ck74 = 1.8 time = 1500
.meas tran vdout0_5ck74 FIND v(dout0_5) AT=1500.1n

* CHECK dout0_6 Vdout0_6ck74 = 0 time = 1500
.meas tran vdout0_6ck74 FIND v(dout0_6) AT=1500.1n

* CHECK dout0_7 Vdout0_7ck74 = 0 time = 1500
.meas tran vdout0_7ck74 FIND v(dout0_7) AT=1500.1n

* CHECK dout0_8 Vdout0_8ck74 = 0 time = 1500
.meas tran vdout0_8ck74 FIND v(dout0_8) AT=1500.1n

* CHECK dout0_9 Vdout0_9ck74 = 1.8 time = 1500
.meas tran vdout0_9ck74 FIND v(dout0_9) AT=1500.1n

* CHECK dout0_10 Vdout0_10ck74 = 1.8 time = 1500
.meas tran vdout0_10ck74 FIND v(dout0_10) AT=1500.1n

* CHECK dout0_11 Vdout0_11ck74 = 0 time = 1500
.meas tran vdout0_11ck74 FIND v(dout0_11) AT=1500.1n

* CHECK dout0_12 Vdout0_12ck74 = 1.8 time = 1500
.meas tran vdout0_12ck74 FIND v(dout0_12) AT=1500.1n

* CHECK dout0_13 Vdout0_13ck74 = 0 time = 1500
.meas tran vdout0_13ck74 FIND v(dout0_13) AT=1500.1n

* CHECK dout0_14 Vdout0_14ck74 = 0 time = 1500
.meas tran vdout0_14ck74 FIND v(dout0_14) AT=1500.1n

* CHECK dout0_15 Vdout0_15ck74 = 1.8 time = 1500
.meas tran vdout0_15ck74 FIND v(dout0_15) AT=1500.1n

* CHECK dout0_0 Vdout0_0ck77 = 0 time = 1560
.meas tran vdout0_0ck77 FIND v(dout0_0) AT=1560.1n

* CHECK dout0_1 Vdout0_1ck77 = 0 time = 1560
.meas tran vdout0_1ck77 FIND v(dout0_1) AT=1560.1n

* CHECK dout0_2 Vdout0_2ck77 = 0 time = 1560
.meas tran vdout0_2ck77 FIND v(dout0_2) AT=1560.1n

* CHECK dout0_3 Vdout0_3ck77 = 1.8 time = 1560
.meas tran vdout0_3ck77 FIND v(dout0_3) AT=1560.1n

* CHECK dout0_4 Vdout0_4ck77 = 0 time = 1560
.meas tran vdout0_4ck77 FIND v(dout0_4) AT=1560.1n

* CHECK dout0_5 Vdout0_5ck77 = 0 time = 1560
.meas tran vdout0_5ck77 FIND v(dout0_5) AT=1560.1n

* CHECK dout0_6 Vdout0_6ck77 = 0 time = 1560
.meas tran vdout0_6ck77 FIND v(dout0_6) AT=1560.1n

* CHECK dout0_7 Vdout0_7ck77 = 0 time = 1560
.meas tran vdout0_7ck77 FIND v(dout0_7) AT=1560.1n

* CHECK dout0_8 Vdout0_8ck77 = 1.8 time = 1560
.meas tran vdout0_8ck77 FIND v(dout0_8) AT=1560.1n

* CHECK dout0_9 Vdout0_9ck77 = 1.8 time = 1560
.meas tran vdout0_9ck77 FIND v(dout0_9) AT=1560.1n

* CHECK dout0_10 Vdout0_10ck77 = 1.8 time = 1560
.meas tran vdout0_10ck77 FIND v(dout0_10) AT=1560.1n

* CHECK dout0_11 Vdout0_11ck77 = 0 time = 1560
.meas tran vdout0_11ck77 FIND v(dout0_11) AT=1560.1n

* CHECK dout0_12 Vdout0_12ck77 = 1.8 time = 1560
.meas tran vdout0_12ck77 FIND v(dout0_12) AT=1560.1n

* CHECK dout0_13 Vdout0_13ck77 = 0 time = 1560
.meas tran vdout0_13ck77 FIND v(dout0_13) AT=1560.1n

* CHECK dout0_14 Vdout0_14ck77 = 1.8 time = 1560
.meas tran vdout0_14ck77 FIND v(dout0_14) AT=1560.1n

* CHECK dout0_15 Vdout0_15ck77 = 0 time = 1560
.meas tran vdout0_15ck77 FIND v(dout0_15) AT=1560.1n

* CHECK dout0_0 Vdout0_0ck78 = 0 time = 1580
.meas tran vdout0_0ck78 FIND v(dout0_0) AT=1580.1n

* CHECK dout0_1 Vdout0_1ck78 = 0 time = 1580
.meas tran vdout0_1ck78 FIND v(dout0_1) AT=1580.1n

* CHECK dout0_2 Vdout0_2ck78 = 0 time = 1580
.meas tran vdout0_2ck78 FIND v(dout0_2) AT=1580.1n

* CHECK dout0_3 Vdout0_3ck78 = 1.8 time = 1580
.meas tran vdout0_3ck78 FIND v(dout0_3) AT=1580.1n

* CHECK dout0_4 Vdout0_4ck78 = 0 time = 1580
.meas tran vdout0_4ck78 FIND v(dout0_4) AT=1580.1n

* CHECK dout0_5 Vdout0_5ck78 = 0 time = 1580
.meas tran vdout0_5ck78 FIND v(dout0_5) AT=1580.1n

* CHECK dout0_6 Vdout0_6ck78 = 0 time = 1580
.meas tran vdout0_6ck78 FIND v(dout0_6) AT=1580.1n

* CHECK dout0_7 Vdout0_7ck78 = 0 time = 1580
.meas tran vdout0_7ck78 FIND v(dout0_7) AT=1580.1n

* CHECK dout0_8 Vdout0_8ck78 = 1.8 time = 1580
.meas tran vdout0_8ck78 FIND v(dout0_8) AT=1580.1n

* CHECK dout0_9 Vdout0_9ck78 = 1.8 time = 1580
.meas tran vdout0_9ck78 FIND v(dout0_9) AT=1580.1n

* CHECK dout0_10 Vdout0_10ck78 = 1.8 time = 1580
.meas tran vdout0_10ck78 FIND v(dout0_10) AT=1580.1n

* CHECK dout0_11 Vdout0_11ck78 = 0 time = 1580
.meas tran vdout0_11ck78 FIND v(dout0_11) AT=1580.1n

* CHECK dout0_12 Vdout0_12ck78 = 1.8 time = 1580
.meas tran vdout0_12ck78 FIND v(dout0_12) AT=1580.1n

* CHECK dout0_13 Vdout0_13ck78 = 0 time = 1580
.meas tran vdout0_13ck78 FIND v(dout0_13) AT=1580.1n

* CHECK dout0_14 Vdout0_14ck78 = 1.8 time = 1580
.meas tran vdout0_14ck78 FIND v(dout0_14) AT=1580.1n

* CHECK dout0_15 Vdout0_15ck78 = 0 time = 1580
.meas tran vdout0_15ck78 FIND v(dout0_15) AT=1580.1n

* CHECK dout0_0 Vdout0_0ck80 = 1.8 time = 1620
.meas tran vdout0_0ck80 FIND v(dout0_0) AT=1620.1n

* CHECK dout0_1 Vdout0_1ck80 = 0 time = 1620
.meas tran vdout0_1ck80 FIND v(dout0_1) AT=1620.1n

* CHECK dout0_2 Vdout0_2ck80 = 1.8 time = 1620
.meas tran vdout0_2ck80 FIND v(dout0_2) AT=1620.1n

* CHECK dout0_3 Vdout0_3ck80 = 1.8 time = 1620
.meas tran vdout0_3ck80 FIND v(dout0_3) AT=1620.1n

* CHECK dout0_4 Vdout0_4ck80 = 1.8 time = 1620
.meas tran vdout0_4ck80 FIND v(dout0_4) AT=1620.1n

* CHECK dout0_5 Vdout0_5ck80 = 1.8 time = 1620
.meas tran vdout0_5ck80 FIND v(dout0_5) AT=1620.1n

* CHECK dout0_6 Vdout0_6ck80 = 0 time = 1620
.meas tran vdout0_6ck80 FIND v(dout0_6) AT=1620.1n

* CHECK dout0_7 Vdout0_7ck80 = 1.8 time = 1620
.meas tran vdout0_7ck80 FIND v(dout0_7) AT=1620.1n

* CHECK dout0_8 Vdout0_8ck80 = 1.8 time = 1620
.meas tran vdout0_8ck80 FIND v(dout0_8) AT=1620.1n

* CHECK dout0_9 Vdout0_9ck80 = 1.8 time = 1620
.meas tran vdout0_9ck80 FIND v(dout0_9) AT=1620.1n

* CHECK dout0_10 Vdout0_10ck80 = 1.8 time = 1620
.meas tran vdout0_10ck80 FIND v(dout0_10) AT=1620.1n

* CHECK dout0_11 Vdout0_11ck80 = 1.8 time = 1620
.meas tran vdout0_11ck80 FIND v(dout0_11) AT=1620.1n

* CHECK dout0_12 Vdout0_12ck80 = 0 time = 1620
.meas tran vdout0_12ck80 FIND v(dout0_12) AT=1620.1n

* CHECK dout0_13 Vdout0_13ck80 = 0 time = 1620
.meas tran vdout0_13ck80 FIND v(dout0_13) AT=1620.1n

* CHECK dout0_14 Vdout0_14ck80 = 1.8 time = 1620
.meas tran vdout0_14ck80 FIND v(dout0_14) AT=1620.1n

* CHECK dout0_15 Vdout0_15ck80 = 0 time = 1620
.meas tran vdout0_15ck80 FIND v(dout0_15) AT=1620.1n

* CHECK dout0_0 Vdout0_0ck81 = 0 time = 1640
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=1640.1n

* CHECK dout0_1 Vdout0_1ck81 = 1.8 time = 1640
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=1640.1n

* CHECK dout0_2 Vdout0_2ck81 = 1.8 time = 1640
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=1640.1n

* CHECK dout0_3 Vdout0_3ck81 = 0 time = 1640
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=1640.1n

* CHECK dout0_4 Vdout0_4ck81 = 0 time = 1640
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=1640.1n

* CHECK dout0_5 Vdout0_5ck81 = 0 time = 1640
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=1640.1n

* CHECK dout0_6 Vdout0_6ck81 = 0 time = 1640
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=1640.1n

* CHECK dout0_7 Vdout0_7ck81 = 1.8 time = 1640
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=1640.1n

* CHECK dout0_8 Vdout0_8ck81 = 1.8 time = 1640
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=1640.1n

* CHECK dout0_9 Vdout0_9ck81 = 1.8 time = 1640
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=1640.1n

* CHECK dout0_10 Vdout0_10ck81 = 0 time = 1640
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=1640.1n

* CHECK dout0_11 Vdout0_11ck81 = 1.8 time = 1640
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=1640.1n

* CHECK dout0_12 Vdout0_12ck81 = 0 time = 1640
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=1640.1n

* CHECK dout0_13 Vdout0_13ck81 = 0 time = 1640
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=1640.1n

* CHECK dout0_14 Vdout0_14ck81 = 0 time = 1640
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=1640.1n

* CHECK dout0_15 Vdout0_15ck81 = 0 time = 1640
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=1640.1n

* CHECK dout0_0 Vdout0_0ck82 = 0 time = 1660
.meas tran vdout0_0ck82 FIND v(dout0_0) AT=1660.1n

* CHECK dout0_1 Vdout0_1ck82 = 0 time = 1660
.meas tran vdout0_1ck82 FIND v(dout0_1) AT=1660.1n

* CHECK dout0_2 Vdout0_2ck82 = 1.8 time = 1660
.meas tran vdout0_2ck82 FIND v(dout0_2) AT=1660.1n

* CHECK dout0_3 Vdout0_3ck82 = 1.8 time = 1660
.meas tran vdout0_3ck82 FIND v(dout0_3) AT=1660.1n

* CHECK dout0_4 Vdout0_4ck82 = 0 time = 1660
.meas tran vdout0_4ck82 FIND v(dout0_4) AT=1660.1n

* CHECK dout0_5 Vdout0_5ck82 = 1.8 time = 1660
.meas tran vdout0_5ck82 FIND v(dout0_5) AT=1660.1n

* CHECK dout0_6 Vdout0_6ck82 = 0 time = 1660
.meas tran vdout0_6ck82 FIND v(dout0_6) AT=1660.1n

* CHECK dout0_7 Vdout0_7ck82 = 0 time = 1660
.meas tran vdout0_7ck82 FIND v(dout0_7) AT=1660.1n

* CHECK dout0_8 Vdout0_8ck82 = 0 time = 1660
.meas tran vdout0_8ck82 FIND v(dout0_8) AT=1660.1n

* CHECK dout0_9 Vdout0_9ck82 = 1.8 time = 1660
.meas tran vdout0_9ck82 FIND v(dout0_9) AT=1660.1n

* CHECK dout0_10 Vdout0_10ck82 = 1.8 time = 1660
.meas tran vdout0_10ck82 FIND v(dout0_10) AT=1660.1n

* CHECK dout0_11 Vdout0_11ck82 = 0 time = 1660
.meas tran vdout0_11ck82 FIND v(dout0_11) AT=1660.1n

* CHECK dout0_12 Vdout0_12ck82 = 1.8 time = 1660
.meas tran vdout0_12ck82 FIND v(dout0_12) AT=1660.1n

* CHECK dout0_13 Vdout0_13ck82 = 0 time = 1660
.meas tran vdout0_13ck82 FIND v(dout0_13) AT=1660.1n

* CHECK dout0_14 Vdout0_14ck82 = 0 time = 1660
.meas tran vdout0_14ck82 FIND v(dout0_14) AT=1660.1n

* CHECK dout0_15 Vdout0_15ck82 = 1.8 time = 1660
.meas tran vdout0_15ck82 FIND v(dout0_15) AT=1660.1n

* CHECK dout0_0 Vdout0_0ck83 = 1.8 time = 1680
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=1680.1n

* CHECK dout0_1 Vdout0_1ck83 = 0 time = 1680
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=1680.1n

* CHECK dout0_2 Vdout0_2ck83 = 1.8 time = 1680
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=1680.1n

* CHECK dout0_3 Vdout0_3ck83 = 1.8 time = 1680
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=1680.1n

* CHECK dout0_4 Vdout0_4ck83 = 1.8 time = 1680
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=1680.1n

* CHECK dout0_5 Vdout0_5ck83 = 1.8 time = 1680
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=1680.1n

* CHECK dout0_6 Vdout0_6ck83 = 0 time = 1680
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=1680.1n

* CHECK dout0_7 Vdout0_7ck83 = 1.8 time = 1680
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=1680.1n

* CHECK dout0_8 Vdout0_8ck83 = 1.8 time = 1680
.meas tran vdout0_8ck83 FIND v(dout0_8) AT=1680.1n

* CHECK dout0_9 Vdout0_9ck83 = 1.8 time = 1680
.meas tran vdout0_9ck83 FIND v(dout0_9) AT=1680.1n

* CHECK dout0_10 Vdout0_10ck83 = 1.8 time = 1680
.meas tran vdout0_10ck83 FIND v(dout0_10) AT=1680.1n

* CHECK dout0_11 Vdout0_11ck83 = 1.8 time = 1680
.meas tran vdout0_11ck83 FIND v(dout0_11) AT=1680.1n

* CHECK dout0_12 Vdout0_12ck83 = 0 time = 1680
.meas tran vdout0_12ck83 FIND v(dout0_12) AT=1680.1n

* CHECK dout0_13 Vdout0_13ck83 = 0 time = 1680
.meas tran vdout0_13ck83 FIND v(dout0_13) AT=1680.1n

* CHECK dout0_14 Vdout0_14ck83 = 1.8 time = 1680
.meas tran vdout0_14ck83 FIND v(dout0_14) AT=1680.1n

* CHECK dout0_15 Vdout0_15ck83 = 0 time = 1680
.meas tran vdout0_15ck83 FIND v(dout0_15) AT=1680.1n

* CHECK dout0_0 Vdout0_0ck86 = 0 time = 1740
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=1740.1n

* CHECK dout0_1 Vdout0_1ck86 = 1.8 time = 1740
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=1740.1n

* CHECK dout0_2 Vdout0_2ck86 = 1.8 time = 1740
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=1740.1n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 1740
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=1740.1n

* CHECK dout0_4 Vdout0_4ck86 = 0 time = 1740
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=1740.1n

* CHECK dout0_5 Vdout0_5ck86 = 1.8 time = 1740
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=1740.1n

* CHECK dout0_6 Vdout0_6ck86 = 0 time = 1740
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=1740.1n

* CHECK dout0_7 Vdout0_7ck86 = 1.8 time = 1740
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=1740.1n

* CHECK dout0_8 Vdout0_8ck86 = 0 time = 1740
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=1740.1n

* CHECK dout0_9 Vdout0_9ck86 = 0 time = 1740
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=1740.1n

* CHECK dout0_10 Vdout0_10ck86 = 1.8 time = 1740
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=1740.1n

* CHECK dout0_11 Vdout0_11ck86 = 0 time = 1740
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=1740.1n

* CHECK dout0_12 Vdout0_12ck86 = 0 time = 1740
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=1740.1n

* CHECK dout0_13 Vdout0_13ck86 = 0 time = 1740
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=1740.1n

* CHECK dout0_14 Vdout0_14ck86 = 1.8 time = 1740
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=1740.1n

* CHECK dout0_15 Vdout0_15ck86 = 1.8 time = 1740
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=1740.1n

* CHECK dout0_0 Vdout0_0ck87 = 0 time = 1760
.meas tran vdout0_0ck87 FIND v(dout0_0) AT=1760.1n

* CHECK dout0_1 Vdout0_1ck87 = 0 time = 1760
.meas tran vdout0_1ck87 FIND v(dout0_1) AT=1760.1n

* CHECK dout0_2 Vdout0_2ck87 = 1.8 time = 1760
.meas tran vdout0_2ck87 FIND v(dout0_2) AT=1760.1n

* CHECK dout0_3 Vdout0_3ck87 = 1.8 time = 1760
.meas tran vdout0_3ck87 FIND v(dout0_3) AT=1760.1n

* CHECK dout0_4 Vdout0_4ck87 = 0 time = 1760
.meas tran vdout0_4ck87 FIND v(dout0_4) AT=1760.1n

* CHECK dout0_5 Vdout0_5ck87 = 1.8 time = 1760
.meas tran vdout0_5ck87 FIND v(dout0_5) AT=1760.1n

* CHECK dout0_6 Vdout0_6ck87 = 0 time = 1760
.meas tran vdout0_6ck87 FIND v(dout0_6) AT=1760.1n

* CHECK dout0_7 Vdout0_7ck87 = 1.8 time = 1760
.meas tran vdout0_7ck87 FIND v(dout0_7) AT=1760.1n

* CHECK dout0_8 Vdout0_8ck87 = 0 time = 1760
.meas tran vdout0_8ck87 FIND v(dout0_8) AT=1760.1n

* CHECK dout0_9 Vdout0_9ck87 = 0 time = 1760
.meas tran vdout0_9ck87 FIND v(dout0_9) AT=1760.1n

* CHECK dout0_10 Vdout0_10ck87 = 1.8 time = 1760
.meas tran vdout0_10ck87 FIND v(dout0_10) AT=1760.1n

* CHECK dout0_11 Vdout0_11ck87 = 1.8 time = 1760
.meas tran vdout0_11ck87 FIND v(dout0_11) AT=1760.1n

* CHECK dout0_12 Vdout0_12ck87 = 0 time = 1760
.meas tran vdout0_12ck87 FIND v(dout0_12) AT=1760.1n

* CHECK dout0_13 Vdout0_13ck87 = 1.8 time = 1760
.meas tran vdout0_13ck87 FIND v(dout0_13) AT=1760.1n

* CHECK dout0_14 Vdout0_14ck87 = 1.8 time = 1760
.meas tran vdout0_14ck87 FIND v(dout0_14) AT=1760.1n

* CHECK dout0_15 Vdout0_15ck87 = 0 time = 1760
.meas tran vdout0_15ck87 FIND v(dout0_15) AT=1760.1n

* CHECK dout0_0 Vdout0_0ck89 = 0 time = 1800
.meas tran vdout0_0ck89 FIND v(dout0_0) AT=1800.1n

* CHECK dout0_1 Vdout0_1ck89 = 0 time = 1800
.meas tran vdout0_1ck89 FIND v(dout0_1) AT=1800.1n

* CHECK dout0_2 Vdout0_2ck89 = 1.8 time = 1800
.meas tran vdout0_2ck89 FIND v(dout0_2) AT=1800.1n

* CHECK dout0_3 Vdout0_3ck89 = 1.8 time = 1800
.meas tran vdout0_3ck89 FIND v(dout0_3) AT=1800.1n

* CHECK dout0_4 Vdout0_4ck89 = 0 time = 1800
.meas tran vdout0_4ck89 FIND v(dout0_4) AT=1800.1n

* CHECK dout0_5 Vdout0_5ck89 = 1.8 time = 1800
.meas tran vdout0_5ck89 FIND v(dout0_5) AT=1800.1n

* CHECK dout0_6 Vdout0_6ck89 = 0 time = 1800
.meas tran vdout0_6ck89 FIND v(dout0_6) AT=1800.1n

* CHECK dout0_7 Vdout0_7ck89 = 1.8 time = 1800
.meas tran vdout0_7ck89 FIND v(dout0_7) AT=1800.1n

* CHECK dout0_8 Vdout0_8ck89 = 0 time = 1800
.meas tran vdout0_8ck89 FIND v(dout0_8) AT=1800.1n

* CHECK dout0_9 Vdout0_9ck89 = 0 time = 1800
.meas tran vdout0_9ck89 FIND v(dout0_9) AT=1800.1n

* CHECK dout0_10 Vdout0_10ck89 = 1.8 time = 1800
.meas tran vdout0_10ck89 FIND v(dout0_10) AT=1800.1n

* CHECK dout0_11 Vdout0_11ck89 = 1.8 time = 1800
.meas tran vdout0_11ck89 FIND v(dout0_11) AT=1800.1n

* CHECK dout0_12 Vdout0_12ck89 = 0 time = 1800
.meas tran vdout0_12ck89 FIND v(dout0_12) AT=1800.1n

* CHECK dout0_13 Vdout0_13ck89 = 1.8 time = 1800
.meas tran vdout0_13ck89 FIND v(dout0_13) AT=1800.1n

* CHECK dout0_14 Vdout0_14ck89 = 1.8 time = 1800
.meas tran vdout0_14ck89 FIND v(dout0_14) AT=1800.1n

* CHECK dout0_15 Vdout0_15ck89 = 0 time = 1800
.meas tran vdout0_15ck89 FIND v(dout0_15) AT=1800.1n

* CHECK dout0_0 Vdout0_0ck97 = 0 time = 1960
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=1960.1n

* CHECK dout0_1 Vdout0_1ck97 = 0 time = 1960
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=1960.1n

* CHECK dout0_2 Vdout0_2ck97 = 1.8 time = 1960
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=1960.1n

* CHECK dout0_3 Vdout0_3ck97 = 1.8 time = 1960
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=1960.1n

* CHECK dout0_4 Vdout0_4ck97 = 0 time = 1960
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=1960.1n

* CHECK dout0_5 Vdout0_5ck97 = 1.8 time = 1960
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=1960.1n

* CHECK dout0_6 Vdout0_6ck97 = 0 time = 1960
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=1960.1n

* CHECK dout0_7 Vdout0_7ck97 = 1.8 time = 1960
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=1960.1n

* CHECK dout0_8 Vdout0_8ck97 = 0 time = 1960
.meas tran vdout0_8ck97 FIND v(dout0_8) AT=1960.1n

* CHECK dout0_9 Vdout0_9ck97 = 0 time = 1960
.meas tran vdout0_9ck97 FIND v(dout0_9) AT=1960.1n

* CHECK dout0_10 Vdout0_10ck97 = 1.8 time = 1960
.meas tran vdout0_10ck97 FIND v(dout0_10) AT=1960.1n

* CHECK dout0_11 Vdout0_11ck97 = 1.8 time = 1960
.meas tran vdout0_11ck97 FIND v(dout0_11) AT=1960.1n

* CHECK dout0_12 Vdout0_12ck97 = 0 time = 1960
.meas tran vdout0_12ck97 FIND v(dout0_12) AT=1960.1n

* CHECK dout0_13 Vdout0_13ck97 = 1.8 time = 1960
.meas tran vdout0_13ck97 FIND v(dout0_13) AT=1960.1n

* CHECK dout0_14 Vdout0_14ck97 = 1.8 time = 1960
.meas tran vdout0_14ck97 FIND v(dout0_14) AT=1960.1n

* CHECK dout0_15 Vdout0_15ck97 = 0 time = 1960
.meas tran vdout0_15ck97 FIND v(dout0_15) AT=1960.1n

* CHECK dout0_0 Vdout0_0ck98 = 1.8 time = 1980
.meas tran vdout0_0ck98 FIND v(dout0_0) AT=1980.1n

* CHECK dout0_1 Vdout0_1ck98 = 1.8 time = 1980
.meas tran vdout0_1ck98 FIND v(dout0_1) AT=1980.1n

* CHECK dout0_2 Vdout0_2ck98 = 0 time = 1980
.meas tran vdout0_2ck98 FIND v(dout0_2) AT=1980.1n

* CHECK dout0_3 Vdout0_3ck98 = 0 time = 1980
.meas tran vdout0_3ck98 FIND v(dout0_3) AT=1980.1n

* CHECK dout0_4 Vdout0_4ck98 = 1.8 time = 1980
.meas tran vdout0_4ck98 FIND v(dout0_4) AT=1980.1n

* CHECK dout0_5 Vdout0_5ck98 = 1.8 time = 1980
.meas tran vdout0_5ck98 FIND v(dout0_5) AT=1980.1n

* CHECK dout0_6 Vdout0_6ck98 = 1.8 time = 1980
.meas tran vdout0_6ck98 FIND v(dout0_6) AT=1980.1n

* CHECK dout0_7 Vdout0_7ck98 = 0 time = 1980
.meas tran vdout0_7ck98 FIND v(dout0_7) AT=1980.1n

* CHECK dout0_8 Vdout0_8ck98 = 1.8 time = 1980
.meas tran vdout0_8ck98 FIND v(dout0_8) AT=1980.1n

* CHECK dout0_9 Vdout0_9ck98 = 1.8 time = 1980
.meas tran vdout0_9ck98 FIND v(dout0_9) AT=1980.1n

* CHECK dout0_10 Vdout0_10ck98 = 1.8 time = 1980
.meas tran vdout0_10ck98 FIND v(dout0_10) AT=1980.1n

* CHECK dout0_11 Vdout0_11ck98 = 1.8 time = 1980
.meas tran vdout0_11ck98 FIND v(dout0_11) AT=1980.1n

* CHECK dout0_12 Vdout0_12ck98 = 0 time = 1980
.meas tran vdout0_12ck98 FIND v(dout0_12) AT=1980.1n

* CHECK dout0_13 Vdout0_13ck98 = 1.8 time = 1980
.meas tran vdout0_13ck98 FIND v(dout0_13) AT=1980.1n

* CHECK dout0_14 Vdout0_14ck98 = 1.8 time = 1980
.meas tran vdout0_14ck98 FIND v(dout0_14) AT=1980.1n

* CHECK dout0_15 Vdout0_15ck98 = 0 time = 1980
.meas tran vdout0_15ck98 FIND v(dout0_15) AT=1980.1n

* CHECK dout0_0 Vdout0_0ck101 = 0 time = 2040
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=2040.1n

* CHECK dout0_1 Vdout0_1ck101 = 1.8 time = 2040
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=2040.1n

* CHECK dout0_2 Vdout0_2ck101 = 0 time = 2040
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=2040.1n

* CHECK dout0_3 Vdout0_3ck101 = 1.8 time = 2040
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=2040.1n

* CHECK dout0_4 Vdout0_4ck101 = 1.8 time = 2040
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=2040.1n

* CHECK dout0_5 Vdout0_5ck101 = 0 time = 2040
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=2040.1n

* CHECK dout0_6 Vdout0_6ck101 = 1.8 time = 2040
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=2040.1n

* CHECK dout0_7 Vdout0_7ck101 = 1.8 time = 2040
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=2040.1n

* CHECK dout0_8 Vdout0_8ck101 = 1.8 time = 2040
.meas tran vdout0_8ck101 FIND v(dout0_8) AT=2040.1n

* CHECK dout0_9 Vdout0_9ck101 = 0 time = 2040
.meas tran vdout0_9ck101 FIND v(dout0_9) AT=2040.1n

* CHECK dout0_10 Vdout0_10ck101 = 0 time = 2040
.meas tran vdout0_10ck101 FIND v(dout0_10) AT=2040.1n

* CHECK dout0_11 Vdout0_11ck101 = 0 time = 2040
.meas tran vdout0_11ck101 FIND v(dout0_11) AT=2040.1n

* CHECK dout0_12 Vdout0_12ck101 = 0 time = 2040
.meas tran vdout0_12ck101 FIND v(dout0_12) AT=2040.1n

* CHECK dout0_13 Vdout0_13ck101 = 1.8 time = 2040
.meas tran vdout0_13ck101 FIND v(dout0_13) AT=2040.1n

* CHECK dout0_14 Vdout0_14ck101 = 1.8 time = 2040
.meas tran vdout0_14ck101 FIND v(dout0_14) AT=2040.1n

* CHECK dout0_15 Vdout0_15ck101 = 1.8 time = 2040
.meas tran vdout0_15ck101 FIND v(dout0_15) AT=2040.1n

* CHECK dout0_0 Vdout0_0ck102 = 0 time = 2060
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=2060.1n

* CHECK dout0_1 Vdout0_1ck102 = 0 time = 2060
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=2060.1n

* CHECK dout0_2 Vdout0_2ck102 = 0 time = 2060
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=2060.1n

* CHECK dout0_3 Vdout0_3ck102 = 1.8 time = 2060
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=2060.1n

* CHECK dout0_4 Vdout0_4ck102 = 0 time = 2060
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=2060.1n

* CHECK dout0_5 Vdout0_5ck102 = 0 time = 2060
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=2060.1n

* CHECK dout0_6 Vdout0_6ck102 = 0 time = 2060
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=2060.1n

* CHECK dout0_7 Vdout0_7ck102 = 0 time = 2060
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=2060.1n

* CHECK dout0_8 Vdout0_8ck102 = 1.8 time = 2060
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=2060.1n

* CHECK dout0_9 Vdout0_9ck102 = 1.8 time = 2060
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=2060.1n

* CHECK dout0_10 Vdout0_10ck102 = 1.8 time = 2060
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=2060.1n

* CHECK dout0_11 Vdout0_11ck102 = 0 time = 2060
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=2060.1n

* CHECK dout0_12 Vdout0_12ck102 = 1.8 time = 2060
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=2060.1n

* CHECK dout0_13 Vdout0_13ck102 = 0 time = 2060
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=2060.1n

* CHECK dout0_14 Vdout0_14ck102 = 1.8 time = 2060
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=2060.1n

* CHECK dout0_15 Vdout0_15ck102 = 0 time = 2060
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=2060.1n

* CHECK dout0_0 Vdout0_0ck104 = 0 time = 2100
.meas tran vdout0_0ck104 FIND v(dout0_0) AT=2100.1n

* CHECK dout0_1 Vdout0_1ck104 = 0 time = 2100
.meas tran vdout0_1ck104 FIND v(dout0_1) AT=2100.1n

* CHECK dout0_2 Vdout0_2ck104 = 0 time = 2100
.meas tran vdout0_2ck104 FIND v(dout0_2) AT=2100.1n

* CHECK dout0_3 Vdout0_3ck104 = 1.8 time = 2100
.meas tran vdout0_3ck104 FIND v(dout0_3) AT=2100.1n

* CHECK dout0_4 Vdout0_4ck104 = 0 time = 2100
.meas tran vdout0_4ck104 FIND v(dout0_4) AT=2100.1n

* CHECK dout0_5 Vdout0_5ck104 = 1.8 time = 2100
.meas tran vdout0_5ck104 FIND v(dout0_5) AT=2100.1n

* CHECK dout0_6 Vdout0_6ck104 = 1.8 time = 2100
.meas tran vdout0_6ck104 FIND v(dout0_6) AT=2100.1n

* CHECK dout0_7 Vdout0_7ck104 = 1.8 time = 2100
.meas tran vdout0_7ck104 FIND v(dout0_7) AT=2100.1n

* CHECK dout0_8 Vdout0_8ck104 = 1.8 time = 2100
.meas tran vdout0_8ck104 FIND v(dout0_8) AT=2100.1n

* CHECK dout0_9 Vdout0_9ck104 = 0 time = 2100
.meas tran vdout0_9ck104 FIND v(dout0_9) AT=2100.1n

* CHECK dout0_10 Vdout0_10ck104 = 0 time = 2100
.meas tran vdout0_10ck104 FIND v(dout0_10) AT=2100.1n

* CHECK dout0_11 Vdout0_11ck104 = 0 time = 2100
.meas tran vdout0_11ck104 FIND v(dout0_11) AT=2100.1n

* CHECK dout0_12 Vdout0_12ck104 = 0 time = 2100
.meas tran vdout0_12ck104 FIND v(dout0_12) AT=2100.1n

* CHECK dout0_13 Vdout0_13ck104 = 1.8 time = 2100
.meas tran vdout0_13ck104 FIND v(dout0_13) AT=2100.1n

* CHECK dout0_14 Vdout0_14ck104 = 1.8 time = 2100
.meas tran vdout0_14ck104 FIND v(dout0_14) AT=2100.1n

* CHECK dout0_15 Vdout0_15ck104 = 1.8 time = 2100
.meas tran vdout0_15ck104 FIND v(dout0_15) AT=2100.1n

* CHECK dout0_0 Vdout0_0ck105 = 0 time = 2120
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=2120.1n

* CHECK dout0_1 Vdout0_1ck105 = 0 time = 2120
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=2120.1n

* CHECK dout0_2 Vdout0_2ck105 = 1.8 time = 2120
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=2120.1n

* CHECK dout0_3 Vdout0_3ck105 = 0 time = 2120
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=2120.1n

* CHECK dout0_4 Vdout0_4ck105 = 1.8 time = 2120
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=2120.1n

* CHECK dout0_5 Vdout0_5ck105 = 0 time = 2120
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=2120.1n

* CHECK dout0_6 Vdout0_6ck105 = 1.8 time = 2120
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=2120.1n

* CHECK dout0_7 Vdout0_7ck105 = 1.8 time = 2120
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=2120.1n

* CHECK dout0_8 Vdout0_8ck105 = 1.8 time = 2120
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=2120.1n

* CHECK dout0_9 Vdout0_9ck105 = 1.8 time = 2120
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=2120.1n

* CHECK dout0_10 Vdout0_10ck105 = 0 time = 2120
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=2120.1n

* CHECK dout0_11 Vdout0_11ck105 = 0 time = 2120
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=2120.1n

* CHECK dout0_12 Vdout0_12ck105 = 1.8 time = 2120
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=2120.1n

* CHECK dout0_13 Vdout0_13ck105 = 1.8 time = 2120
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=2120.1n

* CHECK dout0_14 Vdout0_14ck105 = 0 time = 2120
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=2120.1n

* CHECK dout0_15 Vdout0_15ck105 = 1.8 time = 2120
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=2120.1n

* CHECK dout0_0 Vdout0_0ck106 = 0 time = 2140
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=2140.1n

* CHECK dout0_1 Vdout0_1ck106 = 0 time = 2140
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=2140.1n

* CHECK dout0_2 Vdout0_2ck106 = 1.8 time = 2140
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=2140.1n

* CHECK dout0_3 Vdout0_3ck106 = 1.8 time = 2140
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=2140.1n

* CHECK dout0_4 Vdout0_4ck106 = 0 time = 2140
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=2140.1n

* CHECK dout0_5 Vdout0_5ck106 = 1.8 time = 2140
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=2140.1n

* CHECK dout0_6 Vdout0_6ck106 = 0 time = 2140
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=2140.1n

* CHECK dout0_7 Vdout0_7ck106 = 1.8 time = 2140
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=2140.1n

* CHECK dout0_8 Vdout0_8ck106 = 0 time = 2140
.meas tran vdout0_8ck106 FIND v(dout0_8) AT=2140.1n

* CHECK dout0_9 Vdout0_9ck106 = 0 time = 2140
.meas tran vdout0_9ck106 FIND v(dout0_9) AT=2140.1n

* CHECK dout0_10 Vdout0_10ck106 = 1.8 time = 2140
.meas tran vdout0_10ck106 FIND v(dout0_10) AT=2140.1n

* CHECK dout0_11 Vdout0_11ck106 = 1.8 time = 2140
.meas tran vdout0_11ck106 FIND v(dout0_11) AT=2140.1n

* CHECK dout0_12 Vdout0_12ck106 = 0 time = 2140
.meas tran vdout0_12ck106 FIND v(dout0_12) AT=2140.1n

* CHECK dout0_13 Vdout0_13ck106 = 1.8 time = 2140
.meas tran vdout0_13ck106 FIND v(dout0_13) AT=2140.1n

* CHECK dout0_14 Vdout0_14ck106 = 1.8 time = 2140
.meas tran vdout0_14ck106 FIND v(dout0_14) AT=2140.1n

* CHECK dout0_15 Vdout0_15ck106 = 0 time = 2140
.meas tran vdout0_15ck106 FIND v(dout0_15) AT=2140.1n

* CHECK dout0_0 Vdout0_0ck110 = 0 time = 2220
.meas tran vdout0_0ck110 FIND v(dout0_0) AT=2220.1n

* CHECK dout0_1 Vdout0_1ck110 = 0 time = 2220
.meas tran vdout0_1ck110 FIND v(dout0_1) AT=2220.1n

* CHECK dout0_2 Vdout0_2ck110 = 1.8 time = 2220
.meas tran vdout0_2ck110 FIND v(dout0_2) AT=2220.1n

* CHECK dout0_3 Vdout0_3ck110 = 1.8 time = 2220
.meas tran vdout0_3ck110 FIND v(dout0_3) AT=2220.1n

* CHECK dout0_4 Vdout0_4ck110 = 0 time = 2220
.meas tran vdout0_4ck110 FIND v(dout0_4) AT=2220.1n

* CHECK dout0_5 Vdout0_5ck110 = 1.8 time = 2220
.meas tran vdout0_5ck110 FIND v(dout0_5) AT=2220.1n

* CHECK dout0_6 Vdout0_6ck110 = 0 time = 2220
.meas tran vdout0_6ck110 FIND v(dout0_6) AT=2220.1n

* CHECK dout0_7 Vdout0_7ck110 = 1.8 time = 2220
.meas tran vdout0_7ck110 FIND v(dout0_7) AT=2220.1n

* CHECK dout0_8 Vdout0_8ck110 = 0 time = 2220
.meas tran vdout0_8ck110 FIND v(dout0_8) AT=2220.1n

* CHECK dout0_9 Vdout0_9ck110 = 0 time = 2220
.meas tran vdout0_9ck110 FIND v(dout0_9) AT=2220.1n

* CHECK dout0_10 Vdout0_10ck110 = 1.8 time = 2220
.meas tran vdout0_10ck110 FIND v(dout0_10) AT=2220.1n

* CHECK dout0_11 Vdout0_11ck110 = 1.8 time = 2220
.meas tran vdout0_11ck110 FIND v(dout0_11) AT=2220.1n

* CHECK dout0_12 Vdout0_12ck110 = 0 time = 2220
.meas tran vdout0_12ck110 FIND v(dout0_12) AT=2220.1n

* CHECK dout0_13 Vdout0_13ck110 = 1.8 time = 2220
.meas tran vdout0_13ck110 FIND v(dout0_13) AT=2220.1n

* CHECK dout0_14 Vdout0_14ck110 = 1.8 time = 2220
.meas tran vdout0_14ck110 FIND v(dout0_14) AT=2220.1n

* CHECK dout0_15 Vdout0_15ck110 = 0 time = 2220
.meas tran vdout0_15ck110 FIND v(dout0_15) AT=2220.1n

* CHECK dout0_0 Vdout0_0ck111 = 1.8 time = 2240
.meas tran vdout0_0ck111 FIND v(dout0_0) AT=2240.1n

* CHECK dout0_1 Vdout0_1ck111 = 1.8 time = 2240
.meas tran vdout0_1ck111 FIND v(dout0_1) AT=2240.1n

* CHECK dout0_2 Vdout0_2ck111 = 0 time = 2240
.meas tran vdout0_2ck111 FIND v(dout0_2) AT=2240.1n

* CHECK dout0_3 Vdout0_3ck111 = 1.8 time = 2240
.meas tran vdout0_3ck111 FIND v(dout0_3) AT=2240.1n

* CHECK dout0_4 Vdout0_4ck111 = 0 time = 2240
.meas tran vdout0_4ck111 FIND v(dout0_4) AT=2240.1n

* CHECK dout0_5 Vdout0_5ck111 = 1.8 time = 2240
.meas tran vdout0_5ck111 FIND v(dout0_5) AT=2240.1n

* CHECK dout0_6 Vdout0_6ck111 = 0 time = 2240
.meas tran vdout0_6ck111 FIND v(dout0_6) AT=2240.1n

* CHECK dout0_7 Vdout0_7ck111 = 0 time = 2240
.meas tran vdout0_7ck111 FIND v(dout0_7) AT=2240.1n

* CHECK dout0_8 Vdout0_8ck111 = 0 time = 2240
.meas tran vdout0_8ck111 FIND v(dout0_8) AT=2240.1n

* CHECK dout0_9 Vdout0_9ck111 = 0 time = 2240
.meas tran vdout0_9ck111 FIND v(dout0_9) AT=2240.1n

* CHECK dout0_10 Vdout0_10ck111 = 1.8 time = 2240
.meas tran vdout0_10ck111 FIND v(dout0_10) AT=2240.1n

* CHECK dout0_11 Vdout0_11ck111 = 1.8 time = 2240
.meas tran vdout0_11ck111 FIND v(dout0_11) AT=2240.1n

* CHECK dout0_12 Vdout0_12ck111 = 0 time = 2240
.meas tran vdout0_12ck111 FIND v(dout0_12) AT=2240.1n

* CHECK dout0_13 Vdout0_13ck111 = 1.8 time = 2240
.meas tran vdout0_13ck111 FIND v(dout0_13) AT=2240.1n

* CHECK dout0_14 Vdout0_14ck111 = 0 time = 2240
.meas tran vdout0_14ck111 FIND v(dout0_14) AT=2240.1n

* CHECK dout0_15 Vdout0_15ck111 = 0 time = 2240
.meas tran vdout0_15ck111 FIND v(dout0_15) AT=2240.1n

* CHECK dout0_0 Vdout0_0ck114 = 1.8 time = 2300
.meas tran vdout0_0ck114 FIND v(dout0_0) AT=2300.1n

* CHECK dout0_1 Vdout0_1ck114 = 1.8 time = 2300
.meas tran vdout0_1ck114 FIND v(dout0_1) AT=2300.1n

* CHECK dout0_2 Vdout0_2ck114 = 1.8 time = 2300
.meas tran vdout0_2ck114 FIND v(dout0_2) AT=2300.1n

* CHECK dout0_3 Vdout0_3ck114 = 0 time = 2300
.meas tran vdout0_3ck114 FIND v(dout0_3) AT=2300.1n

* CHECK dout0_4 Vdout0_4ck114 = 0 time = 2300
.meas tran vdout0_4ck114 FIND v(dout0_4) AT=2300.1n

* CHECK dout0_5 Vdout0_5ck114 = 0 time = 2300
.meas tran vdout0_5ck114 FIND v(dout0_5) AT=2300.1n

* CHECK dout0_6 Vdout0_6ck114 = 1.8 time = 2300
.meas tran vdout0_6ck114 FIND v(dout0_6) AT=2300.1n

* CHECK dout0_7 Vdout0_7ck114 = 1.8 time = 2300
.meas tran vdout0_7ck114 FIND v(dout0_7) AT=2300.1n

* CHECK dout0_8 Vdout0_8ck114 = 1.8 time = 2300
.meas tran vdout0_8ck114 FIND v(dout0_8) AT=2300.1n

* CHECK dout0_9 Vdout0_9ck114 = 0 time = 2300
.meas tran vdout0_9ck114 FIND v(dout0_9) AT=2300.1n

* CHECK dout0_10 Vdout0_10ck114 = 0 time = 2300
.meas tran vdout0_10ck114 FIND v(dout0_10) AT=2300.1n

* CHECK dout0_11 Vdout0_11ck114 = 1.8 time = 2300
.meas tran vdout0_11ck114 FIND v(dout0_11) AT=2300.1n

* CHECK dout0_12 Vdout0_12ck114 = 1.8 time = 2300
.meas tran vdout0_12ck114 FIND v(dout0_12) AT=2300.1n

* CHECK dout0_13 Vdout0_13ck114 = 1.8 time = 2300
.meas tran vdout0_13ck114 FIND v(dout0_13) AT=2300.1n

* CHECK dout0_14 Vdout0_14ck114 = 1.8 time = 2300
.meas tran vdout0_14ck114 FIND v(dout0_14) AT=2300.1n

* CHECK dout0_15 Vdout0_15ck114 = 0 time = 2300
.meas tran vdout0_15ck114 FIND v(dout0_15) AT=2300.1n

* CHECK dout0_0 Vdout0_0ck116 = 1.8 time = 2340
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=2340.1n

* CHECK dout0_1 Vdout0_1ck116 = 0 time = 2340
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=2340.1n

* CHECK dout0_2 Vdout0_2ck116 = 1.8 time = 2340
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=2340.1n

* CHECK dout0_3 Vdout0_3ck116 = 1.8 time = 2340
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=2340.1n

* CHECK dout0_4 Vdout0_4ck116 = 1.8 time = 2340
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=2340.1n

* CHECK dout0_5 Vdout0_5ck116 = 0 time = 2340
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=2340.1n

* CHECK dout0_6 Vdout0_6ck116 = 0 time = 2340
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=2340.1n

* CHECK dout0_7 Vdout0_7ck116 = 0 time = 2340
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=2340.1n

* CHECK dout0_8 Vdout0_8ck116 = 0 time = 2340
.meas tran vdout0_8ck116 FIND v(dout0_8) AT=2340.1n

* CHECK dout0_9 Vdout0_9ck116 = 1.8 time = 2340
.meas tran vdout0_9ck116 FIND v(dout0_9) AT=2340.1n

* CHECK dout0_10 Vdout0_10ck116 = 0 time = 2340
.meas tran vdout0_10ck116 FIND v(dout0_10) AT=2340.1n

* CHECK dout0_11 Vdout0_11ck116 = 1.8 time = 2340
.meas tran vdout0_11ck116 FIND v(dout0_11) AT=2340.1n

* CHECK dout0_12 Vdout0_12ck116 = 0 time = 2340
.meas tran vdout0_12ck116 FIND v(dout0_12) AT=2340.1n

* CHECK dout0_13 Vdout0_13ck116 = 0 time = 2340
.meas tran vdout0_13ck116 FIND v(dout0_13) AT=2340.1n

* CHECK dout0_14 Vdout0_14ck116 = 1.8 time = 2340
.meas tran vdout0_14ck116 FIND v(dout0_14) AT=2340.1n

* CHECK dout0_15 Vdout0_15ck116 = 0 time = 2340
.meas tran vdout0_15ck116 FIND v(dout0_15) AT=2340.1n

* CHECK dout0_0 Vdout0_0ck117 = 1.8 time = 2360
.meas tran vdout0_0ck117 FIND v(dout0_0) AT=2360.1n

* CHECK dout0_1 Vdout0_1ck117 = 1.8 time = 2360
.meas tran vdout0_1ck117 FIND v(dout0_1) AT=2360.1n

* CHECK dout0_2 Vdout0_2ck117 = 0 time = 2360
.meas tran vdout0_2ck117 FIND v(dout0_2) AT=2360.1n

* CHECK dout0_3 Vdout0_3ck117 = 1.8 time = 2360
.meas tran vdout0_3ck117 FIND v(dout0_3) AT=2360.1n

* CHECK dout0_4 Vdout0_4ck117 = 0 time = 2360
.meas tran vdout0_4ck117 FIND v(dout0_4) AT=2360.1n

* CHECK dout0_5 Vdout0_5ck117 = 1.8 time = 2360
.meas tran vdout0_5ck117 FIND v(dout0_5) AT=2360.1n

* CHECK dout0_6 Vdout0_6ck117 = 0 time = 2360
.meas tran vdout0_6ck117 FIND v(dout0_6) AT=2360.1n

* CHECK dout0_7 Vdout0_7ck117 = 0 time = 2360
.meas tran vdout0_7ck117 FIND v(dout0_7) AT=2360.1n

* CHECK dout0_8 Vdout0_8ck117 = 0 time = 2360
.meas tran vdout0_8ck117 FIND v(dout0_8) AT=2360.1n

* CHECK dout0_9 Vdout0_9ck117 = 0 time = 2360
.meas tran vdout0_9ck117 FIND v(dout0_9) AT=2360.1n

* CHECK dout0_10 Vdout0_10ck117 = 1.8 time = 2360
.meas tran vdout0_10ck117 FIND v(dout0_10) AT=2360.1n

* CHECK dout0_11 Vdout0_11ck117 = 1.8 time = 2360
.meas tran vdout0_11ck117 FIND v(dout0_11) AT=2360.1n

* CHECK dout0_12 Vdout0_12ck117 = 0 time = 2360
.meas tran vdout0_12ck117 FIND v(dout0_12) AT=2360.1n

* CHECK dout0_13 Vdout0_13ck117 = 1.8 time = 2360
.meas tran vdout0_13ck117 FIND v(dout0_13) AT=2360.1n

* CHECK dout0_14 Vdout0_14ck117 = 0 time = 2360
.meas tran vdout0_14ck117 FIND v(dout0_14) AT=2360.1n

* CHECK dout0_15 Vdout0_15ck117 = 0 time = 2360
.meas tran vdout0_15ck117 FIND v(dout0_15) AT=2360.1n

* CHECK dout0_0 Vdout0_0ck119 = 1.8 time = 2400
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=2400.1n

* CHECK dout0_1 Vdout0_1ck119 = 0 time = 2400
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=2400.1n

* CHECK dout0_2 Vdout0_2ck119 = 1.8 time = 2400
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=2400.1n

* CHECK dout0_3 Vdout0_3ck119 = 1.8 time = 2400
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=2400.1n

* CHECK dout0_4 Vdout0_4ck119 = 1.8 time = 2400
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=2400.1n

* CHECK dout0_5 Vdout0_5ck119 = 0 time = 2400
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=2400.1n

* CHECK dout0_6 Vdout0_6ck119 = 0 time = 2400
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=2400.1n

* CHECK dout0_7 Vdout0_7ck119 = 0 time = 2400
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=2400.1n

* CHECK dout0_8 Vdout0_8ck119 = 0 time = 2400
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=2400.1n

* CHECK dout0_9 Vdout0_9ck119 = 1.8 time = 2400
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=2400.1n

* CHECK dout0_10 Vdout0_10ck119 = 0 time = 2400
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=2400.1n

* CHECK dout0_11 Vdout0_11ck119 = 1.8 time = 2400
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=2400.1n

* CHECK dout0_12 Vdout0_12ck119 = 0 time = 2400
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=2400.1n

* CHECK dout0_13 Vdout0_13ck119 = 0 time = 2400
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=2400.1n

* CHECK dout0_14 Vdout0_14ck119 = 1.8 time = 2400
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=2400.1n

* CHECK dout0_15 Vdout0_15ck119 = 0 time = 2400
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=2400.1n

* CHECK dout0_0 Vdout0_0ck120 = 0 time = 2420
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=2420.1n

* CHECK dout0_1 Vdout0_1ck120 = 0 time = 2420
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=2420.1n

* CHECK dout0_2 Vdout0_2ck120 = 1.8 time = 2420
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=2420.1n

* CHECK dout0_3 Vdout0_3ck120 = 0 time = 2420
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=2420.1n

* CHECK dout0_4 Vdout0_4ck120 = 1.8 time = 2420
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=2420.1n

* CHECK dout0_5 Vdout0_5ck120 = 0 time = 2420
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=2420.1n

* CHECK dout0_6 Vdout0_6ck120 = 1.8 time = 2420
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=2420.1n

* CHECK dout0_7 Vdout0_7ck120 = 1.8 time = 2420
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=2420.1n

* CHECK dout0_8 Vdout0_8ck120 = 1.8 time = 2420
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=2420.1n

* CHECK dout0_9 Vdout0_9ck120 = 1.8 time = 2420
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=2420.1n

* CHECK dout0_10 Vdout0_10ck120 = 0 time = 2420
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=2420.1n

* CHECK dout0_11 Vdout0_11ck120 = 0 time = 2420
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=2420.1n

* CHECK dout0_12 Vdout0_12ck120 = 1.8 time = 2420
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=2420.1n

* CHECK dout0_13 Vdout0_13ck120 = 1.8 time = 2420
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=2420.1n

* CHECK dout0_14 Vdout0_14ck120 = 0 time = 2420
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=2420.1n

* CHECK dout0_15 Vdout0_15ck120 = 1.8 time = 2420
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=2420.1n

* CHECK dout0_0 Vdout0_0ck121 = 1.8 time = 2440
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=2440.1n

* CHECK dout0_1 Vdout0_1ck121 = 1.8 time = 2440
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=2440.1n

* CHECK dout0_2 Vdout0_2ck121 = 1.8 time = 2440
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=2440.1n

* CHECK dout0_3 Vdout0_3ck121 = 1.8 time = 2440
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=2440.1n

* CHECK dout0_4 Vdout0_4ck121 = 0 time = 2440
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=2440.1n

* CHECK dout0_5 Vdout0_5ck121 = 0 time = 2440
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=2440.1n

* CHECK dout0_6 Vdout0_6ck121 = 1.8 time = 2440
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=2440.1n

* CHECK dout0_7 Vdout0_7ck121 = 0 time = 2440
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=2440.1n

* CHECK dout0_8 Vdout0_8ck121 = 0 time = 2440
.meas tran vdout0_8ck121 FIND v(dout0_8) AT=2440.1n

* CHECK dout0_9 Vdout0_9ck121 = 0 time = 2440
.meas tran vdout0_9ck121 FIND v(dout0_9) AT=2440.1n

* CHECK dout0_10 Vdout0_10ck121 = 1.8 time = 2440
.meas tran vdout0_10ck121 FIND v(dout0_10) AT=2440.1n

* CHECK dout0_11 Vdout0_11ck121 = 0 time = 2440
.meas tran vdout0_11ck121 FIND v(dout0_11) AT=2440.1n

* CHECK dout0_12 Vdout0_12ck121 = 0 time = 2440
.meas tran vdout0_12ck121 FIND v(dout0_12) AT=2440.1n

* CHECK dout0_13 Vdout0_13ck121 = 1.8 time = 2440
.meas tran vdout0_13ck121 FIND v(dout0_13) AT=2440.1n

* CHECK dout0_14 Vdout0_14ck121 = 1.8 time = 2440
.meas tran vdout0_14ck121 FIND v(dout0_14) AT=2440.1n

* CHECK dout0_15 Vdout0_15ck121 = 1.8 time = 2440
.meas tran vdout0_15ck121 FIND v(dout0_15) AT=2440.1n

* CHECK dout0_0 Vdout0_0ck122 = 0 time = 2460
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=2460.1n

* CHECK dout0_1 Vdout0_1ck122 = 0 time = 2460
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=2460.1n

* CHECK dout0_2 Vdout0_2ck122 = 1.8 time = 2460
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=2460.1n

* CHECK dout0_3 Vdout0_3ck122 = 0 time = 2460
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=2460.1n

* CHECK dout0_4 Vdout0_4ck122 = 1.8 time = 2460
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=2460.1n

* CHECK dout0_5 Vdout0_5ck122 = 0 time = 2460
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=2460.1n

* CHECK dout0_6 Vdout0_6ck122 = 1.8 time = 2460
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=2460.1n

* CHECK dout0_7 Vdout0_7ck122 = 1.8 time = 2460
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=2460.1n

* CHECK dout0_8 Vdout0_8ck122 = 1.8 time = 2460
.meas tran vdout0_8ck122 FIND v(dout0_8) AT=2460.1n

* CHECK dout0_9 Vdout0_9ck122 = 1.8 time = 2460
.meas tran vdout0_9ck122 FIND v(dout0_9) AT=2460.1n

* CHECK dout0_10 Vdout0_10ck122 = 0 time = 2460
.meas tran vdout0_10ck122 FIND v(dout0_10) AT=2460.1n

* CHECK dout0_11 Vdout0_11ck122 = 0 time = 2460
.meas tran vdout0_11ck122 FIND v(dout0_11) AT=2460.1n

* CHECK dout0_12 Vdout0_12ck122 = 1.8 time = 2460
.meas tran vdout0_12ck122 FIND v(dout0_12) AT=2460.1n

* CHECK dout0_13 Vdout0_13ck122 = 1.8 time = 2460
.meas tran vdout0_13ck122 FIND v(dout0_13) AT=2460.1n

* CHECK dout0_14 Vdout0_14ck122 = 0 time = 2460
.meas tran vdout0_14ck122 FIND v(dout0_14) AT=2460.1n

* CHECK dout0_15 Vdout0_15ck122 = 1.8 time = 2460
.meas tran vdout0_15ck122 FIND v(dout0_15) AT=2460.1n

* CHECK dout0_0 Vdout0_0ck124 = 0 time = 2500
.meas tran vdout0_0ck124 FIND v(dout0_0) AT=2500.1n

* CHECK dout0_1 Vdout0_1ck124 = 0 time = 2500
.meas tran vdout0_1ck124 FIND v(dout0_1) AT=2500.1n

* CHECK dout0_2 Vdout0_2ck124 = 0 time = 2500
.meas tran vdout0_2ck124 FIND v(dout0_2) AT=2500.1n

* CHECK dout0_3 Vdout0_3ck124 = 1.8 time = 2500
.meas tran vdout0_3ck124 FIND v(dout0_3) AT=2500.1n

* CHECK dout0_4 Vdout0_4ck124 = 0 time = 2500
.meas tran vdout0_4ck124 FIND v(dout0_4) AT=2500.1n

* CHECK dout0_5 Vdout0_5ck124 = 1.8 time = 2500
.meas tran vdout0_5ck124 FIND v(dout0_5) AT=2500.1n

* CHECK dout0_6 Vdout0_6ck124 = 1.8 time = 2500
.meas tran vdout0_6ck124 FIND v(dout0_6) AT=2500.1n

* CHECK dout0_7 Vdout0_7ck124 = 1.8 time = 2500
.meas tran vdout0_7ck124 FIND v(dout0_7) AT=2500.1n

* CHECK dout0_8 Vdout0_8ck124 = 1.8 time = 2500
.meas tran vdout0_8ck124 FIND v(dout0_8) AT=2500.1n

* CHECK dout0_9 Vdout0_9ck124 = 0 time = 2500
.meas tran vdout0_9ck124 FIND v(dout0_9) AT=2500.1n

* CHECK dout0_10 Vdout0_10ck124 = 0 time = 2500
.meas tran vdout0_10ck124 FIND v(dout0_10) AT=2500.1n

* CHECK dout0_11 Vdout0_11ck124 = 0 time = 2500
.meas tran vdout0_11ck124 FIND v(dout0_11) AT=2500.1n

* CHECK dout0_12 Vdout0_12ck124 = 0 time = 2500
.meas tran vdout0_12ck124 FIND v(dout0_12) AT=2500.1n

* CHECK dout0_13 Vdout0_13ck124 = 1.8 time = 2500
.meas tran vdout0_13ck124 FIND v(dout0_13) AT=2500.1n

* CHECK dout0_14 Vdout0_14ck124 = 1.8 time = 2500
.meas tran vdout0_14ck124 FIND v(dout0_14) AT=2500.1n

* CHECK dout0_15 Vdout0_15ck124 = 1.8 time = 2500
.meas tran vdout0_15ck124 FIND v(dout0_15) AT=2500.1n

* CHECK dout0_0 Vdout0_0ck125 = 1.8 time = 2520
.meas tran vdout0_0ck125 FIND v(dout0_0) AT=2520.1n

* CHECK dout0_1 Vdout0_1ck125 = 1.8 time = 2520
.meas tran vdout0_1ck125 FIND v(dout0_1) AT=2520.1n

* CHECK dout0_2 Vdout0_2ck125 = 1.8 time = 2520
.meas tran vdout0_2ck125 FIND v(dout0_2) AT=2520.1n

* CHECK dout0_3 Vdout0_3ck125 = 1.8 time = 2520
.meas tran vdout0_3ck125 FIND v(dout0_3) AT=2520.1n

* CHECK dout0_4 Vdout0_4ck125 = 0 time = 2520
.meas tran vdout0_4ck125 FIND v(dout0_4) AT=2520.1n

* CHECK dout0_5 Vdout0_5ck125 = 0 time = 2520
.meas tran vdout0_5ck125 FIND v(dout0_5) AT=2520.1n

* CHECK dout0_6 Vdout0_6ck125 = 1.8 time = 2520
.meas tran vdout0_6ck125 FIND v(dout0_6) AT=2520.1n

* CHECK dout0_7 Vdout0_7ck125 = 0 time = 2520
.meas tran vdout0_7ck125 FIND v(dout0_7) AT=2520.1n

* CHECK dout0_8 Vdout0_8ck125 = 0 time = 2520
.meas tran vdout0_8ck125 FIND v(dout0_8) AT=2520.1n

* CHECK dout0_9 Vdout0_9ck125 = 0 time = 2520
.meas tran vdout0_9ck125 FIND v(dout0_9) AT=2520.1n

* CHECK dout0_10 Vdout0_10ck125 = 1.8 time = 2520
.meas tran vdout0_10ck125 FIND v(dout0_10) AT=2520.1n

* CHECK dout0_11 Vdout0_11ck125 = 0 time = 2520
.meas tran vdout0_11ck125 FIND v(dout0_11) AT=2520.1n

* CHECK dout0_12 Vdout0_12ck125 = 0 time = 2520
.meas tran vdout0_12ck125 FIND v(dout0_12) AT=2520.1n

* CHECK dout0_13 Vdout0_13ck125 = 1.8 time = 2520
.meas tran vdout0_13ck125 FIND v(dout0_13) AT=2520.1n

* CHECK dout0_14 Vdout0_14ck125 = 1.8 time = 2520
.meas tran vdout0_14ck125 FIND v(dout0_14) AT=2520.1n

* CHECK dout0_15 Vdout0_15ck125 = 1.8 time = 2520
.meas tran vdout0_15ck125 FIND v(dout0_15) AT=2520.1n

* CHECK dout0_0 Vdout0_0ck126 = 0 time = 2540
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=2540.1n

* CHECK dout0_1 Vdout0_1ck126 = 0 time = 2540
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=2540.1n

* CHECK dout0_2 Vdout0_2ck126 = 0 time = 2540
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=2540.1n

* CHECK dout0_3 Vdout0_3ck126 = 1.8 time = 2540
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=2540.1n

* CHECK dout0_4 Vdout0_4ck126 = 0 time = 2540
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=2540.1n

* CHECK dout0_5 Vdout0_5ck126 = 0 time = 2540
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=2540.1n

* CHECK dout0_6 Vdout0_6ck126 = 0 time = 2540
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=2540.1n

* CHECK dout0_7 Vdout0_7ck126 = 0 time = 2540
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=2540.1n

* CHECK dout0_8 Vdout0_8ck126 = 1.8 time = 2540
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=2540.1n

* CHECK dout0_9 Vdout0_9ck126 = 1.8 time = 2540
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=2540.1n

* CHECK dout0_10 Vdout0_10ck126 = 1.8 time = 2540
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=2540.1n

* CHECK dout0_11 Vdout0_11ck126 = 0 time = 2540
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=2540.1n

* CHECK dout0_12 Vdout0_12ck126 = 1.8 time = 2540
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=2540.1n

* CHECK dout0_13 Vdout0_13ck126 = 0 time = 2540
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=2540.1n

* CHECK dout0_14 Vdout0_14ck126 = 1.8 time = 2540
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=2540.1n

* CHECK dout0_15 Vdout0_15ck126 = 0 time = 2540
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=2540.1n

* CHECK dout0_0 Vdout0_0ck128 = 1.8 time = 2580
.meas tran vdout0_0ck128 FIND v(dout0_0) AT=2580.1n

* CHECK dout0_1 Vdout0_1ck128 = 1.8 time = 2580
.meas tran vdout0_1ck128 FIND v(dout0_1) AT=2580.1n

* CHECK dout0_2 Vdout0_2ck128 = 1.8 time = 2580
.meas tran vdout0_2ck128 FIND v(dout0_2) AT=2580.1n

* CHECK dout0_3 Vdout0_3ck128 = 1.8 time = 2580
.meas tran vdout0_3ck128 FIND v(dout0_3) AT=2580.1n

* CHECK dout0_4 Vdout0_4ck128 = 0 time = 2580
.meas tran vdout0_4ck128 FIND v(dout0_4) AT=2580.1n

* CHECK dout0_5 Vdout0_5ck128 = 0 time = 2580
.meas tran vdout0_5ck128 FIND v(dout0_5) AT=2580.1n

* CHECK dout0_6 Vdout0_6ck128 = 1.8 time = 2580
.meas tran vdout0_6ck128 FIND v(dout0_6) AT=2580.1n

* CHECK dout0_7 Vdout0_7ck128 = 0 time = 2580
.meas tran vdout0_7ck128 FIND v(dout0_7) AT=2580.1n

* CHECK dout0_8 Vdout0_8ck128 = 0 time = 2580
.meas tran vdout0_8ck128 FIND v(dout0_8) AT=2580.1n

* CHECK dout0_9 Vdout0_9ck128 = 0 time = 2580
.meas tran vdout0_9ck128 FIND v(dout0_9) AT=2580.1n

* CHECK dout0_10 Vdout0_10ck128 = 1.8 time = 2580
.meas tran vdout0_10ck128 FIND v(dout0_10) AT=2580.1n

* CHECK dout0_11 Vdout0_11ck128 = 0 time = 2580
.meas tran vdout0_11ck128 FIND v(dout0_11) AT=2580.1n

* CHECK dout0_12 Vdout0_12ck128 = 0 time = 2580
.meas tran vdout0_12ck128 FIND v(dout0_12) AT=2580.1n

* CHECK dout0_13 Vdout0_13ck128 = 1.8 time = 2580
.meas tran vdout0_13ck128 FIND v(dout0_13) AT=2580.1n

* CHECK dout0_14 Vdout0_14ck128 = 1.8 time = 2580
.meas tran vdout0_14ck128 FIND v(dout0_14) AT=2580.1n

* CHECK dout0_15 Vdout0_15ck128 = 1.8 time = 2580
.meas tran vdout0_15ck128 FIND v(dout0_15) AT=2580.1n

* CHECK dout0_0 Vdout0_0ck132 = 0 time = 2660
.meas tran vdout0_0ck132 FIND v(dout0_0) AT=2660.1n

* CHECK dout0_1 Vdout0_1ck132 = 1.8 time = 2660
.meas tran vdout0_1ck132 FIND v(dout0_1) AT=2660.1n

* CHECK dout0_2 Vdout0_2ck132 = 0 time = 2660
.meas tran vdout0_2ck132 FIND v(dout0_2) AT=2660.1n

* CHECK dout0_3 Vdout0_3ck132 = 0 time = 2660
.meas tran vdout0_3ck132 FIND v(dout0_3) AT=2660.1n

* CHECK dout0_4 Vdout0_4ck132 = 1.8 time = 2660
.meas tran vdout0_4ck132 FIND v(dout0_4) AT=2660.1n

* CHECK dout0_5 Vdout0_5ck132 = 1.8 time = 2660
.meas tran vdout0_5ck132 FIND v(dout0_5) AT=2660.1n

* CHECK dout0_6 Vdout0_6ck132 = 0 time = 2660
.meas tran vdout0_6ck132 FIND v(dout0_6) AT=2660.1n

* CHECK dout0_7 Vdout0_7ck132 = 1.8 time = 2660
.meas tran vdout0_7ck132 FIND v(dout0_7) AT=2660.1n

* CHECK dout0_8 Vdout0_8ck132 = 1.8 time = 2660
.meas tran vdout0_8ck132 FIND v(dout0_8) AT=2660.1n

* CHECK dout0_9 Vdout0_9ck132 = 0 time = 2660
.meas tran vdout0_9ck132 FIND v(dout0_9) AT=2660.1n

* CHECK dout0_10 Vdout0_10ck132 = 1.8 time = 2660
.meas tran vdout0_10ck132 FIND v(dout0_10) AT=2660.1n

* CHECK dout0_11 Vdout0_11ck132 = 0 time = 2660
.meas tran vdout0_11ck132 FIND v(dout0_11) AT=2660.1n

* CHECK dout0_12 Vdout0_12ck132 = 1.8 time = 2660
.meas tran vdout0_12ck132 FIND v(dout0_12) AT=2660.1n

* CHECK dout0_13 Vdout0_13ck132 = 1.8 time = 2660
.meas tran vdout0_13ck132 FIND v(dout0_13) AT=2660.1n

* CHECK dout0_14 Vdout0_14ck132 = 0 time = 2660
.meas tran vdout0_14ck132 FIND v(dout0_14) AT=2660.1n

* CHECK dout0_15 Vdout0_15ck132 = 1.8 time = 2660
.meas tran vdout0_15ck132 FIND v(dout0_15) AT=2660.1n

* CHECK dout0_0 Vdout0_0ck134 = 0 time = 2700
.meas tran vdout0_0ck134 FIND v(dout0_0) AT=2700.1n

* CHECK dout0_1 Vdout0_1ck134 = 1.8 time = 2700
.meas tran vdout0_1ck134 FIND v(dout0_1) AT=2700.1n

* CHECK dout0_2 Vdout0_2ck134 = 0 time = 2700
.meas tran vdout0_2ck134 FIND v(dout0_2) AT=2700.1n

* CHECK dout0_3 Vdout0_3ck134 = 1.8 time = 2700
.meas tran vdout0_3ck134 FIND v(dout0_3) AT=2700.1n

* CHECK dout0_4 Vdout0_4ck134 = 1.8 time = 2700
.meas tran vdout0_4ck134 FIND v(dout0_4) AT=2700.1n

* CHECK dout0_5 Vdout0_5ck134 = 0 time = 2700
.meas tran vdout0_5ck134 FIND v(dout0_5) AT=2700.1n

* CHECK dout0_6 Vdout0_6ck134 = 0 time = 2700
.meas tran vdout0_6ck134 FIND v(dout0_6) AT=2700.1n

* CHECK dout0_7 Vdout0_7ck134 = 1.8 time = 2700
.meas tran vdout0_7ck134 FIND v(dout0_7) AT=2700.1n

* CHECK dout0_8 Vdout0_8ck134 = 1.8 time = 2700
.meas tran vdout0_8ck134 FIND v(dout0_8) AT=2700.1n

* CHECK dout0_9 Vdout0_9ck134 = 0 time = 2700
.meas tran vdout0_9ck134 FIND v(dout0_9) AT=2700.1n

* CHECK dout0_10 Vdout0_10ck134 = 1.8 time = 2700
.meas tran vdout0_10ck134 FIND v(dout0_10) AT=2700.1n

* CHECK dout0_11 Vdout0_11ck134 = 0 time = 2700
.meas tran vdout0_11ck134 FIND v(dout0_11) AT=2700.1n

* CHECK dout0_12 Vdout0_12ck134 = 1.8 time = 2700
.meas tran vdout0_12ck134 FIND v(dout0_12) AT=2700.1n

* CHECK dout0_13 Vdout0_13ck134 = 0 time = 2700
.meas tran vdout0_13ck134 FIND v(dout0_13) AT=2700.1n

* CHECK dout0_14 Vdout0_14ck134 = 1.8 time = 2700
.meas tran vdout0_14ck134 FIND v(dout0_14) AT=2700.1n

* CHECK dout0_15 Vdout0_15ck134 = 0 time = 2700
.meas tran vdout0_15ck134 FIND v(dout0_15) AT=2700.1n

* CHECK dout0_0 Vdout0_0ck143 = 1.8 time = 2880
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=2880.1n

* CHECK dout0_1 Vdout0_1ck143 = 0 time = 2880
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=2880.1n

* CHECK dout0_2 Vdout0_2ck143 = 1.8 time = 2880
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=2880.1n

* CHECK dout0_3 Vdout0_3ck143 = 0 time = 2880
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=2880.1n

* CHECK dout0_4 Vdout0_4ck143 = 0 time = 2880
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=2880.1n

* CHECK dout0_5 Vdout0_5ck143 = 1.8 time = 2880
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=2880.1n

* CHECK dout0_6 Vdout0_6ck143 = 1.8 time = 2880
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=2880.1n

* CHECK dout0_7 Vdout0_7ck143 = 1.8 time = 2880
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=2880.1n

* CHECK dout0_8 Vdout0_8ck143 = 1.8 time = 2880
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=2880.1n

* CHECK dout0_9 Vdout0_9ck143 = 1.8 time = 2880
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=2880.1n

* CHECK dout0_10 Vdout0_10ck143 = 0 time = 2880
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=2880.1n

* CHECK dout0_11 Vdout0_11ck143 = 0 time = 2880
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=2880.1n

* CHECK dout0_12 Vdout0_12ck143 = 1.8 time = 2880
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=2880.1n

* CHECK dout0_13 Vdout0_13ck143 = 1.8 time = 2880
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=2880.1n

* CHECK dout0_14 Vdout0_14ck143 = 0 time = 2880
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=2880.1n

* CHECK dout0_15 Vdout0_15ck143 = 1.8 time = 2880
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=2880.1n

* CHECK dout0_0 Vdout0_0ck144 = 1.8 time = 2900
.meas tran vdout0_0ck144 FIND v(dout0_0) AT=2900.1n

* CHECK dout0_1 Vdout0_1ck144 = 0 time = 2900
.meas tran vdout0_1ck144 FIND v(dout0_1) AT=2900.1n

* CHECK dout0_2 Vdout0_2ck144 = 1.8 time = 2900
.meas tran vdout0_2ck144 FIND v(dout0_2) AT=2900.1n

* CHECK dout0_3 Vdout0_3ck144 = 0 time = 2900
.meas tran vdout0_3ck144 FIND v(dout0_3) AT=2900.1n

* CHECK dout0_4 Vdout0_4ck144 = 1.8 time = 2900
.meas tran vdout0_4ck144 FIND v(dout0_4) AT=2900.1n

* CHECK dout0_5 Vdout0_5ck144 = 0 time = 2900
.meas tran vdout0_5ck144 FIND v(dout0_5) AT=2900.1n

* CHECK dout0_6 Vdout0_6ck144 = 1.8 time = 2900
.meas tran vdout0_6ck144 FIND v(dout0_6) AT=2900.1n

* CHECK dout0_7 Vdout0_7ck144 = 1.8 time = 2900
.meas tran vdout0_7ck144 FIND v(dout0_7) AT=2900.1n

* CHECK dout0_8 Vdout0_8ck144 = 1.8 time = 2900
.meas tran vdout0_8ck144 FIND v(dout0_8) AT=2900.1n

* CHECK dout0_9 Vdout0_9ck144 = 1.8 time = 2900
.meas tran vdout0_9ck144 FIND v(dout0_9) AT=2900.1n

* CHECK dout0_10 Vdout0_10ck144 = 1.8 time = 2900
.meas tran vdout0_10ck144 FIND v(dout0_10) AT=2900.1n

* CHECK dout0_11 Vdout0_11ck144 = 0 time = 2900
.meas tran vdout0_11ck144 FIND v(dout0_11) AT=2900.1n

* CHECK dout0_12 Vdout0_12ck144 = 0 time = 2900
.meas tran vdout0_12ck144 FIND v(dout0_12) AT=2900.1n

* CHECK dout0_13 Vdout0_13ck144 = 0 time = 2900
.meas tran vdout0_13ck144 FIND v(dout0_13) AT=2900.1n

* CHECK dout0_14 Vdout0_14ck144 = 1.8 time = 2900
.meas tran vdout0_14ck144 FIND v(dout0_14) AT=2900.1n

* CHECK dout0_15 Vdout0_15ck144 = 1.8 time = 2900
.meas tran vdout0_15ck144 FIND v(dout0_15) AT=2900.1n

* CHECK dout0_0 Vdout0_0ck146 = 1.8 time = 2940
.meas tran vdout0_0ck146 FIND v(dout0_0) AT=2940.1n

* CHECK dout0_1 Vdout0_1ck146 = 0 time = 2940
.meas tran vdout0_1ck146 FIND v(dout0_1) AT=2940.1n

* CHECK dout0_2 Vdout0_2ck146 = 1.8 time = 2940
.meas tran vdout0_2ck146 FIND v(dout0_2) AT=2940.1n

* CHECK dout0_3 Vdout0_3ck146 = 0 time = 2940
.meas tran vdout0_3ck146 FIND v(dout0_3) AT=2940.1n

* CHECK dout0_4 Vdout0_4ck146 = 1.8 time = 2940
.meas tran vdout0_4ck146 FIND v(dout0_4) AT=2940.1n

* CHECK dout0_5 Vdout0_5ck146 = 0 time = 2940
.meas tran vdout0_5ck146 FIND v(dout0_5) AT=2940.1n

* CHECK dout0_6 Vdout0_6ck146 = 1.8 time = 2940
.meas tran vdout0_6ck146 FIND v(dout0_6) AT=2940.1n

* CHECK dout0_7 Vdout0_7ck146 = 1.8 time = 2940
.meas tran vdout0_7ck146 FIND v(dout0_7) AT=2940.1n

* CHECK dout0_8 Vdout0_8ck146 = 1.8 time = 2940
.meas tran vdout0_8ck146 FIND v(dout0_8) AT=2940.1n

* CHECK dout0_9 Vdout0_9ck146 = 1.8 time = 2940
.meas tran vdout0_9ck146 FIND v(dout0_9) AT=2940.1n

* CHECK dout0_10 Vdout0_10ck146 = 1.8 time = 2940
.meas tran vdout0_10ck146 FIND v(dout0_10) AT=2940.1n

* CHECK dout0_11 Vdout0_11ck146 = 0 time = 2940
.meas tran vdout0_11ck146 FIND v(dout0_11) AT=2940.1n

* CHECK dout0_12 Vdout0_12ck146 = 0 time = 2940
.meas tran vdout0_12ck146 FIND v(dout0_12) AT=2940.1n

* CHECK dout0_13 Vdout0_13ck146 = 0 time = 2940
.meas tran vdout0_13ck146 FIND v(dout0_13) AT=2940.1n

* CHECK dout0_14 Vdout0_14ck146 = 1.8 time = 2940
.meas tran vdout0_14ck146 FIND v(dout0_14) AT=2940.1n

* CHECK dout0_15 Vdout0_15ck146 = 1.8 time = 2940
.meas tran vdout0_15ck146 FIND v(dout0_15) AT=2940.1n

* CHECK dout0_0 Vdout0_0ck147 = 0 time = 2960
.meas tran vdout0_0ck147 FIND v(dout0_0) AT=2960.1n

* CHECK dout0_1 Vdout0_1ck147 = 0 time = 2960
.meas tran vdout0_1ck147 FIND v(dout0_1) AT=2960.1n

* CHECK dout0_2 Vdout0_2ck147 = 0 time = 2960
.meas tran vdout0_2ck147 FIND v(dout0_2) AT=2960.1n

* CHECK dout0_3 Vdout0_3ck147 = 1.8 time = 2960
.meas tran vdout0_3ck147 FIND v(dout0_3) AT=2960.1n

* CHECK dout0_4 Vdout0_4ck147 = 0 time = 2960
.meas tran vdout0_4ck147 FIND v(dout0_4) AT=2960.1n

* CHECK dout0_5 Vdout0_5ck147 = 0 time = 2960
.meas tran vdout0_5ck147 FIND v(dout0_5) AT=2960.1n

* CHECK dout0_6 Vdout0_6ck147 = 0 time = 2960
.meas tran vdout0_6ck147 FIND v(dout0_6) AT=2960.1n

* CHECK dout0_7 Vdout0_7ck147 = 0 time = 2960
.meas tran vdout0_7ck147 FIND v(dout0_7) AT=2960.1n

* CHECK dout0_8 Vdout0_8ck147 = 1.8 time = 2960
.meas tran vdout0_8ck147 FIND v(dout0_8) AT=2960.1n

* CHECK dout0_9 Vdout0_9ck147 = 1.8 time = 2960
.meas tran vdout0_9ck147 FIND v(dout0_9) AT=2960.1n

* CHECK dout0_10 Vdout0_10ck147 = 1.8 time = 2960
.meas tran vdout0_10ck147 FIND v(dout0_10) AT=2960.1n

* CHECK dout0_11 Vdout0_11ck147 = 0 time = 2960
.meas tran vdout0_11ck147 FIND v(dout0_11) AT=2960.1n

* CHECK dout0_12 Vdout0_12ck147 = 1.8 time = 2960
.meas tran vdout0_12ck147 FIND v(dout0_12) AT=2960.1n

* CHECK dout0_13 Vdout0_13ck147 = 0 time = 2960
.meas tran vdout0_13ck147 FIND v(dout0_13) AT=2960.1n

* CHECK dout0_14 Vdout0_14ck147 = 1.8 time = 2960
.meas tran vdout0_14ck147 FIND v(dout0_14) AT=2960.1n

* CHECK dout0_15 Vdout0_15ck147 = 0 time = 2960
.meas tran vdout0_15ck147 FIND v(dout0_15) AT=2960.1n

* CHECK dout0_0 Vdout0_0ck150 = 1.8 time = 3020
.meas tran vdout0_0ck150 FIND v(dout0_0) AT=3020.1n

* CHECK dout0_1 Vdout0_1ck150 = 0 time = 3020
.meas tran vdout0_1ck150 FIND v(dout0_1) AT=3020.1n

* CHECK dout0_2 Vdout0_2ck150 = 0 time = 3020
.meas tran vdout0_2ck150 FIND v(dout0_2) AT=3020.1n

* CHECK dout0_3 Vdout0_3ck150 = 1.8 time = 3020
.meas tran vdout0_3ck150 FIND v(dout0_3) AT=3020.1n

* CHECK dout0_4 Vdout0_4ck150 = 0 time = 3020
.meas tran vdout0_4ck150 FIND v(dout0_4) AT=3020.1n

* CHECK dout0_5 Vdout0_5ck150 = 0 time = 3020
.meas tran vdout0_5ck150 FIND v(dout0_5) AT=3020.1n

* CHECK dout0_6 Vdout0_6ck150 = 0 time = 3020
.meas tran vdout0_6ck150 FIND v(dout0_6) AT=3020.1n

* CHECK dout0_7 Vdout0_7ck150 = 0 time = 3020
.meas tran vdout0_7ck150 FIND v(dout0_7) AT=3020.1n

* CHECK dout0_8 Vdout0_8ck150 = 1.8 time = 3020
.meas tran vdout0_8ck150 FIND v(dout0_8) AT=3020.1n

* CHECK dout0_9 Vdout0_9ck150 = 0 time = 3020
.meas tran vdout0_9ck150 FIND v(dout0_9) AT=3020.1n

* CHECK dout0_10 Vdout0_10ck150 = 1.8 time = 3020
.meas tran vdout0_10ck150 FIND v(dout0_10) AT=3020.1n

* CHECK dout0_11 Vdout0_11ck150 = 0 time = 3020
.meas tran vdout0_11ck150 FIND v(dout0_11) AT=3020.1n

* CHECK dout0_12 Vdout0_12ck150 = 0 time = 3020
.meas tran vdout0_12ck150 FIND v(dout0_12) AT=3020.1n

* CHECK dout0_13 Vdout0_13ck150 = 0 time = 3020
.meas tran vdout0_13ck150 FIND v(dout0_13) AT=3020.1n

* CHECK dout0_14 Vdout0_14ck150 = 1.8 time = 3020
.meas tran vdout0_14ck150 FIND v(dout0_14) AT=3020.1n

* CHECK dout0_15 Vdout0_15ck150 = 0 time = 3020
.meas tran vdout0_15ck150 FIND v(dout0_15) AT=3020.1n

* CHECK dout0_0 Vdout0_0ck151 = 0 time = 3040
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=3040.1n

* CHECK dout0_1 Vdout0_1ck151 = 1.8 time = 3040
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=3040.1n

* CHECK dout0_2 Vdout0_2ck151 = 0 time = 3040
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=3040.1n

* CHECK dout0_3 Vdout0_3ck151 = 1.8 time = 3040
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=3040.1n

* CHECK dout0_4 Vdout0_4ck151 = 1.8 time = 3040
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=3040.1n

* CHECK dout0_5 Vdout0_5ck151 = 0 time = 3040
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=3040.1n

* CHECK dout0_6 Vdout0_6ck151 = 0 time = 3040
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=3040.1n

* CHECK dout0_7 Vdout0_7ck151 = 1.8 time = 3040
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=3040.1n

* CHECK dout0_8 Vdout0_8ck151 = 1.8 time = 3040
.meas tran vdout0_8ck151 FIND v(dout0_8) AT=3040.1n

* CHECK dout0_9 Vdout0_9ck151 = 0 time = 3040
.meas tran vdout0_9ck151 FIND v(dout0_9) AT=3040.1n

* CHECK dout0_10 Vdout0_10ck151 = 1.8 time = 3040
.meas tran vdout0_10ck151 FIND v(dout0_10) AT=3040.1n

* CHECK dout0_11 Vdout0_11ck151 = 0 time = 3040
.meas tran vdout0_11ck151 FIND v(dout0_11) AT=3040.1n

* CHECK dout0_12 Vdout0_12ck151 = 1.8 time = 3040
.meas tran vdout0_12ck151 FIND v(dout0_12) AT=3040.1n

* CHECK dout0_13 Vdout0_13ck151 = 0 time = 3040
.meas tran vdout0_13ck151 FIND v(dout0_13) AT=3040.1n

* CHECK dout0_14 Vdout0_14ck151 = 1.8 time = 3040
.meas tran vdout0_14ck151 FIND v(dout0_14) AT=3040.1n

* CHECK dout0_15 Vdout0_15ck151 = 0 time = 3040
.meas tran vdout0_15ck151 FIND v(dout0_15) AT=3040.1n

* CHECK dout0_0 Vdout0_0ck154 = 0 time = 3100
.meas tran vdout0_0ck154 FIND v(dout0_0) AT=3100.1n

* CHECK dout0_1 Vdout0_1ck154 = 1.8 time = 3100
.meas tran vdout0_1ck154 FIND v(dout0_1) AT=3100.1n

* CHECK dout0_2 Vdout0_2ck154 = 1.8 time = 3100
.meas tran vdout0_2ck154 FIND v(dout0_2) AT=3100.1n

* CHECK dout0_3 Vdout0_3ck154 = 0 time = 3100
.meas tran vdout0_3ck154 FIND v(dout0_3) AT=3100.1n

* CHECK dout0_4 Vdout0_4ck154 = 1.8 time = 3100
.meas tran vdout0_4ck154 FIND v(dout0_4) AT=3100.1n

* CHECK dout0_5 Vdout0_5ck154 = 1.8 time = 3100
.meas tran vdout0_5ck154 FIND v(dout0_5) AT=3100.1n

* CHECK dout0_6 Vdout0_6ck154 = 0 time = 3100
.meas tran vdout0_6ck154 FIND v(dout0_6) AT=3100.1n

* CHECK dout0_7 Vdout0_7ck154 = 1.8 time = 3100
.meas tran vdout0_7ck154 FIND v(dout0_7) AT=3100.1n

* CHECK dout0_8 Vdout0_8ck154 = 0 time = 3100
.meas tran vdout0_8ck154 FIND v(dout0_8) AT=3100.1n

* CHECK dout0_9 Vdout0_9ck154 = 0 time = 3100
.meas tran vdout0_9ck154 FIND v(dout0_9) AT=3100.1n

* CHECK dout0_10 Vdout0_10ck154 = 1.8 time = 3100
.meas tran vdout0_10ck154 FIND v(dout0_10) AT=3100.1n

* CHECK dout0_11 Vdout0_11ck154 = 0 time = 3100
.meas tran vdout0_11ck154 FIND v(dout0_11) AT=3100.1n

* CHECK dout0_12 Vdout0_12ck154 = 1.8 time = 3100
.meas tran vdout0_12ck154 FIND v(dout0_12) AT=3100.1n

* CHECK dout0_13 Vdout0_13ck154 = 1.8 time = 3100
.meas tran vdout0_13ck154 FIND v(dout0_13) AT=3100.1n

* CHECK dout0_14 Vdout0_14ck154 = 0 time = 3100
.meas tran vdout0_14ck154 FIND v(dout0_14) AT=3100.1n

* CHECK dout0_15 Vdout0_15ck154 = 0 time = 3100
.meas tran vdout0_15ck154 FIND v(dout0_15) AT=3100.1n

* CHECK dout0_0 Vdout0_0ck157 = 1.8 time = 3160
.meas tran vdout0_0ck157 FIND v(dout0_0) AT=3160.1n

* CHECK dout0_1 Vdout0_1ck157 = 0 time = 3160
.meas tran vdout0_1ck157 FIND v(dout0_1) AT=3160.1n

* CHECK dout0_2 Vdout0_2ck157 = 0 time = 3160
.meas tran vdout0_2ck157 FIND v(dout0_2) AT=3160.1n

* CHECK dout0_3 Vdout0_3ck157 = 1.8 time = 3160
.meas tran vdout0_3ck157 FIND v(dout0_3) AT=3160.1n

* CHECK dout0_4 Vdout0_4ck157 = 0 time = 3160
.meas tran vdout0_4ck157 FIND v(dout0_4) AT=3160.1n

* CHECK dout0_5 Vdout0_5ck157 = 0 time = 3160
.meas tran vdout0_5ck157 FIND v(dout0_5) AT=3160.1n

* CHECK dout0_6 Vdout0_6ck157 = 0 time = 3160
.meas tran vdout0_6ck157 FIND v(dout0_6) AT=3160.1n

* CHECK dout0_7 Vdout0_7ck157 = 0 time = 3160
.meas tran vdout0_7ck157 FIND v(dout0_7) AT=3160.1n

* CHECK dout0_8 Vdout0_8ck157 = 1.8 time = 3160
.meas tran vdout0_8ck157 FIND v(dout0_8) AT=3160.1n

* CHECK dout0_9 Vdout0_9ck157 = 0 time = 3160
.meas tran vdout0_9ck157 FIND v(dout0_9) AT=3160.1n

* CHECK dout0_10 Vdout0_10ck157 = 1.8 time = 3160
.meas tran vdout0_10ck157 FIND v(dout0_10) AT=3160.1n

* CHECK dout0_11 Vdout0_11ck157 = 0 time = 3160
.meas tran vdout0_11ck157 FIND v(dout0_11) AT=3160.1n

* CHECK dout0_12 Vdout0_12ck157 = 0 time = 3160
.meas tran vdout0_12ck157 FIND v(dout0_12) AT=3160.1n

* CHECK dout0_13 Vdout0_13ck157 = 0 time = 3160
.meas tran vdout0_13ck157 FIND v(dout0_13) AT=3160.1n

* CHECK dout0_14 Vdout0_14ck157 = 1.8 time = 3160
.meas tran vdout0_14ck157 FIND v(dout0_14) AT=3160.1n

* CHECK dout0_15 Vdout0_15ck157 = 0 time = 3160
.meas tran vdout0_15ck157 FIND v(dout0_15) AT=3160.1n

* CHECK dout0_0 Vdout0_0ck160 = 1.8 time = 3220
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=3220.1n

* CHECK dout0_1 Vdout0_1ck160 = 0 time = 3220
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=3220.1n

* CHECK dout0_2 Vdout0_2ck160 = 0 time = 3220
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=3220.1n

* CHECK dout0_3 Vdout0_3ck160 = 1.8 time = 3220
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=3220.1n

* CHECK dout0_4 Vdout0_4ck160 = 0 time = 3220
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=3220.1n

* CHECK dout0_5 Vdout0_5ck160 = 0 time = 3220
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=3220.1n

* CHECK dout0_6 Vdout0_6ck160 = 0 time = 3220
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=3220.1n

* CHECK dout0_7 Vdout0_7ck160 = 0 time = 3220
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=3220.1n

* CHECK dout0_8 Vdout0_8ck160 = 1.8 time = 3220
.meas tran vdout0_8ck160 FIND v(dout0_8) AT=3220.1n

* CHECK dout0_9 Vdout0_9ck160 = 0 time = 3220
.meas tran vdout0_9ck160 FIND v(dout0_9) AT=3220.1n

* CHECK dout0_10 Vdout0_10ck160 = 1.8 time = 3220
.meas tran vdout0_10ck160 FIND v(dout0_10) AT=3220.1n

* CHECK dout0_11 Vdout0_11ck160 = 0 time = 3220
.meas tran vdout0_11ck160 FIND v(dout0_11) AT=3220.1n

* CHECK dout0_12 Vdout0_12ck160 = 0 time = 3220
.meas tran vdout0_12ck160 FIND v(dout0_12) AT=3220.1n

* CHECK dout0_13 Vdout0_13ck160 = 0 time = 3220
.meas tran vdout0_13ck160 FIND v(dout0_13) AT=3220.1n

* CHECK dout0_14 Vdout0_14ck160 = 1.8 time = 3220
.meas tran vdout0_14ck160 FIND v(dout0_14) AT=3220.1n

* CHECK dout0_15 Vdout0_15ck160 = 0 time = 3220
.meas tran vdout0_15ck160 FIND v(dout0_15) AT=3220.1n

* CHECK dout0_0 Vdout0_0ck161 = 1.8 time = 3240
.meas tran vdout0_0ck161 FIND v(dout0_0) AT=3240.1n

* CHECK dout0_1 Vdout0_1ck161 = 0 time = 3240
.meas tran vdout0_1ck161 FIND v(dout0_1) AT=3240.1n

* CHECK dout0_2 Vdout0_2ck161 = 1.8 time = 3240
.meas tran vdout0_2ck161 FIND v(dout0_2) AT=3240.1n

* CHECK dout0_3 Vdout0_3ck161 = 0 time = 3240
.meas tran vdout0_3ck161 FIND v(dout0_3) AT=3240.1n

* CHECK dout0_4 Vdout0_4ck161 = 1.8 time = 3240
.meas tran vdout0_4ck161 FIND v(dout0_4) AT=3240.1n

* CHECK dout0_5 Vdout0_5ck161 = 0 time = 3240
.meas tran vdout0_5ck161 FIND v(dout0_5) AT=3240.1n

* CHECK dout0_6 Vdout0_6ck161 = 1.8 time = 3240
.meas tran vdout0_6ck161 FIND v(dout0_6) AT=3240.1n

* CHECK dout0_7 Vdout0_7ck161 = 1.8 time = 3240
.meas tran vdout0_7ck161 FIND v(dout0_7) AT=3240.1n

* CHECK dout0_8 Vdout0_8ck161 = 1.8 time = 3240
.meas tran vdout0_8ck161 FIND v(dout0_8) AT=3240.1n

* CHECK dout0_9 Vdout0_9ck161 = 1.8 time = 3240
.meas tran vdout0_9ck161 FIND v(dout0_9) AT=3240.1n

* CHECK dout0_10 Vdout0_10ck161 = 1.8 time = 3240
.meas tran vdout0_10ck161 FIND v(dout0_10) AT=3240.1n

* CHECK dout0_11 Vdout0_11ck161 = 0 time = 3240
.meas tran vdout0_11ck161 FIND v(dout0_11) AT=3240.1n

* CHECK dout0_12 Vdout0_12ck161 = 0 time = 3240
.meas tran vdout0_12ck161 FIND v(dout0_12) AT=3240.1n

* CHECK dout0_13 Vdout0_13ck161 = 0 time = 3240
.meas tran vdout0_13ck161 FIND v(dout0_13) AT=3240.1n

* CHECK dout0_14 Vdout0_14ck161 = 1.8 time = 3240
.meas tran vdout0_14ck161 FIND v(dout0_14) AT=3240.1n

* CHECK dout0_15 Vdout0_15ck161 = 1.8 time = 3240
.meas tran vdout0_15ck161 FIND v(dout0_15) AT=3240.1n

* CHECK dout0_0 Vdout0_0ck162 = 0 time = 3260
.meas tran vdout0_0ck162 FIND v(dout0_0) AT=3260.1n

* CHECK dout0_1 Vdout0_1ck162 = 1.8 time = 3260
.meas tran vdout0_1ck162 FIND v(dout0_1) AT=3260.1n

* CHECK dout0_2 Vdout0_2ck162 = 1.8 time = 3260
.meas tran vdout0_2ck162 FIND v(dout0_2) AT=3260.1n

* CHECK dout0_3 Vdout0_3ck162 = 1.8 time = 3260
.meas tran vdout0_3ck162 FIND v(dout0_3) AT=3260.1n

* CHECK dout0_4 Vdout0_4ck162 = 0 time = 3260
.meas tran vdout0_4ck162 FIND v(dout0_4) AT=3260.1n

* CHECK dout0_5 Vdout0_5ck162 = 1.8 time = 3260
.meas tran vdout0_5ck162 FIND v(dout0_5) AT=3260.1n

* CHECK dout0_6 Vdout0_6ck162 = 1.8 time = 3260
.meas tran vdout0_6ck162 FIND v(dout0_6) AT=3260.1n

* CHECK dout0_7 Vdout0_7ck162 = 1.8 time = 3260
.meas tran vdout0_7ck162 FIND v(dout0_7) AT=3260.1n

* CHECK dout0_8 Vdout0_8ck162 = 0 time = 3260
.meas tran vdout0_8ck162 FIND v(dout0_8) AT=3260.1n

* CHECK dout0_9 Vdout0_9ck162 = 0 time = 3260
.meas tran vdout0_9ck162 FIND v(dout0_9) AT=3260.1n

* CHECK dout0_10 Vdout0_10ck162 = 0 time = 3260
.meas tran vdout0_10ck162 FIND v(dout0_10) AT=3260.1n

* CHECK dout0_11 Vdout0_11ck162 = 1.8 time = 3260
.meas tran vdout0_11ck162 FIND v(dout0_11) AT=3260.1n

* CHECK dout0_12 Vdout0_12ck162 = 0 time = 3260
.meas tran vdout0_12ck162 FIND v(dout0_12) AT=3260.1n

* CHECK dout0_13 Vdout0_13ck162 = 1.8 time = 3260
.meas tran vdout0_13ck162 FIND v(dout0_13) AT=3260.1n

* CHECK dout0_14 Vdout0_14ck162 = 1.8 time = 3260
.meas tran vdout0_14ck162 FIND v(dout0_14) AT=3260.1n

* CHECK dout0_15 Vdout0_15ck162 = 1.8 time = 3260
.meas tran vdout0_15ck162 FIND v(dout0_15) AT=3260.1n

* CHECK dout0_0 Vdout0_0ck165 = 0 time = 3320
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=3320.1n

* CHECK dout0_1 Vdout0_1ck165 = 1.8 time = 3320
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=3320.1n

* CHECK dout0_2 Vdout0_2ck165 = 1.8 time = 3320
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=3320.1n

* CHECK dout0_3 Vdout0_3ck165 = 0 time = 3320
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=3320.1n

* CHECK dout0_4 Vdout0_4ck165 = 1.8 time = 3320
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=3320.1n

* CHECK dout0_5 Vdout0_5ck165 = 1.8 time = 3320
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=3320.1n

* CHECK dout0_6 Vdout0_6ck165 = 0 time = 3320
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=3320.1n

* CHECK dout0_7 Vdout0_7ck165 = 1.8 time = 3320
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=3320.1n

* CHECK dout0_8 Vdout0_8ck165 = 0 time = 3320
.meas tran vdout0_8ck165 FIND v(dout0_8) AT=3320.1n

* CHECK dout0_9 Vdout0_9ck165 = 0 time = 3320
.meas tran vdout0_9ck165 FIND v(dout0_9) AT=3320.1n

* CHECK dout0_10 Vdout0_10ck165 = 1.8 time = 3320
.meas tran vdout0_10ck165 FIND v(dout0_10) AT=3320.1n

* CHECK dout0_11 Vdout0_11ck165 = 0 time = 3320
.meas tran vdout0_11ck165 FIND v(dout0_11) AT=3320.1n

* CHECK dout0_12 Vdout0_12ck165 = 1.8 time = 3320
.meas tran vdout0_12ck165 FIND v(dout0_12) AT=3320.1n

* CHECK dout0_13 Vdout0_13ck165 = 1.8 time = 3320
.meas tran vdout0_13ck165 FIND v(dout0_13) AT=3320.1n

* CHECK dout0_14 Vdout0_14ck165 = 0 time = 3320
.meas tran vdout0_14ck165 FIND v(dout0_14) AT=3320.1n

* CHECK dout0_15 Vdout0_15ck165 = 0 time = 3320
.meas tran vdout0_15ck165 FIND v(dout0_15) AT=3320.1n

* CHECK dout0_0 Vdout0_0ck166 = 0 time = 3340
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=3340.1n

* CHECK dout0_1 Vdout0_1ck166 = 1.8 time = 3340
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=3340.1n

* CHECK dout0_2 Vdout0_2ck166 = 0 time = 3340
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=3340.1n

* CHECK dout0_3 Vdout0_3ck166 = 1.8 time = 3340
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=3340.1n

* CHECK dout0_4 Vdout0_4ck166 = 1.8 time = 3340
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=3340.1n

* CHECK dout0_5 Vdout0_5ck166 = 0 time = 3340
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=3340.1n

* CHECK dout0_6 Vdout0_6ck166 = 0 time = 3340
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=3340.1n

* CHECK dout0_7 Vdout0_7ck166 = 1.8 time = 3340
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=3340.1n

* CHECK dout0_8 Vdout0_8ck166 = 1.8 time = 3340
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=3340.1n

* CHECK dout0_9 Vdout0_9ck166 = 0 time = 3340
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=3340.1n

* CHECK dout0_10 Vdout0_10ck166 = 1.8 time = 3340
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=3340.1n

* CHECK dout0_11 Vdout0_11ck166 = 0 time = 3340
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=3340.1n

* CHECK dout0_12 Vdout0_12ck166 = 1.8 time = 3340
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=3340.1n

* CHECK dout0_13 Vdout0_13ck166 = 0 time = 3340
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=3340.1n

* CHECK dout0_14 Vdout0_14ck166 = 1.8 time = 3340
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=3340.1n

* CHECK dout0_15 Vdout0_15ck166 = 0 time = 3340
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=3340.1n

* CHECK dout0_0 Vdout0_0ck170 = 1.8 time = 3420
.meas tran vdout0_0ck170 FIND v(dout0_0) AT=3420.1n

* CHECK dout0_1 Vdout0_1ck170 = 0 time = 3420
.meas tran vdout0_1ck170 FIND v(dout0_1) AT=3420.1n

* CHECK dout0_2 Vdout0_2ck170 = 0 time = 3420
.meas tran vdout0_2ck170 FIND v(dout0_2) AT=3420.1n

* CHECK dout0_3 Vdout0_3ck170 = 1.8 time = 3420
.meas tran vdout0_3ck170 FIND v(dout0_3) AT=3420.1n

* CHECK dout0_4 Vdout0_4ck170 = 0 time = 3420
.meas tran vdout0_4ck170 FIND v(dout0_4) AT=3420.1n

* CHECK dout0_5 Vdout0_5ck170 = 0 time = 3420
.meas tran vdout0_5ck170 FIND v(dout0_5) AT=3420.1n

* CHECK dout0_6 Vdout0_6ck170 = 0 time = 3420
.meas tran vdout0_6ck170 FIND v(dout0_6) AT=3420.1n

* CHECK dout0_7 Vdout0_7ck170 = 0 time = 3420
.meas tran vdout0_7ck170 FIND v(dout0_7) AT=3420.1n

* CHECK dout0_8 Vdout0_8ck170 = 1.8 time = 3420
.meas tran vdout0_8ck170 FIND v(dout0_8) AT=3420.1n

* CHECK dout0_9 Vdout0_9ck170 = 0 time = 3420
.meas tran vdout0_9ck170 FIND v(dout0_9) AT=3420.1n

* CHECK dout0_10 Vdout0_10ck170 = 1.8 time = 3420
.meas tran vdout0_10ck170 FIND v(dout0_10) AT=3420.1n

* CHECK dout0_11 Vdout0_11ck170 = 0 time = 3420
.meas tran vdout0_11ck170 FIND v(dout0_11) AT=3420.1n

* CHECK dout0_12 Vdout0_12ck170 = 0 time = 3420
.meas tran vdout0_12ck170 FIND v(dout0_12) AT=3420.1n

* CHECK dout0_13 Vdout0_13ck170 = 0 time = 3420
.meas tran vdout0_13ck170 FIND v(dout0_13) AT=3420.1n

* CHECK dout0_14 Vdout0_14ck170 = 1.8 time = 3420
.meas tran vdout0_14ck170 FIND v(dout0_14) AT=3420.1n

* CHECK dout0_15 Vdout0_15ck170 = 0 time = 3420
.meas tran vdout0_15ck170 FIND v(dout0_15) AT=3420.1n

* CHECK dout0_0 Vdout0_0ck174 = 0 time = 3500
.meas tran vdout0_0ck174 FIND v(dout0_0) AT=3500.1n

* CHECK dout0_1 Vdout0_1ck174 = 1.8 time = 3500
.meas tran vdout0_1ck174 FIND v(dout0_1) AT=3500.1n

* CHECK dout0_2 Vdout0_2ck174 = 0 time = 3500
.meas tran vdout0_2ck174 FIND v(dout0_2) AT=3500.1n

* CHECK dout0_3 Vdout0_3ck174 = 1.8 time = 3500
.meas tran vdout0_3ck174 FIND v(dout0_3) AT=3500.1n

* CHECK dout0_4 Vdout0_4ck174 = 0 time = 3500
.meas tran vdout0_4ck174 FIND v(dout0_4) AT=3500.1n

* CHECK dout0_5 Vdout0_5ck174 = 0 time = 3500
.meas tran vdout0_5ck174 FIND v(dout0_5) AT=3500.1n

* CHECK dout0_6 Vdout0_6ck174 = 0 time = 3500
.meas tran vdout0_6ck174 FIND v(dout0_6) AT=3500.1n

* CHECK dout0_7 Vdout0_7ck174 = 1.8 time = 3500
.meas tran vdout0_7ck174 FIND v(dout0_7) AT=3500.1n

* CHECK dout0_8 Vdout0_8ck174 = 1.8 time = 3500
.meas tran vdout0_8ck174 FIND v(dout0_8) AT=3500.1n

* CHECK dout0_9 Vdout0_9ck174 = 0 time = 3500
.meas tran vdout0_9ck174 FIND v(dout0_9) AT=3500.1n

* CHECK dout0_10 Vdout0_10ck174 = 0 time = 3500
.meas tran vdout0_10ck174 FIND v(dout0_10) AT=3500.1n

* CHECK dout0_11 Vdout0_11ck174 = 1.8 time = 3500
.meas tran vdout0_11ck174 FIND v(dout0_11) AT=3500.1n

* CHECK dout0_12 Vdout0_12ck174 = 1.8 time = 3500
.meas tran vdout0_12ck174 FIND v(dout0_12) AT=3500.1n

* CHECK dout0_13 Vdout0_13ck174 = 1.8 time = 3500
.meas tran vdout0_13ck174 FIND v(dout0_13) AT=3500.1n

* CHECK dout0_14 Vdout0_14ck174 = 1.8 time = 3500
.meas tran vdout0_14ck174 FIND v(dout0_14) AT=3500.1n

* CHECK dout0_15 Vdout0_15ck174 = 1.8 time = 3500
.meas tran vdout0_15ck174 FIND v(dout0_15) AT=3500.1n

* CHECK dout0_0 Vdout0_0ck175 = 0 time = 3520
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=3520.1n

* CHECK dout0_1 Vdout0_1ck175 = 0 time = 3520
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=3520.1n

* CHECK dout0_2 Vdout0_2ck175 = 1.8 time = 3520
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=3520.1n

* CHECK dout0_3 Vdout0_3ck175 = 0 time = 3520
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=3520.1n

* CHECK dout0_4 Vdout0_4ck175 = 0 time = 3520
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=3520.1n

* CHECK dout0_5 Vdout0_5ck175 = 1.8 time = 3520
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=3520.1n

* CHECK dout0_6 Vdout0_6ck175 = 0 time = 3520
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=3520.1n

* CHECK dout0_7 Vdout0_7ck175 = 1.8 time = 3520
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=3520.1n

* CHECK dout0_8 Vdout0_8ck175 = 1.8 time = 3520
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=3520.1n

* CHECK dout0_9 Vdout0_9ck175 = 1.8 time = 3520
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=3520.1n

* CHECK dout0_10 Vdout0_10ck175 = 1.8 time = 3520
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=3520.1n

* CHECK dout0_11 Vdout0_11ck175 = 1.8 time = 3520
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=3520.1n

* CHECK dout0_12 Vdout0_12ck175 = 1.8 time = 3520
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=3520.1n

* CHECK dout0_13 Vdout0_13ck175 = 1.8 time = 3520
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=3520.1n

* CHECK dout0_14 Vdout0_14ck175 = 1.8 time = 3520
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=3520.1n

* CHECK dout0_15 Vdout0_15ck175 = 1.8 time = 3520
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=3520.1n

* CHECK dout0_0 Vdout0_0ck176 = 0 time = 3540
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=3540.1n

* CHECK dout0_1 Vdout0_1ck176 = 0 time = 3540
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=3540.1n

* CHECK dout0_2 Vdout0_2ck176 = 0 time = 3540
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=3540.1n

* CHECK dout0_3 Vdout0_3ck176 = 0 time = 3540
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=3540.1n

* CHECK dout0_4 Vdout0_4ck176 = 1.8 time = 3540
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=3540.1n

* CHECK dout0_5 Vdout0_5ck176 = 0 time = 3540
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=3540.1n

* CHECK dout0_6 Vdout0_6ck176 = 1.8 time = 3540
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=3540.1n

* CHECK dout0_7 Vdout0_7ck176 = 0 time = 3540
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=3540.1n

* CHECK dout0_8 Vdout0_8ck176 = 1.8 time = 3540
.meas tran vdout0_8ck176 FIND v(dout0_8) AT=3540.1n

* CHECK dout0_9 Vdout0_9ck176 = 1.8 time = 3540
.meas tran vdout0_9ck176 FIND v(dout0_9) AT=3540.1n

* CHECK dout0_10 Vdout0_10ck176 = 1.8 time = 3540
.meas tran vdout0_10ck176 FIND v(dout0_10) AT=3540.1n

* CHECK dout0_11 Vdout0_11ck176 = 0 time = 3540
.meas tran vdout0_11ck176 FIND v(dout0_11) AT=3540.1n

* CHECK dout0_12 Vdout0_12ck176 = 1.8 time = 3540
.meas tran vdout0_12ck176 FIND v(dout0_12) AT=3540.1n

* CHECK dout0_13 Vdout0_13ck176 = 0 time = 3540
.meas tran vdout0_13ck176 FIND v(dout0_13) AT=3540.1n

* CHECK dout0_14 Vdout0_14ck176 = 1.8 time = 3540
.meas tran vdout0_14ck176 FIND v(dout0_14) AT=3540.1n

* CHECK dout0_15 Vdout0_15ck176 = 1.8 time = 3540
.meas tran vdout0_15ck176 FIND v(dout0_15) AT=3540.1n

* CHECK dout0_0 Vdout0_0ck177 = 1.8 time = 3560
.meas tran vdout0_0ck177 FIND v(dout0_0) AT=3560.1n

* CHECK dout0_1 Vdout0_1ck177 = 0 time = 3560
.meas tran vdout0_1ck177 FIND v(dout0_1) AT=3560.1n

* CHECK dout0_2 Vdout0_2ck177 = 0 time = 3560
.meas tran vdout0_2ck177 FIND v(dout0_2) AT=3560.1n

* CHECK dout0_3 Vdout0_3ck177 = 1.8 time = 3560
.meas tran vdout0_3ck177 FIND v(dout0_3) AT=3560.1n

* CHECK dout0_4 Vdout0_4ck177 = 0 time = 3560
.meas tran vdout0_4ck177 FIND v(dout0_4) AT=3560.1n

* CHECK dout0_5 Vdout0_5ck177 = 0 time = 3560
.meas tran vdout0_5ck177 FIND v(dout0_5) AT=3560.1n

* CHECK dout0_6 Vdout0_6ck177 = 0 time = 3560
.meas tran vdout0_6ck177 FIND v(dout0_6) AT=3560.1n

* CHECK dout0_7 Vdout0_7ck177 = 0 time = 3560
.meas tran vdout0_7ck177 FIND v(dout0_7) AT=3560.1n

* CHECK dout0_8 Vdout0_8ck177 = 1.8 time = 3560
.meas tran vdout0_8ck177 FIND v(dout0_8) AT=3560.1n

* CHECK dout0_9 Vdout0_9ck177 = 0 time = 3560
.meas tran vdout0_9ck177 FIND v(dout0_9) AT=3560.1n

* CHECK dout0_10 Vdout0_10ck177 = 1.8 time = 3560
.meas tran vdout0_10ck177 FIND v(dout0_10) AT=3560.1n

* CHECK dout0_11 Vdout0_11ck177 = 0 time = 3560
.meas tran vdout0_11ck177 FIND v(dout0_11) AT=3560.1n

* CHECK dout0_12 Vdout0_12ck177 = 0 time = 3560
.meas tran vdout0_12ck177 FIND v(dout0_12) AT=3560.1n

* CHECK dout0_13 Vdout0_13ck177 = 0 time = 3560
.meas tran vdout0_13ck177 FIND v(dout0_13) AT=3560.1n

* CHECK dout0_14 Vdout0_14ck177 = 1.8 time = 3560
.meas tran vdout0_14ck177 FIND v(dout0_14) AT=3560.1n

* CHECK dout0_15 Vdout0_15ck177 = 0 time = 3560
.meas tran vdout0_15ck177 FIND v(dout0_15) AT=3560.1n

* CHECK dout0_0 Vdout0_0ck178 = 1.8 time = 3580
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=3580.1n

* CHECK dout0_1 Vdout0_1ck178 = 0 time = 3580
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=3580.1n

* CHECK dout0_2 Vdout0_2ck178 = 1.8 time = 3580
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=3580.1n

* CHECK dout0_3 Vdout0_3ck178 = 0 time = 3580
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=3580.1n

* CHECK dout0_4 Vdout0_4ck178 = 1.8 time = 3580
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=3580.1n

* CHECK dout0_5 Vdout0_5ck178 = 0 time = 3580
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=3580.1n

* CHECK dout0_6 Vdout0_6ck178 = 1.8 time = 3580
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=3580.1n

* CHECK dout0_7 Vdout0_7ck178 = 1.8 time = 3580
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=3580.1n

* CHECK dout0_8 Vdout0_8ck178 = 1.8 time = 3580
.meas tran vdout0_8ck178 FIND v(dout0_8) AT=3580.1n

* CHECK dout0_9 Vdout0_9ck178 = 1.8 time = 3580
.meas tran vdout0_9ck178 FIND v(dout0_9) AT=3580.1n

* CHECK dout0_10 Vdout0_10ck178 = 1.8 time = 3580
.meas tran vdout0_10ck178 FIND v(dout0_10) AT=3580.1n

* CHECK dout0_11 Vdout0_11ck178 = 0 time = 3580
.meas tran vdout0_11ck178 FIND v(dout0_11) AT=3580.1n

* CHECK dout0_12 Vdout0_12ck178 = 0 time = 3580
.meas tran vdout0_12ck178 FIND v(dout0_12) AT=3580.1n

* CHECK dout0_13 Vdout0_13ck178 = 0 time = 3580
.meas tran vdout0_13ck178 FIND v(dout0_13) AT=3580.1n

* CHECK dout0_14 Vdout0_14ck178 = 1.8 time = 3580
.meas tran vdout0_14ck178 FIND v(dout0_14) AT=3580.1n

* CHECK dout0_15 Vdout0_15ck178 = 1.8 time = 3580
.meas tran vdout0_15ck178 FIND v(dout0_15) AT=3580.1n

* CHECK dout0_0 Vdout0_0ck180 = 0 time = 3620
.meas tran vdout0_0ck180 FIND v(dout0_0) AT=3620.1n

* CHECK dout0_1 Vdout0_1ck180 = 1.8 time = 3620
.meas tran vdout0_1ck180 FIND v(dout0_1) AT=3620.1n

* CHECK dout0_2 Vdout0_2ck180 = 1.8 time = 3620
.meas tran vdout0_2ck180 FIND v(dout0_2) AT=3620.1n

* CHECK dout0_3 Vdout0_3ck180 = 1.8 time = 3620
.meas tran vdout0_3ck180 FIND v(dout0_3) AT=3620.1n

* CHECK dout0_4 Vdout0_4ck180 = 0 time = 3620
.meas tran vdout0_4ck180 FIND v(dout0_4) AT=3620.1n

* CHECK dout0_5 Vdout0_5ck180 = 1.8 time = 3620
.meas tran vdout0_5ck180 FIND v(dout0_5) AT=3620.1n

* CHECK dout0_6 Vdout0_6ck180 = 1.8 time = 3620
.meas tran vdout0_6ck180 FIND v(dout0_6) AT=3620.1n

* CHECK dout0_7 Vdout0_7ck180 = 1.8 time = 3620
.meas tran vdout0_7ck180 FIND v(dout0_7) AT=3620.1n

* CHECK dout0_8 Vdout0_8ck180 = 0 time = 3620
.meas tran vdout0_8ck180 FIND v(dout0_8) AT=3620.1n

* CHECK dout0_9 Vdout0_9ck180 = 0 time = 3620
.meas tran vdout0_9ck180 FIND v(dout0_9) AT=3620.1n

* CHECK dout0_10 Vdout0_10ck180 = 0 time = 3620
.meas tran vdout0_10ck180 FIND v(dout0_10) AT=3620.1n

* CHECK dout0_11 Vdout0_11ck180 = 1.8 time = 3620
.meas tran vdout0_11ck180 FIND v(dout0_11) AT=3620.1n

* CHECK dout0_12 Vdout0_12ck180 = 0 time = 3620
.meas tran vdout0_12ck180 FIND v(dout0_12) AT=3620.1n

* CHECK dout0_13 Vdout0_13ck180 = 1.8 time = 3620
.meas tran vdout0_13ck180 FIND v(dout0_13) AT=3620.1n

* CHECK dout0_14 Vdout0_14ck180 = 1.8 time = 3620
.meas tran vdout0_14ck180 FIND v(dout0_14) AT=3620.1n

* CHECK dout0_15 Vdout0_15ck180 = 1.8 time = 3620
.meas tran vdout0_15ck180 FIND v(dout0_15) AT=3620.1n

* CHECK dout0_0 Vdout0_0ck181 = 1.8 time = 3640
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=3640.1n

* CHECK dout0_1 Vdout0_1ck181 = 0 time = 3640
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=3640.1n

* CHECK dout0_2 Vdout0_2ck181 = 1.8 time = 3640
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=3640.1n

* CHECK dout0_3 Vdout0_3ck181 = 1.8 time = 3640
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=3640.1n

* CHECK dout0_4 Vdout0_4ck181 = 1.8 time = 3640
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=3640.1n

* CHECK dout0_5 Vdout0_5ck181 = 1.8 time = 3640
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=3640.1n

* CHECK dout0_6 Vdout0_6ck181 = 1.8 time = 3640
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=3640.1n

* CHECK dout0_7 Vdout0_7ck181 = 0 time = 3640
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=3640.1n

* CHECK dout0_8 Vdout0_8ck181 = 0 time = 3640
.meas tran vdout0_8ck181 FIND v(dout0_8) AT=3640.1n

* CHECK dout0_9 Vdout0_9ck181 = 1.8 time = 3640
.meas tran vdout0_9ck181 FIND v(dout0_9) AT=3640.1n

* CHECK dout0_10 Vdout0_10ck181 = 1.8 time = 3640
.meas tran vdout0_10ck181 FIND v(dout0_10) AT=3640.1n

* CHECK dout0_11 Vdout0_11ck181 = 1.8 time = 3640
.meas tran vdout0_11ck181 FIND v(dout0_11) AT=3640.1n

* CHECK dout0_12 Vdout0_12ck181 = 0 time = 3640
.meas tran vdout0_12ck181 FIND v(dout0_12) AT=3640.1n

* CHECK dout0_13 Vdout0_13ck181 = 0 time = 3640
.meas tran vdout0_13ck181 FIND v(dout0_13) AT=3640.1n

* CHECK dout0_14 Vdout0_14ck181 = 1.8 time = 3640
.meas tran vdout0_14ck181 FIND v(dout0_14) AT=3640.1n

* CHECK dout0_15 Vdout0_15ck181 = 1.8 time = 3640
.meas tran vdout0_15ck181 FIND v(dout0_15) AT=3640.1n

* CHECK dout0_0 Vdout0_0ck184 = 0 time = 3700
.meas tran vdout0_0ck184 FIND v(dout0_0) AT=3700.1n

* CHECK dout0_1 Vdout0_1ck184 = 1.8 time = 3700
.meas tran vdout0_1ck184 FIND v(dout0_1) AT=3700.1n

* CHECK dout0_2 Vdout0_2ck184 = 1.8 time = 3700
.meas tran vdout0_2ck184 FIND v(dout0_2) AT=3700.1n

* CHECK dout0_3 Vdout0_3ck184 = 1.8 time = 3700
.meas tran vdout0_3ck184 FIND v(dout0_3) AT=3700.1n

* CHECK dout0_4 Vdout0_4ck184 = 0 time = 3700
.meas tran vdout0_4ck184 FIND v(dout0_4) AT=3700.1n

* CHECK dout0_5 Vdout0_5ck184 = 1.8 time = 3700
.meas tran vdout0_5ck184 FIND v(dout0_5) AT=3700.1n

* CHECK dout0_6 Vdout0_6ck184 = 1.8 time = 3700
.meas tran vdout0_6ck184 FIND v(dout0_6) AT=3700.1n

* CHECK dout0_7 Vdout0_7ck184 = 1.8 time = 3700
.meas tran vdout0_7ck184 FIND v(dout0_7) AT=3700.1n

* CHECK dout0_8 Vdout0_8ck184 = 0 time = 3700
.meas tran vdout0_8ck184 FIND v(dout0_8) AT=3700.1n

* CHECK dout0_9 Vdout0_9ck184 = 0 time = 3700
.meas tran vdout0_9ck184 FIND v(dout0_9) AT=3700.1n

* CHECK dout0_10 Vdout0_10ck184 = 0 time = 3700
.meas tran vdout0_10ck184 FIND v(dout0_10) AT=3700.1n

* CHECK dout0_11 Vdout0_11ck184 = 1.8 time = 3700
.meas tran vdout0_11ck184 FIND v(dout0_11) AT=3700.1n

* CHECK dout0_12 Vdout0_12ck184 = 0 time = 3700
.meas tran vdout0_12ck184 FIND v(dout0_12) AT=3700.1n

* CHECK dout0_13 Vdout0_13ck184 = 1.8 time = 3700
.meas tran vdout0_13ck184 FIND v(dout0_13) AT=3700.1n

* CHECK dout0_14 Vdout0_14ck184 = 1.8 time = 3700
.meas tran vdout0_14ck184 FIND v(dout0_14) AT=3700.1n

* CHECK dout0_15 Vdout0_15ck184 = 1.8 time = 3700
.meas tran vdout0_15ck184 FIND v(dout0_15) AT=3700.1n

* CHECK dout0_0 Vdout0_0ck185 = 0 time = 3720
.meas tran vdout0_0ck185 FIND v(dout0_0) AT=3720.1n

* CHECK dout0_1 Vdout0_1ck185 = 0 time = 3720
.meas tran vdout0_1ck185 FIND v(dout0_1) AT=3720.1n

* CHECK dout0_2 Vdout0_2ck185 = 0 time = 3720
.meas tran vdout0_2ck185 FIND v(dout0_2) AT=3720.1n

* CHECK dout0_3 Vdout0_3ck185 = 0 time = 3720
.meas tran vdout0_3ck185 FIND v(dout0_3) AT=3720.1n

* CHECK dout0_4 Vdout0_4ck185 = 1.8 time = 3720
.meas tran vdout0_4ck185 FIND v(dout0_4) AT=3720.1n

* CHECK dout0_5 Vdout0_5ck185 = 0 time = 3720
.meas tran vdout0_5ck185 FIND v(dout0_5) AT=3720.1n

* CHECK dout0_6 Vdout0_6ck185 = 1.8 time = 3720
.meas tran vdout0_6ck185 FIND v(dout0_6) AT=3720.1n

* CHECK dout0_7 Vdout0_7ck185 = 0 time = 3720
.meas tran vdout0_7ck185 FIND v(dout0_7) AT=3720.1n

* CHECK dout0_8 Vdout0_8ck185 = 1.8 time = 3720
.meas tran vdout0_8ck185 FIND v(dout0_8) AT=3720.1n

* CHECK dout0_9 Vdout0_9ck185 = 1.8 time = 3720
.meas tran vdout0_9ck185 FIND v(dout0_9) AT=3720.1n

* CHECK dout0_10 Vdout0_10ck185 = 1.8 time = 3720
.meas tran vdout0_10ck185 FIND v(dout0_10) AT=3720.1n

* CHECK dout0_11 Vdout0_11ck185 = 0 time = 3720
.meas tran vdout0_11ck185 FIND v(dout0_11) AT=3720.1n

* CHECK dout0_12 Vdout0_12ck185 = 1.8 time = 3720
.meas tran vdout0_12ck185 FIND v(dout0_12) AT=3720.1n

* CHECK dout0_13 Vdout0_13ck185 = 0 time = 3720
.meas tran vdout0_13ck185 FIND v(dout0_13) AT=3720.1n

* CHECK dout0_14 Vdout0_14ck185 = 1.8 time = 3720
.meas tran vdout0_14ck185 FIND v(dout0_14) AT=3720.1n

* CHECK dout0_15 Vdout0_15ck185 = 1.8 time = 3720
.meas tran vdout0_15ck185 FIND v(dout0_15) AT=3720.1n

* CHECK dout0_0 Vdout0_0ck188 = 1.8 time = 3780
.meas tran vdout0_0ck188 FIND v(dout0_0) AT=3780.1n

* CHECK dout0_1 Vdout0_1ck188 = 0 time = 3780
.meas tran vdout0_1ck188 FIND v(dout0_1) AT=3780.1n

* CHECK dout0_2 Vdout0_2ck188 = 0 time = 3780
.meas tran vdout0_2ck188 FIND v(dout0_2) AT=3780.1n

* CHECK dout0_3 Vdout0_3ck188 = 1.8 time = 3780
.meas tran vdout0_3ck188 FIND v(dout0_3) AT=3780.1n

* CHECK dout0_4 Vdout0_4ck188 = 0 time = 3780
.meas tran vdout0_4ck188 FIND v(dout0_4) AT=3780.1n

* CHECK dout0_5 Vdout0_5ck188 = 0 time = 3780
.meas tran vdout0_5ck188 FIND v(dout0_5) AT=3780.1n

* CHECK dout0_6 Vdout0_6ck188 = 0 time = 3780
.meas tran vdout0_6ck188 FIND v(dout0_6) AT=3780.1n

* CHECK dout0_7 Vdout0_7ck188 = 0 time = 3780
.meas tran vdout0_7ck188 FIND v(dout0_7) AT=3780.1n

* CHECK dout0_8 Vdout0_8ck188 = 1.8 time = 3780
.meas tran vdout0_8ck188 FIND v(dout0_8) AT=3780.1n

* CHECK dout0_9 Vdout0_9ck188 = 0 time = 3780
.meas tran vdout0_9ck188 FIND v(dout0_9) AT=3780.1n

* CHECK dout0_10 Vdout0_10ck188 = 1.8 time = 3780
.meas tran vdout0_10ck188 FIND v(dout0_10) AT=3780.1n

* CHECK dout0_11 Vdout0_11ck188 = 0 time = 3780
.meas tran vdout0_11ck188 FIND v(dout0_11) AT=3780.1n

* CHECK dout0_12 Vdout0_12ck188 = 0 time = 3780
.meas tran vdout0_12ck188 FIND v(dout0_12) AT=3780.1n

* CHECK dout0_13 Vdout0_13ck188 = 0 time = 3780
.meas tran vdout0_13ck188 FIND v(dout0_13) AT=3780.1n

* CHECK dout0_14 Vdout0_14ck188 = 1.8 time = 3780
.meas tran vdout0_14ck188 FIND v(dout0_14) AT=3780.1n

* CHECK dout0_15 Vdout0_15ck188 = 0 time = 3780
.meas tran vdout0_15ck188 FIND v(dout0_15) AT=3780.1n

* CHECK dout0_0 Vdout0_0ck189 = 0 time = 3800
.meas tran vdout0_0ck189 FIND v(dout0_0) AT=3800.1n

* CHECK dout0_1 Vdout0_1ck189 = 1.8 time = 3800
.meas tran vdout0_1ck189 FIND v(dout0_1) AT=3800.1n

* CHECK dout0_2 Vdout0_2ck189 = 0 time = 3800
.meas tran vdout0_2ck189 FIND v(dout0_2) AT=3800.1n

* CHECK dout0_3 Vdout0_3ck189 = 1.8 time = 3800
.meas tran vdout0_3ck189 FIND v(dout0_3) AT=3800.1n

* CHECK dout0_4 Vdout0_4ck189 = 1.8 time = 3800
.meas tran vdout0_4ck189 FIND v(dout0_4) AT=3800.1n

* CHECK dout0_5 Vdout0_5ck189 = 1.8 time = 3800
.meas tran vdout0_5ck189 FIND v(dout0_5) AT=3800.1n

* CHECK dout0_6 Vdout0_6ck189 = 1.8 time = 3800
.meas tran vdout0_6ck189 FIND v(dout0_6) AT=3800.1n

* CHECK dout0_7 Vdout0_7ck189 = 1.8 time = 3800
.meas tran vdout0_7ck189 FIND v(dout0_7) AT=3800.1n

* CHECK dout0_8 Vdout0_8ck189 = 0 time = 3800
.meas tran vdout0_8ck189 FIND v(dout0_8) AT=3800.1n

* CHECK dout0_9 Vdout0_9ck189 = 0 time = 3800
.meas tran vdout0_9ck189 FIND v(dout0_9) AT=3800.1n

* CHECK dout0_10 Vdout0_10ck189 = 1.8 time = 3800
.meas tran vdout0_10ck189 FIND v(dout0_10) AT=3800.1n

* CHECK dout0_11 Vdout0_11ck189 = 0 time = 3800
.meas tran vdout0_11ck189 FIND v(dout0_11) AT=3800.1n

* CHECK dout0_12 Vdout0_12ck189 = 1.8 time = 3800
.meas tran vdout0_12ck189 FIND v(dout0_12) AT=3800.1n

* CHECK dout0_13 Vdout0_13ck189 = 1.8 time = 3800
.meas tran vdout0_13ck189 FIND v(dout0_13) AT=3800.1n

* CHECK dout0_14 Vdout0_14ck189 = 0 time = 3800
.meas tran vdout0_14ck189 FIND v(dout0_14) AT=3800.1n

* CHECK dout0_15 Vdout0_15ck189 = 0 time = 3800
.meas tran vdout0_15ck189 FIND v(dout0_15) AT=3800.1n

* CHECK dout0_0 Vdout0_0ck190 = 0 time = 3820
.meas tran vdout0_0ck190 FIND v(dout0_0) AT=3820.1n

* CHECK dout0_1 Vdout0_1ck190 = 0 time = 3820
.meas tran vdout0_1ck190 FIND v(dout0_1) AT=3820.1n

* CHECK dout0_2 Vdout0_2ck190 = 0 time = 3820
.meas tran vdout0_2ck190 FIND v(dout0_2) AT=3820.1n

* CHECK dout0_3 Vdout0_3ck190 = 0 time = 3820
.meas tran vdout0_3ck190 FIND v(dout0_3) AT=3820.1n

* CHECK dout0_4 Vdout0_4ck190 = 1.8 time = 3820
.meas tran vdout0_4ck190 FIND v(dout0_4) AT=3820.1n

* CHECK dout0_5 Vdout0_5ck190 = 0 time = 3820
.meas tran vdout0_5ck190 FIND v(dout0_5) AT=3820.1n

* CHECK dout0_6 Vdout0_6ck190 = 1.8 time = 3820
.meas tran vdout0_6ck190 FIND v(dout0_6) AT=3820.1n

* CHECK dout0_7 Vdout0_7ck190 = 0 time = 3820
.meas tran vdout0_7ck190 FIND v(dout0_7) AT=3820.1n

* CHECK dout0_8 Vdout0_8ck190 = 1.8 time = 3820
.meas tran vdout0_8ck190 FIND v(dout0_8) AT=3820.1n

* CHECK dout0_9 Vdout0_9ck190 = 1.8 time = 3820
.meas tran vdout0_9ck190 FIND v(dout0_9) AT=3820.1n

* CHECK dout0_10 Vdout0_10ck190 = 1.8 time = 3820
.meas tran vdout0_10ck190 FIND v(dout0_10) AT=3820.1n

* CHECK dout0_11 Vdout0_11ck190 = 0 time = 3820
.meas tran vdout0_11ck190 FIND v(dout0_11) AT=3820.1n

* CHECK dout0_12 Vdout0_12ck190 = 1.8 time = 3820
.meas tran vdout0_12ck190 FIND v(dout0_12) AT=3820.1n

* CHECK dout0_13 Vdout0_13ck190 = 0 time = 3820
.meas tran vdout0_13ck190 FIND v(dout0_13) AT=3820.1n

* CHECK dout0_14 Vdout0_14ck190 = 1.8 time = 3820
.meas tran vdout0_14ck190 FIND v(dout0_14) AT=3820.1n

* CHECK dout0_15 Vdout0_15ck190 = 1.8 time = 3820
.meas tran vdout0_15ck190 FIND v(dout0_15) AT=3820.1n

* CHECK dout0_0 Vdout0_0ck191 = 0 time = 3840
.meas tran vdout0_0ck191 FIND v(dout0_0) AT=3840.1n

* CHECK dout0_1 Vdout0_1ck191 = 1.8 time = 3840
.meas tran vdout0_1ck191 FIND v(dout0_1) AT=3840.1n

* CHECK dout0_2 Vdout0_2ck191 = 0 time = 3840
.meas tran vdout0_2ck191 FIND v(dout0_2) AT=3840.1n

* CHECK dout0_3 Vdout0_3ck191 = 1.8 time = 3840
.meas tran vdout0_3ck191 FIND v(dout0_3) AT=3840.1n

* CHECK dout0_4 Vdout0_4ck191 = 1.8 time = 3840
.meas tran vdout0_4ck191 FIND v(dout0_4) AT=3840.1n

* CHECK dout0_5 Vdout0_5ck191 = 1.8 time = 3840
.meas tran vdout0_5ck191 FIND v(dout0_5) AT=3840.1n

* CHECK dout0_6 Vdout0_6ck191 = 1.8 time = 3840
.meas tran vdout0_6ck191 FIND v(dout0_6) AT=3840.1n

* CHECK dout0_7 Vdout0_7ck191 = 1.8 time = 3840
.meas tran vdout0_7ck191 FIND v(dout0_7) AT=3840.1n

* CHECK dout0_8 Vdout0_8ck191 = 0 time = 3840
.meas tran vdout0_8ck191 FIND v(dout0_8) AT=3840.1n

* CHECK dout0_9 Vdout0_9ck191 = 0 time = 3840
.meas tran vdout0_9ck191 FIND v(dout0_9) AT=3840.1n

* CHECK dout0_10 Vdout0_10ck191 = 1.8 time = 3840
.meas tran vdout0_10ck191 FIND v(dout0_10) AT=3840.1n

* CHECK dout0_11 Vdout0_11ck191 = 0 time = 3840
.meas tran vdout0_11ck191 FIND v(dout0_11) AT=3840.1n

* CHECK dout0_12 Vdout0_12ck191 = 1.8 time = 3840
.meas tran vdout0_12ck191 FIND v(dout0_12) AT=3840.1n

* CHECK dout0_13 Vdout0_13ck191 = 1.8 time = 3840
.meas tran vdout0_13ck191 FIND v(dout0_13) AT=3840.1n

* CHECK dout0_14 Vdout0_14ck191 = 0 time = 3840
.meas tran vdout0_14ck191 FIND v(dout0_14) AT=3840.1n

* CHECK dout0_15 Vdout0_15ck191 = 0 time = 3840
.meas tran vdout0_15ck191 FIND v(dout0_15) AT=3840.1n

* CHECK dout0_0 Vdout0_0ck192 = 0 time = 3860
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=3860.1n

* CHECK dout0_1 Vdout0_1ck192 = 0 time = 3860
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=3860.1n

* CHECK dout0_2 Vdout0_2ck192 = 0 time = 3860
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=3860.1n

* CHECK dout0_3 Vdout0_3ck192 = 0 time = 3860
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=3860.1n

* CHECK dout0_4 Vdout0_4ck192 = 1.8 time = 3860
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=3860.1n

* CHECK dout0_5 Vdout0_5ck192 = 0 time = 3860
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=3860.1n

* CHECK dout0_6 Vdout0_6ck192 = 1.8 time = 3860
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=3860.1n

* CHECK dout0_7 Vdout0_7ck192 = 0 time = 3860
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=3860.1n

* CHECK dout0_8 Vdout0_8ck192 = 1.8 time = 3860
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=3860.1n

* CHECK dout0_9 Vdout0_9ck192 = 1.8 time = 3860
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=3860.1n

* CHECK dout0_10 Vdout0_10ck192 = 1.8 time = 3860
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=3860.1n

* CHECK dout0_11 Vdout0_11ck192 = 0 time = 3860
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=3860.1n

* CHECK dout0_12 Vdout0_12ck192 = 1.8 time = 3860
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=3860.1n

* CHECK dout0_13 Vdout0_13ck192 = 0 time = 3860
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=3860.1n

* CHECK dout0_14 Vdout0_14ck192 = 1.8 time = 3860
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=3860.1n

* CHECK dout0_15 Vdout0_15ck192 = 1.8 time = 3860
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=3860.1n

* CHECK dout0_0 Vdout0_0ck196 = 0 time = 3940
.meas tran vdout0_0ck196 FIND v(dout0_0) AT=3940.1n

* CHECK dout0_1 Vdout0_1ck196 = 0 time = 3940
.meas tran vdout0_1ck196 FIND v(dout0_1) AT=3940.1n

* CHECK dout0_2 Vdout0_2ck196 = 1.8 time = 3940
.meas tran vdout0_2ck196 FIND v(dout0_2) AT=3940.1n

* CHECK dout0_3 Vdout0_3ck196 = 1.8 time = 3940
.meas tran vdout0_3ck196 FIND v(dout0_3) AT=3940.1n

* CHECK dout0_4 Vdout0_4ck196 = 1.8 time = 3940
.meas tran vdout0_4ck196 FIND v(dout0_4) AT=3940.1n

* CHECK dout0_5 Vdout0_5ck196 = 1.8 time = 3940
.meas tran vdout0_5ck196 FIND v(dout0_5) AT=3940.1n

* CHECK dout0_6 Vdout0_6ck196 = 0 time = 3940
.meas tran vdout0_6ck196 FIND v(dout0_6) AT=3940.1n

* CHECK dout0_7 Vdout0_7ck196 = 1.8 time = 3940
.meas tran vdout0_7ck196 FIND v(dout0_7) AT=3940.1n

* CHECK dout0_8 Vdout0_8ck196 = 0 time = 3940
.meas tran vdout0_8ck196 FIND v(dout0_8) AT=3940.1n

* CHECK dout0_9 Vdout0_9ck196 = 0 time = 3940
.meas tran vdout0_9ck196 FIND v(dout0_9) AT=3940.1n

* CHECK dout0_10 Vdout0_10ck196 = 0 time = 3940
.meas tran vdout0_10ck196 FIND v(dout0_10) AT=3940.1n

* CHECK dout0_11 Vdout0_11ck196 = 1.8 time = 3940
.meas tran vdout0_11ck196 FIND v(dout0_11) AT=3940.1n

* CHECK dout0_12 Vdout0_12ck196 = 1.8 time = 3940
.meas tran vdout0_12ck196 FIND v(dout0_12) AT=3940.1n

* CHECK dout0_13 Vdout0_13ck196 = 1.8 time = 3940
.meas tran vdout0_13ck196 FIND v(dout0_13) AT=3940.1n

* CHECK dout0_14 Vdout0_14ck196 = 1.8 time = 3940
.meas tran vdout0_14ck196 FIND v(dout0_14) AT=3940.1n

* CHECK dout0_15 Vdout0_15ck196 = 1.8 time = 3940
.meas tran vdout0_15ck196 FIND v(dout0_15) AT=3940.1n

* CHECK dout0_0 Vdout0_0ck197 = 0 time = 3960
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=3960.1n

* CHECK dout0_1 Vdout0_1ck197 = 0 time = 3960
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=3960.1n

* CHECK dout0_2 Vdout0_2ck197 = 1.8 time = 3960
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=3960.1n

* CHECK dout0_3 Vdout0_3ck197 = 0 time = 3960
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=3960.1n

* CHECK dout0_4 Vdout0_4ck197 = 0 time = 3960
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=3960.1n

* CHECK dout0_5 Vdout0_5ck197 = 1.8 time = 3960
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=3960.1n

* CHECK dout0_6 Vdout0_6ck197 = 0 time = 3960
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=3960.1n

* CHECK dout0_7 Vdout0_7ck197 = 1.8 time = 3960
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=3960.1n

* CHECK dout0_8 Vdout0_8ck197 = 1.8 time = 3960
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=3960.1n

* CHECK dout0_9 Vdout0_9ck197 = 1.8 time = 3960
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=3960.1n

* CHECK dout0_10 Vdout0_10ck197 = 1.8 time = 3960
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=3960.1n

* CHECK dout0_11 Vdout0_11ck197 = 1.8 time = 3960
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=3960.1n

* CHECK dout0_12 Vdout0_12ck197 = 1.8 time = 3960
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=3960.1n

* CHECK dout0_13 Vdout0_13ck197 = 1.8 time = 3960
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=3960.1n

* CHECK dout0_14 Vdout0_14ck197 = 1.8 time = 3960
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=3960.1n

* CHECK dout0_15 Vdout0_15ck197 = 1.8 time = 3960
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=3960.1n

* CHECK dout0_0 Vdout0_0ck198 = 0 time = 3980
.meas tran vdout0_0ck198 FIND v(dout0_0) AT=3980.1n

* CHECK dout0_1 Vdout0_1ck198 = 1.8 time = 3980
.meas tran vdout0_1ck198 FIND v(dout0_1) AT=3980.1n

* CHECK dout0_2 Vdout0_2ck198 = 1.8 time = 3980
.meas tran vdout0_2ck198 FIND v(dout0_2) AT=3980.1n

* CHECK dout0_3 Vdout0_3ck198 = 1.8 time = 3980
.meas tran vdout0_3ck198 FIND v(dout0_3) AT=3980.1n

* CHECK dout0_4 Vdout0_4ck198 = 0 time = 3980
.meas tran vdout0_4ck198 FIND v(dout0_4) AT=3980.1n

* CHECK dout0_5 Vdout0_5ck198 = 1.8 time = 3980
.meas tran vdout0_5ck198 FIND v(dout0_5) AT=3980.1n

* CHECK dout0_6 Vdout0_6ck198 = 1.8 time = 3980
.meas tran vdout0_6ck198 FIND v(dout0_6) AT=3980.1n

* CHECK dout0_7 Vdout0_7ck198 = 1.8 time = 3980
.meas tran vdout0_7ck198 FIND v(dout0_7) AT=3980.1n

* CHECK dout0_8 Vdout0_8ck198 = 0 time = 3980
.meas tran vdout0_8ck198 FIND v(dout0_8) AT=3980.1n

* CHECK dout0_9 Vdout0_9ck198 = 0 time = 3980
.meas tran vdout0_9ck198 FIND v(dout0_9) AT=3980.1n

* CHECK dout0_10 Vdout0_10ck198 = 0 time = 3980
.meas tran vdout0_10ck198 FIND v(dout0_10) AT=3980.1n

* CHECK dout0_11 Vdout0_11ck198 = 1.8 time = 3980
.meas tran vdout0_11ck198 FIND v(dout0_11) AT=3980.1n

* CHECK dout0_12 Vdout0_12ck198 = 0 time = 3980
.meas tran vdout0_12ck198 FIND v(dout0_12) AT=3980.1n

* CHECK dout0_13 Vdout0_13ck198 = 1.8 time = 3980
.meas tran vdout0_13ck198 FIND v(dout0_13) AT=3980.1n

* CHECK dout0_14 Vdout0_14ck198 = 1.8 time = 3980
.meas tran vdout0_14ck198 FIND v(dout0_14) AT=3980.1n

* CHECK dout0_15 Vdout0_15ck198 = 1.8 time = 3980
.meas tran vdout0_15ck198 FIND v(dout0_15) AT=3980.1n

* CHECK dout0_0 Vdout0_0ck199 = 0 time = 4000
.meas tran vdout0_0ck199 FIND v(dout0_0) AT=4000.1n

* CHECK dout0_1 Vdout0_1ck199 = 0 time = 4000
.meas tran vdout0_1ck199 FIND v(dout0_1) AT=4000.1n

* CHECK dout0_2 Vdout0_2ck199 = 1.8 time = 4000
.meas tran vdout0_2ck199 FIND v(dout0_2) AT=4000.1n

* CHECK dout0_3 Vdout0_3ck199 = 0 time = 4000
.meas tran vdout0_3ck199 FIND v(dout0_3) AT=4000.1n

* CHECK dout0_4 Vdout0_4ck199 = 0 time = 4000
.meas tran vdout0_4ck199 FIND v(dout0_4) AT=4000.1n

* CHECK dout0_5 Vdout0_5ck199 = 1.8 time = 4000
.meas tran vdout0_5ck199 FIND v(dout0_5) AT=4000.1n

* CHECK dout0_6 Vdout0_6ck199 = 0 time = 4000
.meas tran vdout0_6ck199 FIND v(dout0_6) AT=4000.1n

* CHECK dout0_7 Vdout0_7ck199 = 1.8 time = 4000
.meas tran vdout0_7ck199 FIND v(dout0_7) AT=4000.1n

* CHECK dout0_8 Vdout0_8ck199 = 1.8 time = 4000
.meas tran vdout0_8ck199 FIND v(dout0_8) AT=4000.1n

* CHECK dout0_9 Vdout0_9ck199 = 1.8 time = 4000
.meas tran vdout0_9ck199 FIND v(dout0_9) AT=4000.1n

* CHECK dout0_10 Vdout0_10ck199 = 1.8 time = 4000
.meas tran vdout0_10ck199 FIND v(dout0_10) AT=4000.1n

* CHECK dout0_11 Vdout0_11ck199 = 1.8 time = 4000
.meas tran vdout0_11ck199 FIND v(dout0_11) AT=4000.1n

* CHECK dout0_12 Vdout0_12ck199 = 1.8 time = 4000
.meas tran vdout0_12ck199 FIND v(dout0_12) AT=4000.1n

* CHECK dout0_13 Vdout0_13ck199 = 1.8 time = 4000
.meas tran vdout0_13ck199 FIND v(dout0_13) AT=4000.1n

* CHECK dout0_14 Vdout0_14ck199 = 1.8 time = 4000
.meas tran vdout0_14ck199 FIND v(dout0_14) AT=4000.1n

* CHECK dout0_15 Vdout0_15ck199 = 1.8 time = 4000
.meas tran vdout0_15ck199 FIND v(dout0_15) AT=4000.1n

* CHECK dout0_0 Vdout0_0ck202 = 0 time = 4060
.meas tran vdout0_0ck202 FIND v(dout0_0) AT=4060.1n

* CHECK dout0_1 Vdout0_1ck202 = 0 time = 4060
.meas tran vdout0_1ck202 FIND v(dout0_1) AT=4060.1n

* CHECK dout0_2 Vdout0_2ck202 = 1.8 time = 4060
.meas tran vdout0_2ck202 FIND v(dout0_2) AT=4060.1n

* CHECK dout0_3 Vdout0_3ck202 = 0 time = 4060
.meas tran vdout0_3ck202 FIND v(dout0_3) AT=4060.1n

* CHECK dout0_4 Vdout0_4ck202 = 0 time = 4060
.meas tran vdout0_4ck202 FIND v(dout0_4) AT=4060.1n

* CHECK dout0_5 Vdout0_5ck202 = 1.8 time = 4060
.meas tran vdout0_5ck202 FIND v(dout0_5) AT=4060.1n

* CHECK dout0_6 Vdout0_6ck202 = 0 time = 4060
.meas tran vdout0_6ck202 FIND v(dout0_6) AT=4060.1n

* CHECK dout0_7 Vdout0_7ck202 = 1.8 time = 4060
.meas tran vdout0_7ck202 FIND v(dout0_7) AT=4060.1n

* CHECK dout0_8 Vdout0_8ck202 = 1.8 time = 4060
.meas tran vdout0_8ck202 FIND v(dout0_8) AT=4060.1n

* CHECK dout0_9 Vdout0_9ck202 = 1.8 time = 4060
.meas tran vdout0_9ck202 FIND v(dout0_9) AT=4060.1n

* CHECK dout0_10 Vdout0_10ck202 = 1.8 time = 4060
.meas tran vdout0_10ck202 FIND v(dout0_10) AT=4060.1n

* CHECK dout0_11 Vdout0_11ck202 = 1.8 time = 4060
.meas tran vdout0_11ck202 FIND v(dout0_11) AT=4060.1n

* CHECK dout0_12 Vdout0_12ck202 = 1.8 time = 4060
.meas tran vdout0_12ck202 FIND v(dout0_12) AT=4060.1n

* CHECK dout0_13 Vdout0_13ck202 = 1.8 time = 4060
.meas tran vdout0_13ck202 FIND v(dout0_13) AT=4060.1n

* CHECK dout0_14 Vdout0_14ck202 = 1.8 time = 4060
.meas tran vdout0_14ck202 FIND v(dout0_14) AT=4060.1n

* CHECK dout0_15 Vdout0_15ck202 = 1.8 time = 4060
.meas tran vdout0_15ck202 FIND v(dout0_15) AT=4060.1n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
