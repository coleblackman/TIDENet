* Functional test stimulus file for 20ns period

* TT process corner
.include "/home/mm4uz/Documents/openram/vsdsram_sky130/OpenRAM/technology/sky130A/models/tt.sp"
.include "conv2_wm_sram_16_200_sky130A.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xconv2_wm_sram_16_200_sky130A din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 vdd gnd conv2_wm_sram_16_200_sky130A

* SRAM output loads
CD00 dout0_0  0 39.2968f
CD01 dout0_1  0 39.2968f
CD02 dout0_2  0 39.2968f
CD03 dout0_3  0 39.2968f
CD04 dout0_4  0 39.2968f
CD05 dout0_5  0 39.2968f
CD06 dout0_6  0 39.2968f
CD07 dout0_7  0 39.2968f
CD08 dout0_8  0 39.2968f
CD09 dout0_9  0 39.2968f
CD010 dout0_10  0 39.2968f
CD011 dout0_11  0 39.2968f
CD012 dout0_12  0 39.2968f
CD013 dout0_13  0 39.2968f
CD014 dout0_14  0 39.2968f
CD015 dout0_15  0 39.2968f

* Important signals for debug
* bl:	xconv2_wm_sram_16_200_sky130a.xbank0.bl_0_0
* br:	xconv2_wm_sram_16_200_sky130a.xbank0.br_0_0
* s_en:	xconv2_wm_sram_16_200_sky130a.s_en
* q:	xconv2_wm_sram_16_200_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xconv2_wm_sram_16_200_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 20ns)
*	Writing 1111101100001101  to  address 00000001 (from port 0) during cycle 1 (20ns - 40ns)
*	Writing 1110110011111010  to  address 00000000 (from port 0) during cycle 2 (40ns - 60ns)
*	Writing 1111110011110000  to  address 11000110 (from port 0) during cycle 3 (60ns - 80ns)
*	Reading 1111101100001101 from address 00000001 (from port 0) during cycle 4 (80ns - 100ns)
*	Reading 1111101100001101 from address 00000001 (from port 0) during cycle 5 (100ns - 120ns)
*	Writing 0010010011101101  to  address 00000010 (from port 0) during cycle 7 (140ns - 160ns)
*	Writing 1011100101001110  to  address 00000000 (from port 0) during cycle 8 (160ns - 180ns)
*	Writing 1000001010010011  to  address 11000011 (from port 0) during cycle 9 (180ns - 200ns)
*	Reading 0010010011101101 from address 00000010 (from port 0) during cycle 10 (200ns - 220ns)
*	Reading 0010010011101101 from address 00000010 (from port 0) during cycle 11 (220ns - 240ns)
*	Reading 1000001010010011 from address 11000011 (from port 0) during cycle 12 (240ns - 260ns)
*	Writing 1111010000110010  to  address 00000010 (from port 0) during cycle 16 (320ns - 340ns)
*	Reading 1111101100001101 from address 00000001 (from port 0) during cycle 17 (340ns - 360ns)
*	Writing 1001001001010010  to  address 00000001 (from port 0) during cycle 19 (380ns - 400ns)
*	Writing 0011101110011100  to  address 11000011 (from port 0) during cycle 20 (400ns - 420ns)
*	Reading 1111110011110000 from address 11000110 (from port 0) during cycle 22 (440ns - 460ns)
*	Writing 1001111101100010  to  address 11000011 (from port 0) during cycle 24 (480ns - 500ns)
*	Reading 1111110011110000 from address 11000110 (from port 0) during cycle 25 (500ns - 520ns)
*	Reading 1011100101001110 from address 00000000 (from port 0) during cycle 26 (520ns - 540ns)
*	Writing 1000111010100100  to  address 00000001 (from port 0) during cycle 29 (580ns - 600ns)
*	Reading 1111010000110010 from address 00000010 (from port 0) during cycle 30 (600ns - 620ns)
*	Writing 0000000111100000  to  address 00000011 (from port 0) during cycle 31 (620ns - 640ns)
*	Reading 1001111101100010 from address 11000011 (from port 0) during cycle 33 (660ns - 680ns)
*	Writing 1011111101001001  to  address 11000110 (from port 0) during cycle 34 (680ns - 700ns)
*	Reading 1000111010100100 from address 00000001 (from port 0) during cycle 35 (700ns - 720ns)
*	Reading 1000111010100100 from address 00000001 (from port 0) during cycle 36 (720ns - 740ns)
*	Writing 1001111010110001  to  address 00000000 (from port 0) during cycle 37 (740ns - 760ns)
*	Writing 1011000010000010  to  address 11000110 (from port 0) during cycle 38 (760ns - 780ns)
*	Reading 1000111010100100 from address 00000001 (from port 0) during cycle 39 (780ns - 800ns)
*	Writing 0000001100100101  to  address 11000011 (from port 0) during cycle 40 (800ns - 820ns)
*	Reading 1000111010100100 from address 00000001 (from port 0) during cycle 41 (820ns - 840ns)
*	Reading 0000000111100000 from address 00000011 (from port 0) during cycle 42 (840ns - 860ns)
*	Writing 1001100100010101  to  address 11000101 (from port 0) during cycle 43 (860ns - 880ns)
*	Reading 0000001100100101 from address 11000011 (from port 0) during cycle 44 (880ns - 900ns)
*	Writing 1000001100101000  to  address 00000000 (from port 0) during cycle 45 (900ns - 920ns)
*	Reading 1111010000110010 from address 00000010 (from port 0) during cycle 47 (940ns - 960ns)
*	Reading 0000001100100101 from address 11000011 (from port 0) during cycle 48 (960ns - 980ns)
*	Writing 1110101101100011  to  address 00000010 (from port 0) during cycle 49 (980ns - 1000ns)
*	Reading 1110101101100011 from address 00000010 (from port 0) during cycle 50 (1000ns - 1020ns)
*	Reading 1000111010100100 from address 00000001 (from port 0) during cycle 51 (1020ns - 1040ns)
*	Writing 0010101101011110  to  address 00000000 (from port 0) during cycle 52 (1040ns - 1060ns)
*	Reading 0000000111100000 from address 00000011 (from port 0) during cycle 53 (1060ns - 1080ns)
*	Reading 1000111010100100 from address 00000001 (from port 0) during cycle 54 (1080ns - 1100ns)
*	Reading 1000111010100100 from address 00000001 (from port 0) during cycle 58 (1160ns - 1180ns)
*	Writing 1111010010110010  to  address 00000001 (from port 0) during cycle 59 (1180ns - 1200ns)
*	Reading 1110101101100011 from address 00000010 (from port 0) during cycle 60 (1200ns - 1220ns)
*	Reading 0000001100100101 from address 11000011 (from port 0) during cycle 61 (1220ns - 1240ns)
*	Reading 1111010010110010 from address 00000001 (from port 0) during cycle 62 (1240ns - 1260ns)
*	Reading 1011000010000010 from address 11000110 (from port 0) during cycle 63 (1260ns - 1280ns)
*	Writing 1110111011011011  to  address 00000000 (from port 0) during cycle 64 (1280ns - 1300ns)
*	Reading 1110111011011011 from address 00000000 (from port 0) during cycle 66 (1320ns - 1340ns)
*	Reading 1001100100010101 from address 11000101 (from port 0) during cycle 67 (1340ns - 1360ns)
*	Writing 1011000001011100  to  address 11000100 (from port 0) during cycle 68 (1360ns - 1380ns)
*	Reading 0000001100100101 from address 11000011 (from port 0) during cycle 71 (1420ns - 1440ns)
*	Reading 0000000111100000 from address 00000011 (from port 0) during cycle 72 (1440ns - 1460ns)
*	Writing 1001101001110011  to  address 11000110 (from port 0) during cycle 73 (1460ns - 1480ns)
*	Reading 0000000111100000 from address 00000011 (from port 0) during cycle 75 (1500ns - 1520ns)
*	Writing 1101001111011001  to  address 00000010 (from port 0) during cycle 78 (1560ns - 1580ns)
*	Writing 1111000101001110  to  address 11000100 (from port 0) during cycle 79 (1580ns - 1600ns)
*	Reading 1111000101001110 from address 11000100 (from port 0) during cycle 80 (1600ns - 1620ns)
*	Reading 0000000111100000 from address 00000011 (from port 0) during cycle 81 (1620ns - 1640ns)
*	Writing 0001100001111100  to  address 00000001 (from port 0) during cycle 82 (1640ns - 1660ns)
*	Reading 0000000111100000 from address 00000011 (from port 0) during cycle 87 (1740ns - 1760ns)
*	Reading 0000001100100101 from address 11000011 (from port 0) during cycle 88 (1760ns - 1780ns)
*	Reading 1111000101001110 from address 11000100 (from port 0) during cycle 89 (1780ns - 1800ns)
*	Reading 1111000101001110 from address 11000100 (from port 0) during cycle 91 (1820ns - 1840ns)
*	Reading 1101001111011001 from address 00000010 (from port 0) during cycle 92 (1840ns - 1860ns)
*	Reading 1111000101001110 from address 11000100 (from port 0) during cycle 93 (1860ns - 1880ns)
*	Reading 1111000101001110 from address 11000100 (from port 0) during cycle 94 (1880ns - 1900ns)
*	Writing 0010010010011110  to  address 00000001 (from port 0) during cycle 95 (1900ns - 1920ns)
*	Reading 1111000101001110 from address 11000100 (from port 0) during cycle 96 (1920ns - 1940ns)
*	Reading 1110111011011011 from address 00000000 (from port 0) during cycle 97 (1940ns - 1960ns)
*	Reading 0010010010011110 from address 00000001 (from port 0) during cycle 98 (1960ns - 1980ns)
*	Reading 0010010010011110 from address 00000001 (from port 0) during cycle 99 (1980ns - 2000ns)
*	Reading 0010010010011110 from address 00000001 (from port 0) during cycle 100 (2000ns - 2020ns)
*	Writing 0100011110001100  to  address 11000110 (from port 0) during cycle 101 (2020ns - 2040ns)
*	Reading 1001100100010101 from address 11000101 (from port 0) during cycle 103 (2060ns - 2080ns)
*	Reading 1111000101001110 from address 11000100 (from port 0) during cycle 104 (2080ns - 2100ns)
*	Reading 0010010010011110 from address 00000001 (from port 0) during cycle 105 (2100ns - 2120ns)
*	Reading 1001100100010101 from address 11000101 (from port 0) during cycle 106 (2120ns - 2140ns)
*	Reading 1110111011011011 from address 00000000 (from port 0) during cycle 107 (2140ns - 2160ns)
*	Reading 0010010010011110 from address 00000001 (from port 0) during cycle 108 (2160ns - 2180ns)
*	Reading 1110111011011011 from address 00000000 (from port 0) during cycle 110 (2200ns - 2220ns)
*	Reading 1101001111011001 from address 00000010 (from port 0) during cycle 112 (2240ns - 2260ns)
*	Reading 1101001111011001 from address 00000010 (from port 0) during cycle 114 (2280ns - 2300ns)
*	Writing 1001010111101000  to  address 00000010 (from port 0) during cycle 115 (2300ns - 2320ns)
*	Reading 0100011110001100 from address 11000110 (from port 0) during cycle 116 (2320ns - 2340ns)
*	Reading 0010010010011110 from address 00000001 (from port 0) during cycle 117 (2340ns - 2360ns)
*	Reading 0000000111100000 from address 00000011 (from port 0) during cycle 118 (2360ns - 2380ns)
*	Reading 1110111011011011 from address 00000000 (from port 0) during cycle 119 (2380ns - 2400ns)
*	Writing 0001011000010000  to  address 00000001 (from port 0) during cycle 121 (2420ns - 2440ns)
*	Reading 1001010111101000 from address 00000010 (from port 0) during cycle 122 (2440ns - 2460ns)
*	Reading 0000001100100101 from address 11000011 (from port 0) during cycle 123 (2460ns - 2480ns)
*	Reading 0001011000010000 from address 00000001 (from port 0) during cycle 124 (2480ns - 2500ns)
*	Reading 1001100100010101 from address 11000101 (from port 0) during cycle 126 (2520ns - 2540ns)
*	Writing 0011110100000111  to  address 11000011 (from port 0) during cycle 127 (2540ns - 2560ns)
*	Writing 1001101111100010  to  address 00000000 (from port 0) during cycle 128 (2560ns - 2580ns)
*	Writing 0110000100001011  to  address 00000011 (from port 0) during cycle 129 (2580ns - 2600ns)
*	Writing 1001100000000010  to  address 00000011 (from port 0) during cycle 130 (2600ns - 2620ns)
*	Reading 0100011110001100 from address 11000110 (from port 0) during cycle 131 (2620ns - 2640ns)
*	Writing 1001101111100110  to  address 00000000 (from port 0) during cycle 132 (2640ns - 2660ns)
*	Reading 1111000101001110 from address 11000100 (from port 0) during cycle 133 (2660ns - 2680ns)
*	Writing 0000111010011010  to  address 00000011 (from port 0) during cycle 134 (2680ns - 2700ns)
*	Reading 0100011110001100 from address 11000110 (from port 0) during cycle 136 (2720ns - 2740ns)
*	Reading 0001011000010000 from address 00000001 (from port 0) during cycle 139 (2780ns - 2800ns)
*	Reading 1111000101001110 from address 11000100 (from port 0) during cycle 141 (2820ns - 2840ns)
*	Reading 1001101111100110 from address 00000000 (from port 0) during cycle 142 (2840ns - 2860ns)
*	Reading 1111000101001110 from address 11000100 (from port 0) during cycle 144 (2880ns - 2900ns)
*	Writing 0100100101110110  to  address 00000011 (from port 0) during cycle 145 (2900ns - 2920ns)
*	Writing 0111110010111010  to  address 00000000 (from port 0) during cycle 147 (2940ns - 2960ns)
*	Writing 0111010000110101  to  address 00000001 (from port 0) during cycle 148 (2960ns - 2980ns)
*	Writing 1101101011000101  to  address 00000001 (from port 0) during cycle 149 (2980ns - 3000ns)
*	Writing 1110100010010100  to  address 11000101 (from port 0) during cycle 151 (3020ns - 3040ns)
*	Writing 1100010011111101  to  address 11000011 (from port 0) during cycle 152 (3040ns - 3060ns)
*	Reading 1100010011111101 from address 11000011 (from port 0) during cycle 155 (3100ns - 3120ns)
*	Reading 0111110010111010 from address 00000000 (from port 0) during cycle 156 (3120ns - 3140ns)
*	Reading 0100100101110110 from address 00000011 (from port 0) during cycle 157 (3140ns - 3160ns)
*	Reading 0111110010111010 from address 00000000 (from port 0) during cycle 158 (3160ns - 3180ns)
*	Reading 0100100101110110 from address 00000011 (from port 0) during cycle 159 (3180ns - 3200ns)
*	Writing 1011000011000010  to  address 00000011 (from port 0) during cycle 160 (3200ns - 3220ns)
*	Reading 1101101011000101 from address 00000001 (from port 0) during cycle 161 (3220ns - 3240ns)
*	Writing 0011110101100010  to  address 11000110 (from port 0) during cycle 162 (3240ns - 3260ns)
*	Writing 1010111000010111  to  address 00000000 (from port 0) during cycle 163 (3260ns - 3280ns)
*	Writing 0101110001111111  to  address 11000011 (from port 0) during cycle 164 (3280ns - 3300ns)
*	Reading 1011000011000010 from address 00000011 (from port 0) during cycle 165 (3300ns - 3320ns)
*	Reading 0011110101100010 from address 11000110 (from port 0) during cycle 166 (3320ns - 3340ns)
*	Reading 1001010111101000 from address 00000010 (from port 0) during cycle 167 (3340ns - 3360ns)
*	Reading 0101110001111111 from address 11000011 (from port 0) during cycle 168 (3360ns - 3380ns)
*	Reading 1010111000010111 from address 00000000 (from port 0) during cycle 169 (3380ns - 3400ns)
*	Reading 1001010111101000 from address 00000010 (from port 0) during cycle 170 (3400ns - 3420ns)
*	Writing 0001000100001101  to  address 00000000 (from port 0) during cycle 171 (3420ns - 3440ns)
*	Writing 0100101010101100  to  address 11000110 (from port 0) during cycle 172 (3440ns - 3460ns)
*	Reading 0001000100001101 from address 00000000 (from port 0) during cycle 173 (3460ns - 3480ns)
*	Reading 1101101011000101 from address 00000001 (from port 0) during cycle 174 (3480ns - 3500ns)
*	Writing 1100110000001111  to  address 00000001 (from port 0) during cycle 175 (3500ns - 3520ns)
*	Reading 0101110001111111 from address 11000011 (from port 0) during cycle 176 (3520ns - 3540ns)
*	Reading 0001000100001101 from address 00000000 (from port 0) during cycle 177 (3540ns - 3560ns)
*	Reading 1110100010010100 from address 11000101 (from port 0) during cycle 180 (3600ns - 3620ns)
*	Reading 0001000100001101 from address 00000000 (from port 0) during cycle 181 (3620ns - 3640ns)
*	Reading 1110100010010100 from address 11000101 (from port 0) during cycle 183 (3660ns - 3680ns)
*	Writing 0110101110010001  to  address 00000010 (from port 0) during cycle 184 (3680ns - 3700ns)
*	Writing 0100101001100000  to  address 00000001 (from port 0) during cycle 185 (3700ns - 3720ns)
*	Reading 1110100010010100 from address 11000101 (from port 0) during cycle 187 (3740ns - 3760ns)
*	Writing 0101100101110101  to  address 11000100 (from port 0) during cycle 188 (3760ns - 3780ns)
*	Reading 1011000011000010 from address 00000011 (from port 0) during cycle 189 (3780ns - 3800ns)
*	Reading 0001000100001101 from address 00000000 (from port 0) during cycle 190 (3800ns - 3820ns)
*	Reading 0110101110010001 from address 00000010 (from port 0) during cycle 192 (3840ns - 3860ns)
*	Writing 0011010100101010  to  address 11000100 (from port 0) during cycle 193 (3860ns - 3880ns)
*	Reading 0101110001111111 from address 11000011 (from port 0) during cycle 194 (3880ns - 3900ns)
*	Reading 0100101001100000 from address 00000001 (from port 0) during cycle 195 (3900ns - 3920ns)
*	Reading 1110100010010100 from address 11000101 (from port 0) during cycle 197 (3940ns - 3960ns)
*	Reading 0011010100101010 from address 11000100 (from port 0) during cycle 199 (3980ns - 4000ns)
*	Writing 1011101011001010  to  address 00000011 (from port 0) during cycle 200 (4000ns - 4020ns)
*	Reading 0110101110010001 from address 00000010 (from port 0) during cycle 203 (4060ns - 4080ns)
*	Writing 1101010011011011  to  address 00000011 (from port 0) during cycle 204 (4080ns - 4100ns)
*	Idle during cycle 205 (4100ns - 4120ns)

* Generation of data and address signals
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 1), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 1), (720, 1), (740, 1), (760, 0), (780, 0), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 1), (2980, 1), (3000, 1), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 1), (780, 1), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 1), (600, 1), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 0), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 1), (720, 1), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 1), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 0), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 0), (2920, 0), (2940, 1), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 0), (700, 0), (720, 0), (740, 1), (760, 0), (780, 0), (800, 1), (820, 1), (840, 1), (860, 0), (880, 0), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 1), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 1), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 1), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 0), (700, 0), (720, 0), (740, 1), (760, 1), (780, 1), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 1), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 0), (2920, 0), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 0), (760, 0), (780, 0), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 1), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 0), (640, 0), (660, 0), (680, 1), (700, 1), (720, 1), (740, 1), (760, 0), (780, 0), (800, 1), (820, 1), (840, 1), (860, 0), (880, 0), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 1), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 0), (640, 0), (660, 0), (680, 1), (700, 1), (720, 1), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 0), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 0), (640, 0), (660, 0), (680, 1), (700, 1), (720, 1), (740, 1), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 1), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 0), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 1), (720, 1), (740, 0), (760, 1), (780, 1), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 0), (640, 0), (660, 0), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 0), (820, 0), (840, 0), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 1), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 1), (100, 1), (120, 1), (140, 0), (160, 0), (180, 1), (200, 0), (220, 0), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 0), (480, 1), (500, 0), (520, 0), (540, 0), (560, 0), (580, 1), (600, 0), (620, 1), (640, 1), (660, 1), (680, 0), (700, 1), (720, 1), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 1), (980, 0), (1000, 0), (1020, 1), (1040, 0), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 1), (2080, 0), (2100, 1), (2120, 1), (2140, 0), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 1), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 0), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 1), (3160, 0), (3180, 1), (3200, 1), (3220, 1), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 0), (3340, 0), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 1), (3620, 0), (3640, 0), (3660, 1), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 1), (4100, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 0), (100, 0), (120, 0), (140, 1), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 0), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 0), (720, 0), (740, 0), (760, 1), (780, 0), (800, 1), (820, 0), (840, 1), (860, 0), (880, 1), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 0), (1040, 0), (1060, 1), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 0), (1620, 1), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 1), (1760, 1), (1780, 0), (1800, 0), (1820, 0), (1840, 1), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 1), (2380, 0), (2400, 0), (2420, 0), (2440, 1), (2460, 1), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 0), (2580, 1), (2600, 1), (2620, 1), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 1), (3160, 0), (3180, 1), (3200, 1), (3220, 0), (3240, 1), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 1), (3420, 0), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 0), (3820, 0), (3840, 1), (3860, 0), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 0), (500, 1), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 0), (720, 0), (740, 0), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 0), (1860, 1), (1880, 1), (1900, 0), (1920, 1), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 0), (2120, 1), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 1), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 0), (2860, 0), (2880, 1), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 1), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 1), (3260, 0), (3280, 0), (3300, 0), (3320, 1), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 1), (3620, 0), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 0), (220, 0), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 0), (720, 0), (740, 0), (760, 1), (780, 0), (800, 1), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 1), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 1), (1240, 0), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 0), (1860, 1), (1880, 1), (1900, 0), (1920, 1), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 0), (2120, 1), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 1), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 0), (2860, 0), (2880, 1), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 1), (3260, 0), (3280, 1), (3300, 0), (3320, 1), (3340, 0), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 1), (3620, 0), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 0), (220, 0), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 1), (680, 1), (700, 0), (720, 0), (740, 0), (760, 1), (780, 0), (800, 1), (820, 0), (840, 0), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 1), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 1), (1240, 0), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 0), (1860, 1), (1880, 1), (1900, 0), (1920, 1), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 0), (2120, 1), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 1), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 0), (2860, 0), (2880, 1), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 1), (3260, 0), (3280, 1), (3300, 0), (3320, 1), (3340, 0), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 1), (3620, 0), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 1), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 1), (380, 0), (400, 0), (420, 1), (440, 0), (460, 1), (480, 0), (500, 0), (520, 0), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 1), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 1), (1500, 0), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 1), (2240, 0), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 0), (2740, 1), (2760, 1), (2780, 0), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 0), (2900, 0), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 1), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 0), (3620, 0), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 1), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 1), (3940, 0), (3960, 1), (3980, 0), (4000, 0), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 1.8v 138.95n 1.8v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 1.8v )
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 1), (100, 1), (120, 1), (140, 0), (160, 0), (180, 0), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 1), (360, 1), (380, 0), (400, 0), (420, 1), (440, 1), (460, 1), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 0), (600, 1), (620, 0), (640, 1), (660, 1), (680, 0), (700, 1), (720, 1), (740, 0), (760, 0), (780, 1), (800, 0), (820, 1), (840, 1), (860, 0), (880, 1), (900, 0), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 1), (1020, 1), (1040, 0), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 0), (1300, 1), (1320, 1), (1340, 1), (1360, 0), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 0), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 1), (1620, 1), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 1), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 0), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 1), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 1), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 1), (4040, 1), (4060, 1), (4080, 0), (4100, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 0.0v 638.95n 0.0v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 1.8v )
* PULSE: period=20
Vclk0 clk0 0 PULSE (0 1.8 19.95n 0.1n 0.1n 9.899999999999999n 20n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 1.8 time = 100
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=100.1n

* CHECK dout0_1 Vdout0_1ck4 = 0 time = 100
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=100.1n

* CHECK dout0_2 Vdout0_2ck4 = 1.8 time = 100
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=100.1n

* CHECK dout0_3 Vdout0_3ck4 = 1.8 time = 100
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=100.1n

* CHECK dout0_4 Vdout0_4ck4 = 0 time = 100
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=100.1n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 100
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=100.1n

* CHECK dout0_6 Vdout0_6ck4 = 0 time = 100
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=100.1n

* CHECK dout0_7 Vdout0_7ck4 = 0 time = 100
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=100.1n

* CHECK dout0_8 Vdout0_8ck4 = 1.8 time = 100
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=100.1n

* CHECK dout0_9 Vdout0_9ck4 = 1.8 time = 100
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=100.1n

* CHECK dout0_10 Vdout0_10ck4 = 0 time = 100
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=100.1n

* CHECK dout0_11 Vdout0_11ck4 = 1.8 time = 100
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=100.1n

* CHECK dout0_12 Vdout0_12ck4 = 1.8 time = 100
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=100.1n

* CHECK dout0_13 Vdout0_13ck4 = 1.8 time = 100
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=100.1n

* CHECK dout0_14 Vdout0_14ck4 = 1.8 time = 100
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=100.1n

* CHECK dout0_15 Vdout0_15ck4 = 1.8 time = 100
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=100.1n

* CHECK dout0_0 Vdout0_0ck5 = 1.8 time = 120
.meas tran vdout0_0ck5 FIND v(dout0_0) AT=120.1n

* CHECK dout0_1 Vdout0_1ck5 = 0 time = 120
.meas tran vdout0_1ck5 FIND v(dout0_1) AT=120.1n

* CHECK dout0_2 Vdout0_2ck5 = 1.8 time = 120
.meas tran vdout0_2ck5 FIND v(dout0_2) AT=120.1n

* CHECK dout0_3 Vdout0_3ck5 = 1.8 time = 120
.meas tran vdout0_3ck5 FIND v(dout0_3) AT=120.1n

* CHECK dout0_4 Vdout0_4ck5 = 0 time = 120
.meas tran vdout0_4ck5 FIND v(dout0_4) AT=120.1n

* CHECK dout0_5 Vdout0_5ck5 = 0 time = 120
.meas tran vdout0_5ck5 FIND v(dout0_5) AT=120.1n

* CHECK dout0_6 Vdout0_6ck5 = 0 time = 120
.meas tran vdout0_6ck5 FIND v(dout0_6) AT=120.1n

* CHECK dout0_7 Vdout0_7ck5 = 0 time = 120
.meas tran vdout0_7ck5 FIND v(dout0_7) AT=120.1n

* CHECK dout0_8 Vdout0_8ck5 = 1.8 time = 120
.meas tran vdout0_8ck5 FIND v(dout0_8) AT=120.1n

* CHECK dout0_9 Vdout0_9ck5 = 1.8 time = 120
.meas tran vdout0_9ck5 FIND v(dout0_9) AT=120.1n

* CHECK dout0_10 Vdout0_10ck5 = 0 time = 120
.meas tran vdout0_10ck5 FIND v(dout0_10) AT=120.1n

* CHECK dout0_11 Vdout0_11ck5 = 1.8 time = 120
.meas tran vdout0_11ck5 FIND v(dout0_11) AT=120.1n

* CHECK dout0_12 Vdout0_12ck5 = 1.8 time = 120
.meas tran vdout0_12ck5 FIND v(dout0_12) AT=120.1n

* CHECK dout0_13 Vdout0_13ck5 = 1.8 time = 120
.meas tran vdout0_13ck5 FIND v(dout0_13) AT=120.1n

* CHECK dout0_14 Vdout0_14ck5 = 1.8 time = 120
.meas tran vdout0_14ck5 FIND v(dout0_14) AT=120.1n

* CHECK dout0_15 Vdout0_15ck5 = 1.8 time = 120
.meas tran vdout0_15ck5 FIND v(dout0_15) AT=120.1n

* CHECK dout0_0 Vdout0_0ck10 = 1.8 time = 220
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=220.1n

* CHECK dout0_1 Vdout0_1ck10 = 0 time = 220
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=220.1n

* CHECK dout0_2 Vdout0_2ck10 = 1.8 time = 220
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=220.1n

* CHECK dout0_3 Vdout0_3ck10 = 1.8 time = 220
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=220.1n

* CHECK dout0_4 Vdout0_4ck10 = 0 time = 220
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=220.1n

* CHECK dout0_5 Vdout0_5ck10 = 1.8 time = 220
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=220.1n

* CHECK dout0_6 Vdout0_6ck10 = 1.8 time = 220
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=220.1n

* CHECK dout0_7 Vdout0_7ck10 = 1.8 time = 220
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=220.1n

* CHECK dout0_8 Vdout0_8ck10 = 0 time = 220
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=220.1n

* CHECK dout0_9 Vdout0_9ck10 = 0 time = 220
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=220.1n

* CHECK dout0_10 Vdout0_10ck10 = 1.8 time = 220
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=220.1n

* CHECK dout0_11 Vdout0_11ck10 = 0 time = 220
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=220.1n

* CHECK dout0_12 Vdout0_12ck10 = 0 time = 220
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=220.1n

* CHECK dout0_13 Vdout0_13ck10 = 1.8 time = 220
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=220.1n

* CHECK dout0_14 Vdout0_14ck10 = 0 time = 220
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=220.1n

* CHECK dout0_15 Vdout0_15ck10 = 0 time = 220
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=220.1n

* CHECK dout0_0 Vdout0_0ck11 = 1.8 time = 240
.meas tran vdout0_0ck11 FIND v(dout0_0) AT=240.1n

* CHECK dout0_1 Vdout0_1ck11 = 0 time = 240
.meas tran vdout0_1ck11 FIND v(dout0_1) AT=240.1n

* CHECK dout0_2 Vdout0_2ck11 = 1.8 time = 240
.meas tran vdout0_2ck11 FIND v(dout0_2) AT=240.1n

* CHECK dout0_3 Vdout0_3ck11 = 1.8 time = 240
.meas tran vdout0_3ck11 FIND v(dout0_3) AT=240.1n

* CHECK dout0_4 Vdout0_4ck11 = 0 time = 240
.meas tran vdout0_4ck11 FIND v(dout0_4) AT=240.1n

* CHECK dout0_5 Vdout0_5ck11 = 1.8 time = 240
.meas tran vdout0_5ck11 FIND v(dout0_5) AT=240.1n

* CHECK dout0_6 Vdout0_6ck11 = 1.8 time = 240
.meas tran vdout0_6ck11 FIND v(dout0_6) AT=240.1n

* CHECK dout0_7 Vdout0_7ck11 = 1.8 time = 240
.meas tran vdout0_7ck11 FIND v(dout0_7) AT=240.1n

* CHECK dout0_8 Vdout0_8ck11 = 0 time = 240
.meas tran vdout0_8ck11 FIND v(dout0_8) AT=240.1n

* CHECK dout0_9 Vdout0_9ck11 = 0 time = 240
.meas tran vdout0_9ck11 FIND v(dout0_9) AT=240.1n

* CHECK dout0_10 Vdout0_10ck11 = 1.8 time = 240
.meas tran vdout0_10ck11 FIND v(dout0_10) AT=240.1n

* CHECK dout0_11 Vdout0_11ck11 = 0 time = 240
.meas tran vdout0_11ck11 FIND v(dout0_11) AT=240.1n

* CHECK dout0_12 Vdout0_12ck11 = 0 time = 240
.meas tran vdout0_12ck11 FIND v(dout0_12) AT=240.1n

* CHECK dout0_13 Vdout0_13ck11 = 1.8 time = 240
.meas tran vdout0_13ck11 FIND v(dout0_13) AT=240.1n

* CHECK dout0_14 Vdout0_14ck11 = 0 time = 240
.meas tran vdout0_14ck11 FIND v(dout0_14) AT=240.1n

* CHECK dout0_15 Vdout0_15ck11 = 0 time = 240
.meas tran vdout0_15ck11 FIND v(dout0_15) AT=240.1n

* CHECK dout0_0 Vdout0_0ck12 = 1.8 time = 260
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=260.1n

* CHECK dout0_1 Vdout0_1ck12 = 1.8 time = 260
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=260.1n

* CHECK dout0_2 Vdout0_2ck12 = 0 time = 260
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=260.1n

* CHECK dout0_3 Vdout0_3ck12 = 0 time = 260
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=260.1n

* CHECK dout0_4 Vdout0_4ck12 = 1.8 time = 260
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=260.1n

* CHECK dout0_5 Vdout0_5ck12 = 0 time = 260
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=260.1n

* CHECK dout0_6 Vdout0_6ck12 = 0 time = 260
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=260.1n

* CHECK dout0_7 Vdout0_7ck12 = 1.8 time = 260
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=260.1n

* CHECK dout0_8 Vdout0_8ck12 = 0 time = 260
.meas tran vdout0_8ck12 FIND v(dout0_8) AT=260.1n

* CHECK dout0_9 Vdout0_9ck12 = 1.8 time = 260
.meas tran vdout0_9ck12 FIND v(dout0_9) AT=260.1n

* CHECK dout0_10 Vdout0_10ck12 = 0 time = 260
.meas tran vdout0_10ck12 FIND v(dout0_10) AT=260.1n

* CHECK dout0_11 Vdout0_11ck12 = 0 time = 260
.meas tran vdout0_11ck12 FIND v(dout0_11) AT=260.1n

* CHECK dout0_12 Vdout0_12ck12 = 0 time = 260
.meas tran vdout0_12ck12 FIND v(dout0_12) AT=260.1n

* CHECK dout0_13 Vdout0_13ck12 = 0 time = 260
.meas tran vdout0_13ck12 FIND v(dout0_13) AT=260.1n

* CHECK dout0_14 Vdout0_14ck12 = 0 time = 260
.meas tran vdout0_14ck12 FIND v(dout0_14) AT=260.1n

* CHECK dout0_15 Vdout0_15ck12 = 1.8 time = 260
.meas tran vdout0_15ck12 FIND v(dout0_15) AT=260.1n

* CHECK dout0_0 Vdout0_0ck17 = 1.8 time = 360
.meas tran vdout0_0ck17 FIND v(dout0_0) AT=360.1n

* CHECK dout0_1 Vdout0_1ck17 = 0 time = 360
.meas tran vdout0_1ck17 FIND v(dout0_1) AT=360.1n

* CHECK dout0_2 Vdout0_2ck17 = 1.8 time = 360
.meas tran vdout0_2ck17 FIND v(dout0_2) AT=360.1n

* CHECK dout0_3 Vdout0_3ck17 = 1.8 time = 360
.meas tran vdout0_3ck17 FIND v(dout0_3) AT=360.1n

* CHECK dout0_4 Vdout0_4ck17 = 0 time = 360
.meas tran vdout0_4ck17 FIND v(dout0_4) AT=360.1n

* CHECK dout0_5 Vdout0_5ck17 = 0 time = 360
.meas tran vdout0_5ck17 FIND v(dout0_5) AT=360.1n

* CHECK dout0_6 Vdout0_6ck17 = 0 time = 360
.meas tran vdout0_6ck17 FIND v(dout0_6) AT=360.1n

* CHECK dout0_7 Vdout0_7ck17 = 0 time = 360
.meas tran vdout0_7ck17 FIND v(dout0_7) AT=360.1n

* CHECK dout0_8 Vdout0_8ck17 = 1.8 time = 360
.meas tran vdout0_8ck17 FIND v(dout0_8) AT=360.1n

* CHECK dout0_9 Vdout0_9ck17 = 1.8 time = 360
.meas tran vdout0_9ck17 FIND v(dout0_9) AT=360.1n

* CHECK dout0_10 Vdout0_10ck17 = 0 time = 360
.meas tran vdout0_10ck17 FIND v(dout0_10) AT=360.1n

* CHECK dout0_11 Vdout0_11ck17 = 1.8 time = 360
.meas tran vdout0_11ck17 FIND v(dout0_11) AT=360.1n

* CHECK dout0_12 Vdout0_12ck17 = 1.8 time = 360
.meas tran vdout0_12ck17 FIND v(dout0_12) AT=360.1n

* CHECK dout0_13 Vdout0_13ck17 = 1.8 time = 360
.meas tran vdout0_13ck17 FIND v(dout0_13) AT=360.1n

* CHECK dout0_14 Vdout0_14ck17 = 1.8 time = 360
.meas tran vdout0_14ck17 FIND v(dout0_14) AT=360.1n

* CHECK dout0_15 Vdout0_15ck17 = 1.8 time = 360
.meas tran vdout0_15ck17 FIND v(dout0_15) AT=360.1n

* CHECK dout0_0 Vdout0_0ck22 = 0 time = 460
.meas tran vdout0_0ck22 FIND v(dout0_0) AT=460.1n

* CHECK dout0_1 Vdout0_1ck22 = 0 time = 460
.meas tran vdout0_1ck22 FIND v(dout0_1) AT=460.1n

* CHECK dout0_2 Vdout0_2ck22 = 0 time = 460
.meas tran vdout0_2ck22 FIND v(dout0_2) AT=460.1n

* CHECK dout0_3 Vdout0_3ck22 = 0 time = 460
.meas tran vdout0_3ck22 FIND v(dout0_3) AT=460.1n

* CHECK dout0_4 Vdout0_4ck22 = 1.8 time = 460
.meas tran vdout0_4ck22 FIND v(dout0_4) AT=460.1n

* CHECK dout0_5 Vdout0_5ck22 = 1.8 time = 460
.meas tran vdout0_5ck22 FIND v(dout0_5) AT=460.1n

* CHECK dout0_6 Vdout0_6ck22 = 1.8 time = 460
.meas tran vdout0_6ck22 FIND v(dout0_6) AT=460.1n

* CHECK dout0_7 Vdout0_7ck22 = 1.8 time = 460
.meas tran vdout0_7ck22 FIND v(dout0_7) AT=460.1n

* CHECK dout0_8 Vdout0_8ck22 = 0 time = 460
.meas tran vdout0_8ck22 FIND v(dout0_8) AT=460.1n

* CHECK dout0_9 Vdout0_9ck22 = 0 time = 460
.meas tran vdout0_9ck22 FIND v(dout0_9) AT=460.1n

* CHECK dout0_10 Vdout0_10ck22 = 1.8 time = 460
.meas tran vdout0_10ck22 FIND v(dout0_10) AT=460.1n

* CHECK dout0_11 Vdout0_11ck22 = 1.8 time = 460
.meas tran vdout0_11ck22 FIND v(dout0_11) AT=460.1n

* CHECK dout0_12 Vdout0_12ck22 = 1.8 time = 460
.meas tran vdout0_12ck22 FIND v(dout0_12) AT=460.1n

* CHECK dout0_13 Vdout0_13ck22 = 1.8 time = 460
.meas tran vdout0_13ck22 FIND v(dout0_13) AT=460.1n

* CHECK dout0_14 Vdout0_14ck22 = 1.8 time = 460
.meas tran vdout0_14ck22 FIND v(dout0_14) AT=460.1n

* CHECK dout0_15 Vdout0_15ck22 = 1.8 time = 460
.meas tran vdout0_15ck22 FIND v(dout0_15) AT=460.1n

* CHECK dout0_0 Vdout0_0ck25 = 0 time = 520
.meas tran vdout0_0ck25 FIND v(dout0_0) AT=520.1n

* CHECK dout0_1 Vdout0_1ck25 = 0 time = 520
.meas tran vdout0_1ck25 FIND v(dout0_1) AT=520.1n

* CHECK dout0_2 Vdout0_2ck25 = 0 time = 520
.meas tran vdout0_2ck25 FIND v(dout0_2) AT=520.1n

* CHECK dout0_3 Vdout0_3ck25 = 0 time = 520
.meas tran vdout0_3ck25 FIND v(dout0_3) AT=520.1n

* CHECK dout0_4 Vdout0_4ck25 = 1.8 time = 520
.meas tran vdout0_4ck25 FIND v(dout0_4) AT=520.1n

* CHECK dout0_5 Vdout0_5ck25 = 1.8 time = 520
.meas tran vdout0_5ck25 FIND v(dout0_5) AT=520.1n

* CHECK dout0_6 Vdout0_6ck25 = 1.8 time = 520
.meas tran vdout0_6ck25 FIND v(dout0_6) AT=520.1n

* CHECK dout0_7 Vdout0_7ck25 = 1.8 time = 520
.meas tran vdout0_7ck25 FIND v(dout0_7) AT=520.1n

* CHECK dout0_8 Vdout0_8ck25 = 0 time = 520
.meas tran vdout0_8ck25 FIND v(dout0_8) AT=520.1n

* CHECK dout0_9 Vdout0_9ck25 = 0 time = 520
.meas tran vdout0_9ck25 FIND v(dout0_9) AT=520.1n

* CHECK dout0_10 Vdout0_10ck25 = 1.8 time = 520
.meas tran vdout0_10ck25 FIND v(dout0_10) AT=520.1n

* CHECK dout0_11 Vdout0_11ck25 = 1.8 time = 520
.meas tran vdout0_11ck25 FIND v(dout0_11) AT=520.1n

* CHECK dout0_12 Vdout0_12ck25 = 1.8 time = 520
.meas tran vdout0_12ck25 FIND v(dout0_12) AT=520.1n

* CHECK dout0_13 Vdout0_13ck25 = 1.8 time = 520
.meas tran vdout0_13ck25 FIND v(dout0_13) AT=520.1n

* CHECK dout0_14 Vdout0_14ck25 = 1.8 time = 520
.meas tran vdout0_14ck25 FIND v(dout0_14) AT=520.1n

* CHECK dout0_15 Vdout0_15ck25 = 1.8 time = 520
.meas tran vdout0_15ck25 FIND v(dout0_15) AT=520.1n

* CHECK dout0_0 Vdout0_0ck26 = 0 time = 540
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=540.1n

* CHECK dout0_1 Vdout0_1ck26 = 1.8 time = 540
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=540.1n

* CHECK dout0_2 Vdout0_2ck26 = 1.8 time = 540
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=540.1n

* CHECK dout0_3 Vdout0_3ck26 = 1.8 time = 540
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=540.1n

* CHECK dout0_4 Vdout0_4ck26 = 0 time = 540
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=540.1n

* CHECK dout0_5 Vdout0_5ck26 = 0 time = 540
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=540.1n

* CHECK dout0_6 Vdout0_6ck26 = 1.8 time = 540
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=540.1n

* CHECK dout0_7 Vdout0_7ck26 = 0 time = 540
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=540.1n

* CHECK dout0_8 Vdout0_8ck26 = 1.8 time = 540
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=540.1n

* CHECK dout0_9 Vdout0_9ck26 = 0 time = 540
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=540.1n

* CHECK dout0_10 Vdout0_10ck26 = 0 time = 540
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=540.1n

* CHECK dout0_11 Vdout0_11ck26 = 1.8 time = 540
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=540.1n

* CHECK dout0_12 Vdout0_12ck26 = 1.8 time = 540
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=540.1n

* CHECK dout0_13 Vdout0_13ck26 = 1.8 time = 540
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=540.1n

* CHECK dout0_14 Vdout0_14ck26 = 0 time = 540
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=540.1n

* CHECK dout0_15 Vdout0_15ck26 = 1.8 time = 540
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=540.1n

* CHECK dout0_0 Vdout0_0ck30 = 0 time = 620
.meas tran vdout0_0ck30 FIND v(dout0_0) AT=620.1n

* CHECK dout0_1 Vdout0_1ck30 = 1.8 time = 620
.meas tran vdout0_1ck30 FIND v(dout0_1) AT=620.1n

* CHECK dout0_2 Vdout0_2ck30 = 0 time = 620
.meas tran vdout0_2ck30 FIND v(dout0_2) AT=620.1n

* CHECK dout0_3 Vdout0_3ck30 = 0 time = 620
.meas tran vdout0_3ck30 FIND v(dout0_3) AT=620.1n

* CHECK dout0_4 Vdout0_4ck30 = 1.8 time = 620
.meas tran vdout0_4ck30 FIND v(dout0_4) AT=620.1n

* CHECK dout0_5 Vdout0_5ck30 = 1.8 time = 620
.meas tran vdout0_5ck30 FIND v(dout0_5) AT=620.1n

* CHECK dout0_6 Vdout0_6ck30 = 0 time = 620
.meas tran vdout0_6ck30 FIND v(dout0_6) AT=620.1n

* CHECK dout0_7 Vdout0_7ck30 = 0 time = 620
.meas tran vdout0_7ck30 FIND v(dout0_7) AT=620.1n

* CHECK dout0_8 Vdout0_8ck30 = 0 time = 620
.meas tran vdout0_8ck30 FIND v(dout0_8) AT=620.1n

* CHECK dout0_9 Vdout0_9ck30 = 0 time = 620
.meas tran vdout0_9ck30 FIND v(dout0_9) AT=620.1n

* CHECK dout0_10 Vdout0_10ck30 = 1.8 time = 620
.meas tran vdout0_10ck30 FIND v(dout0_10) AT=620.1n

* CHECK dout0_11 Vdout0_11ck30 = 0 time = 620
.meas tran vdout0_11ck30 FIND v(dout0_11) AT=620.1n

* CHECK dout0_12 Vdout0_12ck30 = 1.8 time = 620
.meas tran vdout0_12ck30 FIND v(dout0_12) AT=620.1n

* CHECK dout0_13 Vdout0_13ck30 = 1.8 time = 620
.meas tran vdout0_13ck30 FIND v(dout0_13) AT=620.1n

* CHECK dout0_14 Vdout0_14ck30 = 1.8 time = 620
.meas tran vdout0_14ck30 FIND v(dout0_14) AT=620.1n

* CHECK dout0_15 Vdout0_15ck30 = 1.8 time = 620
.meas tran vdout0_15ck30 FIND v(dout0_15) AT=620.1n

* CHECK dout0_0 Vdout0_0ck33 = 0 time = 680
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=680.1n

* CHECK dout0_1 Vdout0_1ck33 = 1.8 time = 680
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=680.1n

* CHECK dout0_2 Vdout0_2ck33 = 0 time = 680
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=680.1n

* CHECK dout0_3 Vdout0_3ck33 = 0 time = 680
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=680.1n

* CHECK dout0_4 Vdout0_4ck33 = 0 time = 680
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=680.1n

* CHECK dout0_5 Vdout0_5ck33 = 1.8 time = 680
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=680.1n

* CHECK dout0_6 Vdout0_6ck33 = 1.8 time = 680
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=680.1n

* CHECK dout0_7 Vdout0_7ck33 = 0 time = 680
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=680.1n

* CHECK dout0_8 Vdout0_8ck33 = 1.8 time = 680
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=680.1n

* CHECK dout0_9 Vdout0_9ck33 = 1.8 time = 680
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=680.1n

* CHECK dout0_10 Vdout0_10ck33 = 1.8 time = 680
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=680.1n

* CHECK dout0_11 Vdout0_11ck33 = 1.8 time = 680
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=680.1n

* CHECK dout0_12 Vdout0_12ck33 = 1.8 time = 680
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=680.1n

* CHECK dout0_13 Vdout0_13ck33 = 0 time = 680
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=680.1n

* CHECK dout0_14 Vdout0_14ck33 = 0 time = 680
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=680.1n

* CHECK dout0_15 Vdout0_15ck33 = 1.8 time = 680
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=680.1n

* CHECK dout0_0 Vdout0_0ck35 = 0 time = 720
.meas tran vdout0_0ck35 FIND v(dout0_0) AT=720.1n

* CHECK dout0_1 Vdout0_1ck35 = 0 time = 720
.meas tran vdout0_1ck35 FIND v(dout0_1) AT=720.1n

* CHECK dout0_2 Vdout0_2ck35 = 1.8 time = 720
.meas tran vdout0_2ck35 FIND v(dout0_2) AT=720.1n

* CHECK dout0_3 Vdout0_3ck35 = 0 time = 720
.meas tran vdout0_3ck35 FIND v(dout0_3) AT=720.1n

* CHECK dout0_4 Vdout0_4ck35 = 0 time = 720
.meas tran vdout0_4ck35 FIND v(dout0_4) AT=720.1n

* CHECK dout0_5 Vdout0_5ck35 = 1.8 time = 720
.meas tran vdout0_5ck35 FIND v(dout0_5) AT=720.1n

* CHECK dout0_6 Vdout0_6ck35 = 0 time = 720
.meas tran vdout0_6ck35 FIND v(dout0_6) AT=720.1n

* CHECK dout0_7 Vdout0_7ck35 = 1.8 time = 720
.meas tran vdout0_7ck35 FIND v(dout0_7) AT=720.1n

* CHECK dout0_8 Vdout0_8ck35 = 0 time = 720
.meas tran vdout0_8ck35 FIND v(dout0_8) AT=720.1n

* CHECK dout0_9 Vdout0_9ck35 = 1.8 time = 720
.meas tran vdout0_9ck35 FIND v(dout0_9) AT=720.1n

* CHECK dout0_10 Vdout0_10ck35 = 1.8 time = 720
.meas tran vdout0_10ck35 FIND v(dout0_10) AT=720.1n

* CHECK dout0_11 Vdout0_11ck35 = 1.8 time = 720
.meas tran vdout0_11ck35 FIND v(dout0_11) AT=720.1n

* CHECK dout0_12 Vdout0_12ck35 = 0 time = 720
.meas tran vdout0_12ck35 FIND v(dout0_12) AT=720.1n

* CHECK dout0_13 Vdout0_13ck35 = 0 time = 720
.meas tran vdout0_13ck35 FIND v(dout0_13) AT=720.1n

* CHECK dout0_14 Vdout0_14ck35 = 0 time = 720
.meas tran vdout0_14ck35 FIND v(dout0_14) AT=720.1n

* CHECK dout0_15 Vdout0_15ck35 = 1.8 time = 720
.meas tran vdout0_15ck35 FIND v(dout0_15) AT=720.1n

* CHECK dout0_0 Vdout0_0ck36 = 0 time = 740
.meas tran vdout0_0ck36 FIND v(dout0_0) AT=740.1n

* CHECK dout0_1 Vdout0_1ck36 = 0 time = 740
.meas tran vdout0_1ck36 FIND v(dout0_1) AT=740.1n

* CHECK dout0_2 Vdout0_2ck36 = 1.8 time = 740
.meas tran vdout0_2ck36 FIND v(dout0_2) AT=740.1n

* CHECK dout0_3 Vdout0_3ck36 = 0 time = 740
.meas tran vdout0_3ck36 FIND v(dout0_3) AT=740.1n

* CHECK dout0_4 Vdout0_4ck36 = 0 time = 740
.meas tran vdout0_4ck36 FIND v(dout0_4) AT=740.1n

* CHECK dout0_5 Vdout0_5ck36 = 1.8 time = 740
.meas tran vdout0_5ck36 FIND v(dout0_5) AT=740.1n

* CHECK dout0_6 Vdout0_6ck36 = 0 time = 740
.meas tran vdout0_6ck36 FIND v(dout0_6) AT=740.1n

* CHECK dout0_7 Vdout0_7ck36 = 1.8 time = 740
.meas tran vdout0_7ck36 FIND v(dout0_7) AT=740.1n

* CHECK dout0_8 Vdout0_8ck36 = 0 time = 740
.meas tran vdout0_8ck36 FIND v(dout0_8) AT=740.1n

* CHECK dout0_9 Vdout0_9ck36 = 1.8 time = 740
.meas tran vdout0_9ck36 FIND v(dout0_9) AT=740.1n

* CHECK dout0_10 Vdout0_10ck36 = 1.8 time = 740
.meas tran vdout0_10ck36 FIND v(dout0_10) AT=740.1n

* CHECK dout0_11 Vdout0_11ck36 = 1.8 time = 740
.meas tran vdout0_11ck36 FIND v(dout0_11) AT=740.1n

* CHECK dout0_12 Vdout0_12ck36 = 0 time = 740
.meas tran vdout0_12ck36 FIND v(dout0_12) AT=740.1n

* CHECK dout0_13 Vdout0_13ck36 = 0 time = 740
.meas tran vdout0_13ck36 FIND v(dout0_13) AT=740.1n

* CHECK dout0_14 Vdout0_14ck36 = 0 time = 740
.meas tran vdout0_14ck36 FIND v(dout0_14) AT=740.1n

* CHECK dout0_15 Vdout0_15ck36 = 1.8 time = 740
.meas tran vdout0_15ck36 FIND v(dout0_15) AT=740.1n

* CHECK dout0_0 Vdout0_0ck39 = 0 time = 800
.meas tran vdout0_0ck39 FIND v(dout0_0) AT=800.1n

* CHECK dout0_1 Vdout0_1ck39 = 0 time = 800
.meas tran vdout0_1ck39 FIND v(dout0_1) AT=800.1n

* CHECK dout0_2 Vdout0_2ck39 = 1.8 time = 800
.meas tran vdout0_2ck39 FIND v(dout0_2) AT=800.1n

* CHECK dout0_3 Vdout0_3ck39 = 0 time = 800
.meas tran vdout0_3ck39 FIND v(dout0_3) AT=800.1n

* CHECK dout0_4 Vdout0_4ck39 = 0 time = 800
.meas tran vdout0_4ck39 FIND v(dout0_4) AT=800.1n

* CHECK dout0_5 Vdout0_5ck39 = 1.8 time = 800
.meas tran vdout0_5ck39 FIND v(dout0_5) AT=800.1n

* CHECK dout0_6 Vdout0_6ck39 = 0 time = 800
.meas tran vdout0_6ck39 FIND v(dout0_6) AT=800.1n

* CHECK dout0_7 Vdout0_7ck39 = 1.8 time = 800
.meas tran vdout0_7ck39 FIND v(dout0_7) AT=800.1n

* CHECK dout0_8 Vdout0_8ck39 = 0 time = 800
.meas tran vdout0_8ck39 FIND v(dout0_8) AT=800.1n

* CHECK dout0_9 Vdout0_9ck39 = 1.8 time = 800
.meas tran vdout0_9ck39 FIND v(dout0_9) AT=800.1n

* CHECK dout0_10 Vdout0_10ck39 = 1.8 time = 800
.meas tran vdout0_10ck39 FIND v(dout0_10) AT=800.1n

* CHECK dout0_11 Vdout0_11ck39 = 1.8 time = 800
.meas tran vdout0_11ck39 FIND v(dout0_11) AT=800.1n

* CHECK dout0_12 Vdout0_12ck39 = 0 time = 800
.meas tran vdout0_12ck39 FIND v(dout0_12) AT=800.1n

* CHECK dout0_13 Vdout0_13ck39 = 0 time = 800
.meas tran vdout0_13ck39 FIND v(dout0_13) AT=800.1n

* CHECK dout0_14 Vdout0_14ck39 = 0 time = 800
.meas tran vdout0_14ck39 FIND v(dout0_14) AT=800.1n

* CHECK dout0_15 Vdout0_15ck39 = 1.8 time = 800
.meas tran vdout0_15ck39 FIND v(dout0_15) AT=800.1n

* CHECK dout0_0 Vdout0_0ck41 = 0 time = 840
.meas tran vdout0_0ck41 FIND v(dout0_0) AT=840.1n

* CHECK dout0_1 Vdout0_1ck41 = 0 time = 840
.meas tran vdout0_1ck41 FIND v(dout0_1) AT=840.1n

* CHECK dout0_2 Vdout0_2ck41 = 1.8 time = 840
.meas tran vdout0_2ck41 FIND v(dout0_2) AT=840.1n

* CHECK dout0_3 Vdout0_3ck41 = 0 time = 840
.meas tran vdout0_3ck41 FIND v(dout0_3) AT=840.1n

* CHECK dout0_4 Vdout0_4ck41 = 0 time = 840
.meas tran vdout0_4ck41 FIND v(dout0_4) AT=840.1n

* CHECK dout0_5 Vdout0_5ck41 = 1.8 time = 840
.meas tran vdout0_5ck41 FIND v(dout0_5) AT=840.1n

* CHECK dout0_6 Vdout0_6ck41 = 0 time = 840
.meas tran vdout0_6ck41 FIND v(dout0_6) AT=840.1n

* CHECK dout0_7 Vdout0_7ck41 = 1.8 time = 840
.meas tran vdout0_7ck41 FIND v(dout0_7) AT=840.1n

* CHECK dout0_8 Vdout0_8ck41 = 0 time = 840
.meas tran vdout0_8ck41 FIND v(dout0_8) AT=840.1n

* CHECK dout0_9 Vdout0_9ck41 = 1.8 time = 840
.meas tran vdout0_9ck41 FIND v(dout0_9) AT=840.1n

* CHECK dout0_10 Vdout0_10ck41 = 1.8 time = 840
.meas tran vdout0_10ck41 FIND v(dout0_10) AT=840.1n

* CHECK dout0_11 Vdout0_11ck41 = 1.8 time = 840
.meas tran vdout0_11ck41 FIND v(dout0_11) AT=840.1n

* CHECK dout0_12 Vdout0_12ck41 = 0 time = 840
.meas tran vdout0_12ck41 FIND v(dout0_12) AT=840.1n

* CHECK dout0_13 Vdout0_13ck41 = 0 time = 840
.meas tran vdout0_13ck41 FIND v(dout0_13) AT=840.1n

* CHECK dout0_14 Vdout0_14ck41 = 0 time = 840
.meas tran vdout0_14ck41 FIND v(dout0_14) AT=840.1n

* CHECK dout0_15 Vdout0_15ck41 = 1.8 time = 840
.meas tran vdout0_15ck41 FIND v(dout0_15) AT=840.1n

* CHECK dout0_0 Vdout0_0ck42 = 0 time = 860
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=860.1n

* CHECK dout0_1 Vdout0_1ck42 = 0 time = 860
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=860.1n

* CHECK dout0_2 Vdout0_2ck42 = 0 time = 860
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=860.1n

* CHECK dout0_3 Vdout0_3ck42 = 0 time = 860
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=860.1n

* CHECK dout0_4 Vdout0_4ck42 = 0 time = 860
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=860.1n

* CHECK dout0_5 Vdout0_5ck42 = 1.8 time = 860
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=860.1n

* CHECK dout0_6 Vdout0_6ck42 = 1.8 time = 860
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=860.1n

* CHECK dout0_7 Vdout0_7ck42 = 1.8 time = 860
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=860.1n

* CHECK dout0_8 Vdout0_8ck42 = 1.8 time = 860
.meas tran vdout0_8ck42 FIND v(dout0_8) AT=860.1n

* CHECK dout0_9 Vdout0_9ck42 = 0 time = 860
.meas tran vdout0_9ck42 FIND v(dout0_9) AT=860.1n

* CHECK dout0_10 Vdout0_10ck42 = 0 time = 860
.meas tran vdout0_10ck42 FIND v(dout0_10) AT=860.1n

* CHECK dout0_11 Vdout0_11ck42 = 0 time = 860
.meas tran vdout0_11ck42 FIND v(dout0_11) AT=860.1n

* CHECK dout0_12 Vdout0_12ck42 = 0 time = 860
.meas tran vdout0_12ck42 FIND v(dout0_12) AT=860.1n

* CHECK dout0_13 Vdout0_13ck42 = 0 time = 860
.meas tran vdout0_13ck42 FIND v(dout0_13) AT=860.1n

* CHECK dout0_14 Vdout0_14ck42 = 0 time = 860
.meas tran vdout0_14ck42 FIND v(dout0_14) AT=860.1n

* CHECK dout0_15 Vdout0_15ck42 = 0 time = 860
.meas tran vdout0_15ck42 FIND v(dout0_15) AT=860.1n

* CHECK dout0_0 Vdout0_0ck44 = 1.8 time = 900
.meas tran vdout0_0ck44 FIND v(dout0_0) AT=900.1n

* CHECK dout0_1 Vdout0_1ck44 = 0 time = 900
.meas tran vdout0_1ck44 FIND v(dout0_1) AT=900.1n

* CHECK dout0_2 Vdout0_2ck44 = 1.8 time = 900
.meas tran vdout0_2ck44 FIND v(dout0_2) AT=900.1n

* CHECK dout0_3 Vdout0_3ck44 = 0 time = 900
.meas tran vdout0_3ck44 FIND v(dout0_3) AT=900.1n

* CHECK dout0_4 Vdout0_4ck44 = 0 time = 900
.meas tran vdout0_4ck44 FIND v(dout0_4) AT=900.1n

* CHECK dout0_5 Vdout0_5ck44 = 1.8 time = 900
.meas tran vdout0_5ck44 FIND v(dout0_5) AT=900.1n

* CHECK dout0_6 Vdout0_6ck44 = 0 time = 900
.meas tran vdout0_6ck44 FIND v(dout0_6) AT=900.1n

* CHECK dout0_7 Vdout0_7ck44 = 0 time = 900
.meas tran vdout0_7ck44 FIND v(dout0_7) AT=900.1n

* CHECK dout0_8 Vdout0_8ck44 = 1.8 time = 900
.meas tran vdout0_8ck44 FIND v(dout0_8) AT=900.1n

* CHECK dout0_9 Vdout0_9ck44 = 1.8 time = 900
.meas tran vdout0_9ck44 FIND v(dout0_9) AT=900.1n

* CHECK dout0_10 Vdout0_10ck44 = 0 time = 900
.meas tran vdout0_10ck44 FIND v(dout0_10) AT=900.1n

* CHECK dout0_11 Vdout0_11ck44 = 0 time = 900
.meas tran vdout0_11ck44 FIND v(dout0_11) AT=900.1n

* CHECK dout0_12 Vdout0_12ck44 = 0 time = 900
.meas tran vdout0_12ck44 FIND v(dout0_12) AT=900.1n

* CHECK dout0_13 Vdout0_13ck44 = 0 time = 900
.meas tran vdout0_13ck44 FIND v(dout0_13) AT=900.1n

* CHECK dout0_14 Vdout0_14ck44 = 0 time = 900
.meas tran vdout0_14ck44 FIND v(dout0_14) AT=900.1n

* CHECK dout0_15 Vdout0_15ck44 = 0 time = 900
.meas tran vdout0_15ck44 FIND v(dout0_15) AT=900.1n

* CHECK dout0_0 Vdout0_0ck47 = 0 time = 960
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=960.1n

* CHECK dout0_1 Vdout0_1ck47 = 1.8 time = 960
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=960.1n

* CHECK dout0_2 Vdout0_2ck47 = 0 time = 960
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=960.1n

* CHECK dout0_3 Vdout0_3ck47 = 0 time = 960
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=960.1n

* CHECK dout0_4 Vdout0_4ck47 = 1.8 time = 960
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=960.1n

* CHECK dout0_5 Vdout0_5ck47 = 1.8 time = 960
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=960.1n

* CHECK dout0_6 Vdout0_6ck47 = 0 time = 960
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=960.1n

* CHECK dout0_7 Vdout0_7ck47 = 0 time = 960
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=960.1n

* CHECK dout0_8 Vdout0_8ck47 = 0 time = 960
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=960.1n

* CHECK dout0_9 Vdout0_9ck47 = 0 time = 960
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=960.1n

* CHECK dout0_10 Vdout0_10ck47 = 1.8 time = 960
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=960.1n

* CHECK dout0_11 Vdout0_11ck47 = 0 time = 960
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=960.1n

* CHECK dout0_12 Vdout0_12ck47 = 1.8 time = 960
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=960.1n

* CHECK dout0_13 Vdout0_13ck47 = 1.8 time = 960
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=960.1n

* CHECK dout0_14 Vdout0_14ck47 = 1.8 time = 960
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=960.1n

* CHECK dout0_15 Vdout0_15ck47 = 1.8 time = 960
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=960.1n

* CHECK dout0_0 Vdout0_0ck48 = 1.8 time = 980
.meas tran vdout0_0ck48 FIND v(dout0_0) AT=980.1n

* CHECK dout0_1 Vdout0_1ck48 = 0 time = 980
.meas tran vdout0_1ck48 FIND v(dout0_1) AT=980.1n

* CHECK dout0_2 Vdout0_2ck48 = 1.8 time = 980
.meas tran vdout0_2ck48 FIND v(dout0_2) AT=980.1n

* CHECK dout0_3 Vdout0_3ck48 = 0 time = 980
.meas tran vdout0_3ck48 FIND v(dout0_3) AT=980.1n

* CHECK dout0_4 Vdout0_4ck48 = 0 time = 980
.meas tran vdout0_4ck48 FIND v(dout0_4) AT=980.1n

* CHECK dout0_5 Vdout0_5ck48 = 1.8 time = 980
.meas tran vdout0_5ck48 FIND v(dout0_5) AT=980.1n

* CHECK dout0_6 Vdout0_6ck48 = 0 time = 980
.meas tran vdout0_6ck48 FIND v(dout0_6) AT=980.1n

* CHECK dout0_7 Vdout0_7ck48 = 0 time = 980
.meas tran vdout0_7ck48 FIND v(dout0_7) AT=980.1n

* CHECK dout0_8 Vdout0_8ck48 = 1.8 time = 980
.meas tran vdout0_8ck48 FIND v(dout0_8) AT=980.1n

* CHECK dout0_9 Vdout0_9ck48 = 1.8 time = 980
.meas tran vdout0_9ck48 FIND v(dout0_9) AT=980.1n

* CHECK dout0_10 Vdout0_10ck48 = 0 time = 980
.meas tran vdout0_10ck48 FIND v(dout0_10) AT=980.1n

* CHECK dout0_11 Vdout0_11ck48 = 0 time = 980
.meas tran vdout0_11ck48 FIND v(dout0_11) AT=980.1n

* CHECK dout0_12 Vdout0_12ck48 = 0 time = 980
.meas tran vdout0_12ck48 FIND v(dout0_12) AT=980.1n

* CHECK dout0_13 Vdout0_13ck48 = 0 time = 980
.meas tran vdout0_13ck48 FIND v(dout0_13) AT=980.1n

* CHECK dout0_14 Vdout0_14ck48 = 0 time = 980
.meas tran vdout0_14ck48 FIND v(dout0_14) AT=980.1n

* CHECK dout0_15 Vdout0_15ck48 = 0 time = 980
.meas tran vdout0_15ck48 FIND v(dout0_15) AT=980.1n

* CHECK dout0_0 Vdout0_0ck50 = 1.8 time = 1020
.meas tran vdout0_0ck50 FIND v(dout0_0) AT=1020.1n

* CHECK dout0_1 Vdout0_1ck50 = 1.8 time = 1020
.meas tran vdout0_1ck50 FIND v(dout0_1) AT=1020.1n

* CHECK dout0_2 Vdout0_2ck50 = 0 time = 1020
.meas tran vdout0_2ck50 FIND v(dout0_2) AT=1020.1n

* CHECK dout0_3 Vdout0_3ck50 = 0 time = 1020
.meas tran vdout0_3ck50 FIND v(dout0_3) AT=1020.1n

* CHECK dout0_4 Vdout0_4ck50 = 0 time = 1020
.meas tran vdout0_4ck50 FIND v(dout0_4) AT=1020.1n

* CHECK dout0_5 Vdout0_5ck50 = 1.8 time = 1020
.meas tran vdout0_5ck50 FIND v(dout0_5) AT=1020.1n

* CHECK dout0_6 Vdout0_6ck50 = 1.8 time = 1020
.meas tran vdout0_6ck50 FIND v(dout0_6) AT=1020.1n

* CHECK dout0_7 Vdout0_7ck50 = 0 time = 1020
.meas tran vdout0_7ck50 FIND v(dout0_7) AT=1020.1n

* CHECK dout0_8 Vdout0_8ck50 = 1.8 time = 1020
.meas tran vdout0_8ck50 FIND v(dout0_8) AT=1020.1n

* CHECK dout0_9 Vdout0_9ck50 = 1.8 time = 1020
.meas tran vdout0_9ck50 FIND v(dout0_9) AT=1020.1n

* CHECK dout0_10 Vdout0_10ck50 = 0 time = 1020
.meas tran vdout0_10ck50 FIND v(dout0_10) AT=1020.1n

* CHECK dout0_11 Vdout0_11ck50 = 1.8 time = 1020
.meas tran vdout0_11ck50 FIND v(dout0_11) AT=1020.1n

* CHECK dout0_12 Vdout0_12ck50 = 0 time = 1020
.meas tran vdout0_12ck50 FIND v(dout0_12) AT=1020.1n

* CHECK dout0_13 Vdout0_13ck50 = 1.8 time = 1020
.meas tran vdout0_13ck50 FIND v(dout0_13) AT=1020.1n

* CHECK dout0_14 Vdout0_14ck50 = 1.8 time = 1020
.meas tran vdout0_14ck50 FIND v(dout0_14) AT=1020.1n

* CHECK dout0_15 Vdout0_15ck50 = 1.8 time = 1020
.meas tran vdout0_15ck50 FIND v(dout0_15) AT=1020.1n

* CHECK dout0_0 Vdout0_0ck51 = 0 time = 1040
.meas tran vdout0_0ck51 FIND v(dout0_0) AT=1040.1n

* CHECK dout0_1 Vdout0_1ck51 = 0 time = 1040
.meas tran vdout0_1ck51 FIND v(dout0_1) AT=1040.1n

* CHECK dout0_2 Vdout0_2ck51 = 1.8 time = 1040
.meas tran vdout0_2ck51 FIND v(dout0_2) AT=1040.1n

* CHECK dout0_3 Vdout0_3ck51 = 0 time = 1040
.meas tran vdout0_3ck51 FIND v(dout0_3) AT=1040.1n

* CHECK dout0_4 Vdout0_4ck51 = 0 time = 1040
.meas tran vdout0_4ck51 FIND v(dout0_4) AT=1040.1n

* CHECK dout0_5 Vdout0_5ck51 = 1.8 time = 1040
.meas tran vdout0_5ck51 FIND v(dout0_5) AT=1040.1n

* CHECK dout0_6 Vdout0_6ck51 = 0 time = 1040
.meas tran vdout0_6ck51 FIND v(dout0_6) AT=1040.1n

* CHECK dout0_7 Vdout0_7ck51 = 1.8 time = 1040
.meas tran vdout0_7ck51 FIND v(dout0_7) AT=1040.1n

* CHECK dout0_8 Vdout0_8ck51 = 0 time = 1040
.meas tran vdout0_8ck51 FIND v(dout0_8) AT=1040.1n

* CHECK dout0_9 Vdout0_9ck51 = 1.8 time = 1040
.meas tran vdout0_9ck51 FIND v(dout0_9) AT=1040.1n

* CHECK dout0_10 Vdout0_10ck51 = 1.8 time = 1040
.meas tran vdout0_10ck51 FIND v(dout0_10) AT=1040.1n

* CHECK dout0_11 Vdout0_11ck51 = 1.8 time = 1040
.meas tran vdout0_11ck51 FIND v(dout0_11) AT=1040.1n

* CHECK dout0_12 Vdout0_12ck51 = 0 time = 1040
.meas tran vdout0_12ck51 FIND v(dout0_12) AT=1040.1n

* CHECK dout0_13 Vdout0_13ck51 = 0 time = 1040
.meas tran vdout0_13ck51 FIND v(dout0_13) AT=1040.1n

* CHECK dout0_14 Vdout0_14ck51 = 0 time = 1040
.meas tran vdout0_14ck51 FIND v(dout0_14) AT=1040.1n

* CHECK dout0_15 Vdout0_15ck51 = 1.8 time = 1040
.meas tran vdout0_15ck51 FIND v(dout0_15) AT=1040.1n

* CHECK dout0_0 Vdout0_0ck53 = 0 time = 1080
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=1080.1n

* CHECK dout0_1 Vdout0_1ck53 = 0 time = 1080
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=1080.1n

* CHECK dout0_2 Vdout0_2ck53 = 0 time = 1080
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=1080.1n

* CHECK dout0_3 Vdout0_3ck53 = 0 time = 1080
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=1080.1n

* CHECK dout0_4 Vdout0_4ck53 = 0 time = 1080
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=1080.1n

* CHECK dout0_5 Vdout0_5ck53 = 1.8 time = 1080
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=1080.1n

* CHECK dout0_6 Vdout0_6ck53 = 1.8 time = 1080
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=1080.1n

* CHECK dout0_7 Vdout0_7ck53 = 1.8 time = 1080
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=1080.1n

* CHECK dout0_8 Vdout0_8ck53 = 1.8 time = 1080
.meas tran vdout0_8ck53 FIND v(dout0_8) AT=1080.1n

* CHECK dout0_9 Vdout0_9ck53 = 0 time = 1080
.meas tran vdout0_9ck53 FIND v(dout0_9) AT=1080.1n

* CHECK dout0_10 Vdout0_10ck53 = 0 time = 1080
.meas tran vdout0_10ck53 FIND v(dout0_10) AT=1080.1n

* CHECK dout0_11 Vdout0_11ck53 = 0 time = 1080
.meas tran vdout0_11ck53 FIND v(dout0_11) AT=1080.1n

* CHECK dout0_12 Vdout0_12ck53 = 0 time = 1080
.meas tran vdout0_12ck53 FIND v(dout0_12) AT=1080.1n

* CHECK dout0_13 Vdout0_13ck53 = 0 time = 1080
.meas tran vdout0_13ck53 FIND v(dout0_13) AT=1080.1n

* CHECK dout0_14 Vdout0_14ck53 = 0 time = 1080
.meas tran vdout0_14ck53 FIND v(dout0_14) AT=1080.1n

* CHECK dout0_15 Vdout0_15ck53 = 0 time = 1080
.meas tran vdout0_15ck53 FIND v(dout0_15) AT=1080.1n

* CHECK dout0_0 Vdout0_0ck54 = 0 time = 1100
.meas tran vdout0_0ck54 FIND v(dout0_0) AT=1100.1n

* CHECK dout0_1 Vdout0_1ck54 = 0 time = 1100
.meas tran vdout0_1ck54 FIND v(dout0_1) AT=1100.1n

* CHECK dout0_2 Vdout0_2ck54 = 1.8 time = 1100
.meas tran vdout0_2ck54 FIND v(dout0_2) AT=1100.1n

* CHECK dout0_3 Vdout0_3ck54 = 0 time = 1100
.meas tran vdout0_3ck54 FIND v(dout0_3) AT=1100.1n

* CHECK dout0_4 Vdout0_4ck54 = 0 time = 1100
.meas tran vdout0_4ck54 FIND v(dout0_4) AT=1100.1n

* CHECK dout0_5 Vdout0_5ck54 = 1.8 time = 1100
.meas tran vdout0_5ck54 FIND v(dout0_5) AT=1100.1n

* CHECK dout0_6 Vdout0_6ck54 = 0 time = 1100
.meas tran vdout0_6ck54 FIND v(dout0_6) AT=1100.1n

* CHECK dout0_7 Vdout0_7ck54 = 1.8 time = 1100
.meas tran vdout0_7ck54 FIND v(dout0_7) AT=1100.1n

* CHECK dout0_8 Vdout0_8ck54 = 0 time = 1100
.meas tran vdout0_8ck54 FIND v(dout0_8) AT=1100.1n

* CHECK dout0_9 Vdout0_9ck54 = 1.8 time = 1100
.meas tran vdout0_9ck54 FIND v(dout0_9) AT=1100.1n

* CHECK dout0_10 Vdout0_10ck54 = 1.8 time = 1100
.meas tran vdout0_10ck54 FIND v(dout0_10) AT=1100.1n

* CHECK dout0_11 Vdout0_11ck54 = 1.8 time = 1100
.meas tran vdout0_11ck54 FIND v(dout0_11) AT=1100.1n

* CHECK dout0_12 Vdout0_12ck54 = 0 time = 1100
.meas tran vdout0_12ck54 FIND v(dout0_12) AT=1100.1n

* CHECK dout0_13 Vdout0_13ck54 = 0 time = 1100
.meas tran vdout0_13ck54 FIND v(dout0_13) AT=1100.1n

* CHECK dout0_14 Vdout0_14ck54 = 0 time = 1100
.meas tran vdout0_14ck54 FIND v(dout0_14) AT=1100.1n

* CHECK dout0_15 Vdout0_15ck54 = 1.8 time = 1100
.meas tran vdout0_15ck54 FIND v(dout0_15) AT=1100.1n

* CHECK dout0_0 Vdout0_0ck58 = 0 time = 1180
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=1180.1n

* CHECK dout0_1 Vdout0_1ck58 = 0 time = 1180
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=1180.1n

* CHECK dout0_2 Vdout0_2ck58 = 1.8 time = 1180
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=1180.1n

* CHECK dout0_3 Vdout0_3ck58 = 0 time = 1180
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=1180.1n

* CHECK dout0_4 Vdout0_4ck58 = 0 time = 1180
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=1180.1n

* CHECK dout0_5 Vdout0_5ck58 = 1.8 time = 1180
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=1180.1n

* CHECK dout0_6 Vdout0_6ck58 = 0 time = 1180
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=1180.1n

* CHECK dout0_7 Vdout0_7ck58 = 1.8 time = 1180
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=1180.1n

* CHECK dout0_8 Vdout0_8ck58 = 0 time = 1180
.meas tran vdout0_8ck58 FIND v(dout0_8) AT=1180.1n

* CHECK dout0_9 Vdout0_9ck58 = 1.8 time = 1180
.meas tran vdout0_9ck58 FIND v(dout0_9) AT=1180.1n

* CHECK dout0_10 Vdout0_10ck58 = 1.8 time = 1180
.meas tran vdout0_10ck58 FIND v(dout0_10) AT=1180.1n

* CHECK dout0_11 Vdout0_11ck58 = 1.8 time = 1180
.meas tran vdout0_11ck58 FIND v(dout0_11) AT=1180.1n

* CHECK dout0_12 Vdout0_12ck58 = 0 time = 1180
.meas tran vdout0_12ck58 FIND v(dout0_12) AT=1180.1n

* CHECK dout0_13 Vdout0_13ck58 = 0 time = 1180
.meas tran vdout0_13ck58 FIND v(dout0_13) AT=1180.1n

* CHECK dout0_14 Vdout0_14ck58 = 0 time = 1180
.meas tran vdout0_14ck58 FIND v(dout0_14) AT=1180.1n

* CHECK dout0_15 Vdout0_15ck58 = 1.8 time = 1180
.meas tran vdout0_15ck58 FIND v(dout0_15) AT=1180.1n

* CHECK dout0_0 Vdout0_0ck60 = 1.8 time = 1220
.meas tran vdout0_0ck60 FIND v(dout0_0) AT=1220.1n

* CHECK dout0_1 Vdout0_1ck60 = 1.8 time = 1220
.meas tran vdout0_1ck60 FIND v(dout0_1) AT=1220.1n

* CHECK dout0_2 Vdout0_2ck60 = 0 time = 1220
.meas tran vdout0_2ck60 FIND v(dout0_2) AT=1220.1n

* CHECK dout0_3 Vdout0_3ck60 = 0 time = 1220
.meas tran vdout0_3ck60 FIND v(dout0_3) AT=1220.1n

* CHECK dout0_4 Vdout0_4ck60 = 0 time = 1220
.meas tran vdout0_4ck60 FIND v(dout0_4) AT=1220.1n

* CHECK dout0_5 Vdout0_5ck60 = 1.8 time = 1220
.meas tran vdout0_5ck60 FIND v(dout0_5) AT=1220.1n

* CHECK dout0_6 Vdout0_6ck60 = 1.8 time = 1220
.meas tran vdout0_6ck60 FIND v(dout0_6) AT=1220.1n

* CHECK dout0_7 Vdout0_7ck60 = 0 time = 1220
.meas tran vdout0_7ck60 FIND v(dout0_7) AT=1220.1n

* CHECK dout0_8 Vdout0_8ck60 = 1.8 time = 1220
.meas tran vdout0_8ck60 FIND v(dout0_8) AT=1220.1n

* CHECK dout0_9 Vdout0_9ck60 = 1.8 time = 1220
.meas tran vdout0_9ck60 FIND v(dout0_9) AT=1220.1n

* CHECK dout0_10 Vdout0_10ck60 = 0 time = 1220
.meas tran vdout0_10ck60 FIND v(dout0_10) AT=1220.1n

* CHECK dout0_11 Vdout0_11ck60 = 1.8 time = 1220
.meas tran vdout0_11ck60 FIND v(dout0_11) AT=1220.1n

* CHECK dout0_12 Vdout0_12ck60 = 0 time = 1220
.meas tran vdout0_12ck60 FIND v(dout0_12) AT=1220.1n

* CHECK dout0_13 Vdout0_13ck60 = 1.8 time = 1220
.meas tran vdout0_13ck60 FIND v(dout0_13) AT=1220.1n

* CHECK dout0_14 Vdout0_14ck60 = 1.8 time = 1220
.meas tran vdout0_14ck60 FIND v(dout0_14) AT=1220.1n

* CHECK dout0_15 Vdout0_15ck60 = 1.8 time = 1220
.meas tran vdout0_15ck60 FIND v(dout0_15) AT=1220.1n

* CHECK dout0_0 Vdout0_0ck61 = 1.8 time = 1240
.meas tran vdout0_0ck61 FIND v(dout0_0) AT=1240.1n

* CHECK dout0_1 Vdout0_1ck61 = 0 time = 1240
.meas tran vdout0_1ck61 FIND v(dout0_1) AT=1240.1n

* CHECK dout0_2 Vdout0_2ck61 = 1.8 time = 1240
.meas tran vdout0_2ck61 FIND v(dout0_2) AT=1240.1n

* CHECK dout0_3 Vdout0_3ck61 = 0 time = 1240
.meas tran vdout0_3ck61 FIND v(dout0_3) AT=1240.1n

* CHECK dout0_4 Vdout0_4ck61 = 0 time = 1240
.meas tran vdout0_4ck61 FIND v(dout0_4) AT=1240.1n

* CHECK dout0_5 Vdout0_5ck61 = 1.8 time = 1240
.meas tran vdout0_5ck61 FIND v(dout0_5) AT=1240.1n

* CHECK dout0_6 Vdout0_6ck61 = 0 time = 1240
.meas tran vdout0_6ck61 FIND v(dout0_6) AT=1240.1n

* CHECK dout0_7 Vdout0_7ck61 = 0 time = 1240
.meas tran vdout0_7ck61 FIND v(dout0_7) AT=1240.1n

* CHECK dout0_8 Vdout0_8ck61 = 1.8 time = 1240
.meas tran vdout0_8ck61 FIND v(dout0_8) AT=1240.1n

* CHECK dout0_9 Vdout0_9ck61 = 1.8 time = 1240
.meas tran vdout0_9ck61 FIND v(dout0_9) AT=1240.1n

* CHECK dout0_10 Vdout0_10ck61 = 0 time = 1240
.meas tran vdout0_10ck61 FIND v(dout0_10) AT=1240.1n

* CHECK dout0_11 Vdout0_11ck61 = 0 time = 1240
.meas tran vdout0_11ck61 FIND v(dout0_11) AT=1240.1n

* CHECK dout0_12 Vdout0_12ck61 = 0 time = 1240
.meas tran vdout0_12ck61 FIND v(dout0_12) AT=1240.1n

* CHECK dout0_13 Vdout0_13ck61 = 0 time = 1240
.meas tran vdout0_13ck61 FIND v(dout0_13) AT=1240.1n

* CHECK dout0_14 Vdout0_14ck61 = 0 time = 1240
.meas tran vdout0_14ck61 FIND v(dout0_14) AT=1240.1n

* CHECK dout0_15 Vdout0_15ck61 = 0 time = 1240
.meas tran vdout0_15ck61 FIND v(dout0_15) AT=1240.1n

* CHECK dout0_0 Vdout0_0ck62 = 0 time = 1260
.meas tran vdout0_0ck62 FIND v(dout0_0) AT=1260.1n

* CHECK dout0_1 Vdout0_1ck62 = 1.8 time = 1260
.meas tran vdout0_1ck62 FIND v(dout0_1) AT=1260.1n

* CHECK dout0_2 Vdout0_2ck62 = 0 time = 1260
.meas tran vdout0_2ck62 FIND v(dout0_2) AT=1260.1n

* CHECK dout0_3 Vdout0_3ck62 = 0 time = 1260
.meas tran vdout0_3ck62 FIND v(dout0_3) AT=1260.1n

* CHECK dout0_4 Vdout0_4ck62 = 1.8 time = 1260
.meas tran vdout0_4ck62 FIND v(dout0_4) AT=1260.1n

* CHECK dout0_5 Vdout0_5ck62 = 1.8 time = 1260
.meas tran vdout0_5ck62 FIND v(dout0_5) AT=1260.1n

* CHECK dout0_6 Vdout0_6ck62 = 0 time = 1260
.meas tran vdout0_6ck62 FIND v(dout0_6) AT=1260.1n

* CHECK dout0_7 Vdout0_7ck62 = 1.8 time = 1260
.meas tran vdout0_7ck62 FIND v(dout0_7) AT=1260.1n

* CHECK dout0_8 Vdout0_8ck62 = 0 time = 1260
.meas tran vdout0_8ck62 FIND v(dout0_8) AT=1260.1n

* CHECK dout0_9 Vdout0_9ck62 = 0 time = 1260
.meas tran vdout0_9ck62 FIND v(dout0_9) AT=1260.1n

* CHECK dout0_10 Vdout0_10ck62 = 1.8 time = 1260
.meas tran vdout0_10ck62 FIND v(dout0_10) AT=1260.1n

* CHECK dout0_11 Vdout0_11ck62 = 0 time = 1260
.meas tran vdout0_11ck62 FIND v(dout0_11) AT=1260.1n

* CHECK dout0_12 Vdout0_12ck62 = 1.8 time = 1260
.meas tran vdout0_12ck62 FIND v(dout0_12) AT=1260.1n

* CHECK dout0_13 Vdout0_13ck62 = 1.8 time = 1260
.meas tran vdout0_13ck62 FIND v(dout0_13) AT=1260.1n

* CHECK dout0_14 Vdout0_14ck62 = 1.8 time = 1260
.meas tran vdout0_14ck62 FIND v(dout0_14) AT=1260.1n

* CHECK dout0_15 Vdout0_15ck62 = 1.8 time = 1260
.meas tran vdout0_15ck62 FIND v(dout0_15) AT=1260.1n

* CHECK dout0_0 Vdout0_0ck63 = 0 time = 1280
.meas tran vdout0_0ck63 FIND v(dout0_0) AT=1280.1n

* CHECK dout0_1 Vdout0_1ck63 = 1.8 time = 1280
.meas tran vdout0_1ck63 FIND v(dout0_1) AT=1280.1n

* CHECK dout0_2 Vdout0_2ck63 = 0 time = 1280
.meas tran vdout0_2ck63 FIND v(dout0_2) AT=1280.1n

* CHECK dout0_3 Vdout0_3ck63 = 0 time = 1280
.meas tran vdout0_3ck63 FIND v(dout0_3) AT=1280.1n

* CHECK dout0_4 Vdout0_4ck63 = 0 time = 1280
.meas tran vdout0_4ck63 FIND v(dout0_4) AT=1280.1n

* CHECK dout0_5 Vdout0_5ck63 = 0 time = 1280
.meas tran vdout0_5ck63 FIND v(dout0_5) AT=1280.1n

* CHECK dout0_6 Vdout0_6ck63 = 0 time = 1280
.meas tran vdout0_6ck63 FIND v(dout0_6) AT=1280.1n

* CHECK dout0_7 Vdout0_7ck63 = 1.8 time = 1280
.meas tran vdout0_7ck63 FIND v(dout0_7) AT=1280.1n

* CHECK dout0_8 Vdout0_8ck63 = 0 time = 1280
.meas tran vdout0_8ck63 FIND v(dout0_8) AT=1280.1n

* CHECK dout0_9 Vdout0_9ck63 = 0 time = 1280
.meas tran vdout0_9ck63 FIND v(dout0_9) AT=1280.1n

* CHECK dout0_10 Vdout0_10ck63 = 0 time = 1280
.meas tran vdout0_10ck63 FIND v(dout0_10) AT=1280.1n

* CHECK dout0_11 Vdout0_11ck63 = 0 time = 1280
.meas tran vdout0_11ck63 FIND v(dout0_11) AT=1280.1n

* CHECK dout0_12 Vdout0_12ck63 = 1.8 time = 1280
.meas tran vdout0_12ck63 FIND v(dout0_12) AT=1280.1n

* CHECK dout0_13 Vdout0_13ck63 = 1.8 time = 1280
.meas tran vdout0_13ck63 FIND v(dout0_13) AT=1280.1n

* CHECK dout0_14 Vdout0_14ck63 = 0 time = 1280
.meas tran vdout0_14ck63 FIND v(dout0_14) AT=1280.1n

* CHECK dout0_15 Vdout0_15ck63 = 1.8 time = 1280
.meas tran vdout0_15ck63 FIND v(dout0_15) AT=1280.1n

* CHECK dout0_0 Vdout0_0ck66 = 1.8 time = 1340
.meas tran vdout0_0ck66 FIND v(dout0_0) AT=1340.1n

* CHECK dout0_1 Vdout0_1ck66 = 1.8 time = 1340
.meas tran vdout0_1ck66 FIND v(dout0_1) AT=1340.1n

* CHECK dout0_2 Vdout0_2ck66 = 0 time = 1340
.meas tran vdout0_2ck66 FIND v(dout0_2) AT=1340.1n

* CHECK dout0_3 Vdout0_3ck66 = 1.8 time = 1340
.meas tran vdout0_3ck66 FIND v(dout0_3) AT=1340.1n

* CHECK dout0_4 Vdout0_4ck66 = 1.8 time = 1340
.meas tran vdout0_4ck66 FIND v(dout0_4) AT=1340.1n

* CHECK dout0_5 Vdout0_5ck66 = 0 time = 1340
.meas tran vdout0_5ck66 FIND v(dout0_5) AT=1340.1n

* CHECK dout0_6 Vdout0_6ck66 = 1.8 time = 1340
.meas tran vdout0_6ck66 FIND v(dout0_6) AT=1340.1n

* CHECK dout0_7 Vdout0_7ck66 = 1.8 time = 1340
.meas tran vdout0_7ck66 FIND v(dout0_7) AT=1340.1n

* CHECK dout0_8 Vdout0_8ck66 = 0 time = 1340
.meas tran vdout0_8ck66 FIND v(dout0_8) AT=1340.1n

* CHECK dout0_9 Vdout0_9ck66 = 1.8 time = 1340
.meas tran vdout0_9ck66 FIND v(dout0_9) AT=1340.1n

* CHECK dout0_10 Vdout0_10ck66 = 1.8 time = 1340
.meas tran vdout0_10ck66 FIND v(dout0_10) AT=1340.1n

* CHECK dout0_11 Vdout0_11ck66 = 1.8 time = 1340
.meas tran vdout0_11ck66 FIND v(dout0_11) AT=1340.1n

* CHECK dout0_12 Vdout0_12ck66 = 0 time = 1340
.meas tran vdout0_12ck66 FIND v(dout0_12) AT=1340.1n

* CHECK dout0_13 Vdout0_13ck66 = 1.8 time = 1340
.meas tran vdout0_13ck66 FIND v(dout0_13) AT=1340.1n

* CHECK dout0_14 Vdout0_14ck66 = 1.8 time = 1340
.meas tran vdout0_14ck66 FIND v(dout0_14) AT=1340.1n

* CHECK dout0_15 Vdout0_15ck66 = 1.8 time = 1340
.meas tran vdout0_15ck66 FIND v(dout0_15) AT=1340.1n

* CHECK dout0_0 Vdout0_0ck67 = 1.8 time = 1360
.meas tran vdout0_0ck67 FIND v(dout0_0) AT=1360.1n

* CHECK dout0_1 Vdout0_1ck67 = 0 time = 1360
.meas tran vdout0_1ck67 FIND v(dout0_1) AT=1360.1n

* CHECK dout0_2 Vdout0_2ck67 = 1.8 time = 1360
.meas tran vdout0_2ck67 FIND v(dout0_2) AT=1360.1n

* CHECK dout0_3 Vdout0_3ck67 = 0 time = 1360
.meas tran vdout0_3ck67 FIND v(dout0_3) AT=1360.1n

* CHECK dout0_4 Vdout0_4ck67 = 1.8 time = 1360
.meas tran vdout0_4ck67 FIND v(dout0_4) AT=1360.1n

* CHECK dout0_5 Vdout0_5ck67 = 0 time = 1360
.meas tran vdout0_5ck67 FIND v(dout0_5) AT=1360.1n

* CHECK dout0_6 Vdout0_6ck67 = 0 time = 1360
.meas tran vdout0_6ck67 FIND v(dout0_6) AT=1360.1n

* CHECK dout0_7 Vdout0_7ck67 = 0 time = 1360
.meas tran vdout0_7ck67 FIND v(dout0_7) AT=1360.1n

* CHECK dout0_8 Vdout0_8ck67 = 1.8 time = 1360
.meas tran vdout0_8ck67 FIND v(dout0_8) AT=1360.1n

* CHECK dout0_9 Vdout0_9ck67 = 0 time = 1360
.meas tran vdout0_9ck67 FIND v(dout0_9) AT=1360.1n

* CHECK dout0_10 Vdout0_10ck67 = 0 time = 1360
.meas tran vdout0_10ck67 FIND v(dout0_10) AT=1360.1n

* CHECK dout0_11 Vdout0_11ck67 = 1.8 time = 1360
.meas tran vdout0_11ck67 FIND v(dout0_11) AT=1360.1n

* CHECK dout0_12 Vdout0_12ck67 = 1.8 time = 1360
.meas tran vdout0_12ck67 FIND v(dout0_12) AT=1360.1n

* CHECK dout0_13 Vdout0_13ck67 = 0 time = 1360
.meas tran vdout0_13ck67 FIND v(dout0_13) AT=1360.1n

* CHECK dout0_14 Vdout0_14ck67 = 0 time = 1360
.meas tran vdout0_14ck67 FIND v(dout0_14) AT=1360.1n

* CHECK dout0_15 Vdout0_15ck67 = 1.8 time = 1360
.meas tran vdout0_15ck67 FIND v(dout0_15) AT=1360.1n

* CHECK dout0_0 Vdout0_0ck71 = 1.8 time = 1440
.meas tran vdout0_0ck71 FIND v(dout0_0) AT=1440.1n

* CHECK dout0_1 Vdout0_1ck71 = 0 time = 1440
.meas tran vdout0_1ck71 FIND v(dout0_1) AT=1440.1n

* CHECK dout0_2 Vdout0_2ck71 = 1.8 time = 1440
.meas tran vdout0_2ck71 FIND v(dout0_2) AT=1440.1n

* CHECK dout0_3 Vdout0_3ck71 = 0 time = 1440
.meas tran vdout0_3ck71 FIND v(dout0_3) AT=1440.1n

* CHECK dout0_4 Vdout0_4ck71 = 0 time = 1440
.meas tran vdout0_4ck71 FIND v(dout0_4) AT=1440.1n

* CHECK dout0_5 Vdout0_5ck71 = 1.8 time = 1440
.meas tran vdout0_5ck71 FIND v(dout0_5) AT=1440.1n

* CHECK dout0_6 Vdout0_6ck71 = 0 time = 1440
.meas tran vdout0_6ck71 FIND v(dout0_6) AT=1440.1n

* CHECK dout0_7 Vdout0_7ck71 = 0 time = 1440
.meas tran vdout0_7ck71 FIND v(dout0_7) AT=1440.1n

* CHECK dout0_8 Vdout0_8ck71 = 1.8 time = 1440
.meas tran vdout0_8ck71 FIND v(dout0_8) AT=1440.1n

* CHECK dout0_9 Vdout0_9ck71 = 1.8 time = 1440
.meas tran vdout0_9ck71 FIND v(dout0_9) AT=1440.1n

* CHECK dout0_10 Vdout0_10ck71 = 0 time = 1440
.meas tran vdout0_10ck71 FIND v(dout0_10) AT=1440.1n

* CHECK dout0_11 Vdout0_11ck71 = 0 time = 1440
.meas tran vdout0_11ck71 FIND v(dout0_11) AT=1440.1n

* CHECK dout0_12 Vdout0_12ck71 = 0 time = 1440
.meas tran vdout0_12ck71 FIND v(dout0_12) AT=1440.1n

* CHECK dout0_13 Vdout0_13ck71 = 0 time = 1440
.meas tran vdout0_13ck71 FIND v(dout0_13) AT=1440.1n

* CHECK dout0_14 Vdout0_14ck71 = 0 time = 1440
.meas tran vdout0_14ck71 FIND v(dout0_14) AT=1440.1n

* CHECK dout0_15 Vdout0_15ck71 = 0 time = 1440
.meas tran vdout0_15ck71 FIND v(dout0_15) AT=1440.1n

* CHECK dout0_0 Vdout0_0ck72 = 0 time = 1460
.meas tran vdout0_0ck72 FIND v(dout0_0) AT=1460.1n

* CHECK dout0_1 Vdout0_1ck72 = 0 time = 1460
.meas tran vdout0_1ck72 FIND v(dout0_1) AT=1460.1n

* CHECK dout0_2 Vdout0_2ck72 = 0 time = 1460
.meas tran vdout0_2ck72 FIND v(dout0_2) AT=1460.1n

* CHECK dout0_3 Vdout0_3ck72 = 0 time = 1460
.meas tran vdout0_3ck72 FIND v(dout0_3) AT=1460.1n

* CHECK dout0_4 Vdout0_4ck72 = 0 time = 1460
.meas tran vdout0_4ck72 FIND v(dout0_4) AT=1460.1n

* CHECK dout0_5 Vdout0_5ck72 = 1.8 time = 1460
.meas tran vdout0_5ck72 FIND v(dout0_5) AT=1460.1n

* CHECK dout0_6 Vdout0_6ck72 = 1.8 time = 1460
.meas tran vdout0_6ck72 FIND v(dout0_6) AT=1460.1n

* CHECK dout0_7 Vdout0_7ck72 = 1.8 time = 1460
.meas tran vdout0_7ck72 FIND v(dout0_7) AT=1460.1n

* CHECK dout0_8 Vdout0_8ck72 = 1.8 time = 1460
.meas tran vdout0_8ck72 FIND v(dout0_8) AT=1460.1n

* CHECK dout0_9 Vdout0_9ck72 = 0 time = 1460
.meas tran vdout0_9ck72 FIND v(dout0_9) AT=1460.1n

* CHECK dout0_10 Vdout0_10ck72 = 0 time = 1460
.meas tran vdout0_10ck72 FIND v(dout0_10) AT=1460.1n

* CHECK dout0_11 Vdout0_11ck72 = 0 time = 1460
.meas tran vdout0_11ck72 FIND v(dout0_11) AT=1460.1n

* CHECK dout0_12 Vdout0_12ck72 = 0 time = 1460
.meas tran vdout0_12ck72 FIND v(dout0_12) AT=1460.1n

* CHECK dout0_13 Vdout0_13ck72 = 0 time = 1460
.meas tran vdout0_13ck72 FIND v(dout0_13) AT=1460.1n

* CHECK dout0_14 Vdout0_14ck72 = 0 time = 1460
.meas tran vdout0_14ck72 FIND v(dout0_14) AT=1460.1n

* CHECK dout0_15 Vdout0_15ck72 = 0 time = 1460
.meas tran vdout0_15ck72 FIND v(dout0_15) AT=1460.1n

* CHECK dout0_0 Vdout0_0ck75 = 0 time = 1520
.meas tran vdout0_0ck75 FIND v(dout0_0) AT=1520.1n

* CHECK dout0_1 Vdout0_1ck75 = 0 time = 1520
.meas tran vdout0_1ck75 FIND v(dout0_1) AT=1520.1n

* CHECK dout0_2 Vdout0_2ck75 = 0 time = 1520
.meas tran vdout0_2ck75 FIND v(dout0_2) AT=1520.1n

* CHECK dout0_3 Vdout0_3ck75 = 0 time = 1520
.meas tran vdout0_3ck75 FIND v(dout0_3) AT=1520.1n

* CHECK dout0_4 Vdout0_4ck75 = 0 time = 1520
.meas tran vdout0_4ck75 FIND v(dout0_4) AT=1520.1n

* CHECK dout0_5 Vdout0_5ck75 = 1.8 time = 1520
.meas tran vdout0_5ck75 FIND v(dout0_5) AT=1520.1n

* CHECK dout0_6 Vdout0_6ck75 = 1.8 time = 1520
.meas tran vdout0_6ck75 FIND v(dout0_6) AT=1520.1n

* CHECK dout0_7 Vdout0_7ck75 = 1.8 time = 1520
.meas tran vdout0_7ck75 FIND v(dout0_7) AT=1520.1n

* CHECK dout0_8 Vdout0_8ck75 = 1.8 time = 1520
.meas tran vdout0_8ck75 FIND v(dout0_8) AT=1520.1n

* CHECK dout0_9 Vdout0_9ck75 = 0 time = 1520
.meas tran vdout0_9ck75 FIND v(dout0_9) AT=1520.1n

* CHECK dout0_10 Vdout0_10ck75 = 0 time = 1520
.meas tran vdout0_10ck75 FIND v(dout0_10) AT=1520.1n

* CHECK dout0_11 Vdout0_11ck75 = 0 time = 1520
.meas tran vdout0_11ck75 FIND v(dout0_11) AT=1520.1n

* CHECK dout0_12 Vdout0_12ck75 = 0 time = 1520
.meas tran vdout0_12ck75 FIND v(dout0_12) AT=1520.1n

* CHECK dout0_13 Vdout0_13ck75 = 0 time = 1520
.meas tran vdout0_13ck75 FIND v(dout0_13) AT=1520.1n

* CHECK dout0_14 Vdout0_14ck75 = 0 time = 1520
.meas tran vdout0_14ck75 FIND v(dout0_14) AT=1520.1n

* CHECK dout0_15 Vdout0_15ck75 = 0 time = 1520
.meas tran vdout0_15ck75 FIND v(dout0_15) AT=1520.1n

* CHECK dout0_0 Vdout0_0ck80 = 0 time = 1620
.meas tran vdout0_0ck80 FIND v(dout0_0) AT=1620.1n

* CHECK dout0_1 Vdout0_1ck80 = 1.8 time = 1620
.meas tran vdout0_1ck80 FIND v(dout0_1) AT=1620.1n

* CHECK dout0_2 Vdout0_2ck80 = 1.8 time = 1620
.meas tran vdout0_2ck80 FIND v(dout0_2) AT=1620.1n

* CHECK dout0_3 Vdout0_3ck80 = 1.8 time = 1620
.meas tran vdout0_3ck80 FIND v(dout0_3) AT=1620.1n

* CHECK dout0_4 Vdout0_4ck80 = 0 time = 1620
.meas tran vdout0_4ck80 FIND v(dout0_4) AT=1620.1n

* CHECK dout0_5 Vdout0_5ck80 = 0 time = 1620
.meas tran vdout0_5ck80 FIND v(dout0_5) AT=1620.1n

* CHECK dout0_6 Vdout0_6ck80 = 1.8 time = 1620
.meas tran vdout0_6ck80 FIND v(dout0_6) AT=1620.1n

* CHECK dout0_7 Vdout0_7ck80 = 0 time = 1620
.meas tran vdout0_7ck80 FIND v(dout0_7) AT=1620.1n

* CHECK dout0_8 Vdout0_8ck80 = 1.8 time = 1620
.meas tran vdout0_8ck80 FIND v(dout0_8) AT=1620.1n

* CHECK dout0_9 Vdout0_9ck80 = 0 time = 1620
.meas tran vdout0_9ck80 FIND v(dout0_9) AT=1620.1n

* CHECK dout0_10 Vdout0_10ck80 = 0 time = 1620
.meas tran vdout0_10ck80 FIND v(dout0_10) AT=1620.1n

* CHECK dout0_11 Vdout0_11ck80 = 0 time = 1620
.meas tran vdout0_11ck80 FIND v(dout0_11) AT=1620.1n

* CHECK dout0_12 Vdout0_12ck80 = 1.8 time = 1620
.meas tran vdout0_12ck80 FIND v(dout0_12) AT=1620.1n

* CHECK dout0_13 Vdout0_13ck80 = 1.8 time = 1620
.meas tran vdout0_13ck80 FIND v(dout0_13) AT=1620.1n

* CHECK dout0_14 Vdout0_14ck80 = 1.8 time = 1620
.meas tran vdout0_14ck80 FIND v(dout0_14) AT=1620.1n

* CHECK dout0_15 Vdout0_15ck80 = 1.8 time = 1620
.meas tran vdout0_15ck80 FIND v(dout0_15) AT=1620.1n

* CHECK dout0_0 Vdout0_0ck81 = 0 time = 1640
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=1640.1n

* CHECK dout0_1 Vdout0_1ck81 = 0 time = 1640
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=1640.1n

* CHECK dout0_2 Vdout0_2ck81 = 0 time = 1640
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=1640.1n

* CHECK dout0_3 Vdout0_3ck81 = 0 time = 1640
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=1640.1n

* CHECK dout0_4 Vdout0_4ck81 = 0 time = 1640
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=1640.1n

* CHECK dout0_5 Vdout0_5ck81 = 1.8 time = 1640
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=1640.1n

* CHECK dout0_6 Vdout0_6ck81 = 1.8 time = 1640
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=1640.1n

* CHECK dout0_7 Vdout0_7ck81 = 1.8 time = 1640
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=1640.1n

* CHECK dout0_8 Vdout0_8ck81 = 1.8 time = 1640
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=1640.1n

* CHECK dout0_9 Vdout0_9ck81 = 0 time = 1640
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=1640.1n

* CHECK dout0_10 Vdout0_10ck81 = 0 time = 1640
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=1640.1n

* CHECK dout0_11 Vdout0_11ck81 = 0 time = 1640
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=1640.1n

* CHECK dout0_12 Vdout0_12ck81 = 0 time = 1640
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=1640.1n

* CHECK dout0_13 Vdout0_13ck81 = 0 time = 1640
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=1640.1n

* CHECK dout0_14 Vdout0_14ck81 = 0 time = 1640
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=1640.1n

* CHECK dout0_15 Vdout0_15ck81 = 0 time = 1640
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=1640.1n

* CHECK dout0_0 Vdout0_0ck87 = 0 time = 1760
.meas tran vdout0_0ck87 FIND v(dout0_0) AT=1760.1n

* CHECK dout0_1 Vdout0_1ck87 = 0 time = 1760
.meas tran vdout0_1ck87 FIND v(dout0_1) AT=1760.1n

* CHECK dout0_2 Vdout0_2ck87 = 0 time = 1760
.meas tran vdout0_2ck87 FIND v(dout0_2) AT=1760.1n

* CHECK dout0_3 Vdout0_3ck87 = 0 time = 1760
.meas tran vdout0_3ck87 FIND v(dout0_3) AT=1760.1n

* CHECK dout0_4 Vdout0_4ck87 = 0 time = 1760
.meas tran vdout0_4ck87 FIND v(dout0_4) AT=1760.1n

* CHECK dout0_5 Vdout0_5ck87 = 1.8 time = 1760
.meas tran vdout0_5ck87 FIND v(dout0_5) AT=1760.1n

* CHECK dout0_6 Vdout0_6ck87 = 1.8 time = 1760
.meas tran vdout0_6ck87 FIND v(dout0_6) AT=1760.1n

* CHECK dout0_7 Vdout0_7ck87 = 1.8 time = 1760
.meas tran vdout0_7ck87 FIND v(dout0_7) AT=1760.1n

* CHECK dout0_8 Vdout0_8ck87 = 1.8 time = 1760
.meas tran vdout0_8ck87 FIND v(dout0_8) AT=1760.1n

* CHECK dout0_9 Vdout0_9ck87 = 0 time = 1760
.meas tran vdout0_9ck87 FIND v(dout0_9) AT=1760.1n

* CHECK dout0_10 Vdout0_10ck87 = 0 time = 1760
.meas tran vdout0_10ck87 FIND v(dout0_10) AT=1760.1n

* CHECK dout0_11 Vdout0_11ck87 = 0 time = 1760
.meas tran vdout0_11ck87 FIND v(dout0_11) AT=1760.1n

* CHECK dout0_12 Vdout0_12ck87 = 0 time = 1760
.meas tran vdout0_12ck87 FIND v(dout0_12) AT=1760.1n

* CHECK dout0_13 Vdout0_13ck87 = 0 time = 1760
.meas tran vdout0_13ck87 FIND v(dout0_13) AT=1760.1n

* CHECK dout0_14 Vdout0_14ck87 = 0 time = 1760
.meas tran vdout0_14ck87 FIND v(dout0_14) AT=1760.1n

* CHECK dout0_15 Vdout0_15ck87 = 0 time = 1760
.meas tran vdout0_15ck87 FIND v(dout0_15) AT=1760.1n

* CHECK dout0_0 Vdout0_0ck88 = 1.8 time = 1780
.meas tran vdout0_0ck88 FIND v(dout0_0) AT=1780.1n

* CHECK dout0_1 Vdout0_1ck88 = 0 time = 1780
.meas tran vdout0_1ck88 FIND v(dout0_1) AT=1780.1n

* CHECK dout0_2 Vdout0_2ck88 = 1.8 time = 1780
.meas tran vdout0_2ck88 FIND v(dout0_2) AT=1780.1n

* CHECK dout0_3 Vdout0_3ck88 = 0 time = 1780
.meas tran vdout0_3ck88 FIND v(dout0_3) AT=1780.1n

* CHECK dout0_4 Vdout0_4ck88 = 0 time = 1780
.meas tran vdout0_4ck88 FIND v(dout0_4) AT=1780.1n

* CHECK dout0_5 Vdout0_5ck88 = 1.8 time = 1780
.meas tran vdout0_5ck88 FIND v(dout0_5) AT=1780.1n

* CHECK dout0_6 Vdout0_6ck88 = 0 time = 1780
.meas tran vdout0_6ck88 FIND v(dout0_6) AT=1780.1n

* CHECK dout0_7 Vdout0_7ck88 = 0 time = 1780
.meas tran vdout0_7ck88 FIND v(dout0_7) AT=1780.1n

* CHECK dout0_8 Vdout0_8ck88 = 1.8 time = 1780
.meas tran vdout0_8ck88 FIND v(dout0_8) AT=1780.1n

* CHECK dout0_9 Vdout0_9ck88 = 1.8 time = 1780
.meas tran vdout0_9ck88 FIND v(dout0_9) AT=1780.1n

* CHECK dout0_10 Vdout0_10ck88 = 0 time = 1780
.meas tran vdout0_10ck88 FIND v(dout0_10) AT=1780.1n

* CHECK dout0_11 Vdout0_11ck88 = 0 time = 1780
.meas tran vdout0_11ck88 FIND v(dout0_11) AT=1780.1n

* CHECK dout0_12 Vdout0_12ck88 = 0 time = 1780
.meas tran vdout0_12ck88 FIND v(dout0_12) AT=1780.1n

* CHECK dout0_13 Vdout0_13ck88 = 0 time = 1780
.meas tran vdout0_13ck88 FIND v(dout0_13) AT=1780.1n

* CHECK dout0_14 Vdout0_14ck88 = 0 time = 1780
.meas tran vdout0_14ck88 FIND v(dout0_14) AT=1780.1n

* CHECK dout0_15 Vdout0_15ck88 = 0 time = 1780
.meas tran vdout0_15ck88 FIND v(dout0_15) AT=1780.1n

* CHECK dout0_0 Vdout0_0ck89 = 0 time = 1800
.meas tran vdout0_0ck89 FIND v(dout0_0) AT=1800.1n

* CHECK dout0_1 Vdout0_1ck89 = 1.8 time = 1800
.meas tran vdout0_1ck89 FIND v(dout0_1) AT=1800.1n

* CHECK dout0_2 Vdout0_2ck89 = 1.8 time = 1800
.meas tran vdout0_2ck89 FIND v(dout0_2) AT=1800.1n

* CHECK dout0_3 Vdout0_3ck89 = 1.8 time = 1800
.meas tran vdout0_3ck89 FIND v(dout0_3) AT=1800.1n

* CHECK dout0_4 Vdout0_4ck89 = 0 time = 1800
.meas tran vdout0_4ck89 FIND v(dout0_4) AT=1800.1n

* CHECK dout0_5 Vdout0_5ck89 = 0 time = 1800
.meas tran vdout0_5ck89 FIND v(dout0_5) AT=1800.1n

* CHECK dout0_6 Vdout0_6ck89 = 1.8 time = 1800
.meas tran vdout0_6ck89 FIND v(dout0_6) AT=1800.1n

* CHECK dout0_7 Vdout0_7ck89 = 0 time = 1800
.meas tran vdout0_7ck89 FIND v(dout0_7) AT=1800.1n

* CHECK dout0_8 Vdout0_8ck89 = 1.8 time = 1800
.meas tran vdout0_8ck89 FIND v(dout0_8) AT=1800.1n

* CHECK dout0_9 Vdout0_9ck89 = 0 time = 1800
.meas tran vdout0_9ck89 FIND v(dout0_9) AT=1800.1n

* CHECK dout0_10 Vdout0_10ck89 = 0 time = 1800
.meas tran vdout0_10ck89 FIND v(dout0_10) AT=1800.1n

* CHECK dout0_11 Vdout0_11ck89 = 0 time = 1800
.meas tran vdout0_11ck89 FIND v(dout0_11) AT=1800.1n

* CHECK dout0_12 Vdout0_12ck89 = 1.8 time = 1800
.meas tran vdout0_12ck89 FIND v(dout0_12) AT=1800.1n

* CHECK dout0_13 Vdout0_13ck89 = 1.8 time = 1800
.meas tran vdout0_13ck89 FIND v(dout0_13) AT=1800.1n

* CHECK dout0_14 Vdout0_14ck89 = 1.8 time = 1800
.meas tran vdout0_14ck89 FIND v(dout0_14) AT=1800.1n

* CHECK dout0_15 Vdout0_15ck89 = 1.8 time = 1800
.meas tran vdout0_15ck89 FIND v(dout0_15) AT=1800.1n

* CHECK dout0_0 Vdout0_0ck91 = 0 time = 1840
.meas tran vdout0_0ck91 FIND v(dout0_0) AT=1840.1n

* CHECK dout0_1 Vdout0_1ck91 = 1.8 time = 1840
.meas tran vdout0_1ck91 FIND v(dout0_1) AT=1840.1n

* CHECK dout0_2 Vdout0_2ck91 = 1.8 time = 1840
.meas tran vdout0_2ck91 FIND v(dout0_2) AT=1840.1n

* CHECK dout0_3 Vdout0_3ck91 = 1.8 time = 1840
.meas tran vdout0_3ck91 FIND v(dout0_3) AT=1840.1n

* CHECK dout0_4 Vdout0_4ck91 = 0 time = 1840
.meas tran vdout0_4ck91 FIND v(dout0_4) AT=1840.1n

* CHECK dout0_5 Vdout0_5ck91 = 0 time = 1840
.meas tran vdout0_5ck91 FIND v(dout0_5) AT=1840.1n

* CHECK dout0_6 Vdout0_6ck91 = 1.8 time = 1840
.meas tran vdout0_6ck91 FIND v(dout0_6) AT=1840.1n

* CHECK dout0_7 Vdout0_7ck91 = 0 time = 1840
.meas tran vdout0_7ck91 FIND v(dout0_7) AT=1840.1n

* CHECK dout0_8 Vdout0_8ck91 = 1.8 time = 1840
.meas tran vdout0_8ck91 FIND v(dout0_8) AT=1840.1n

* CHECK dout0_9 Vdout0_9ck91 = 0 time = 1840
.meas tran vdout0_9ck91 FIND v(dout0_9) AT=1840.1n

* CHECK dout0_10 Vdout0_10ck91 = 0 time = 1840
.meas tran vdout0_10ck91 FIND v(dout0_10) AT=1840.1n

* CHECK dout0_11 Vdout0_11ck91 = 0 time = 1840
.meas tran vdout0_11ck91 FIND v(dout0_11) AT=1840.1n

* CHECK dout0_12 Vdout0_12ck91 = 1.8 time = 1840
.meas tran vdout0_12ck91 FIND v(dout0_12) AT=1840.1n

* CHECK dout0_13 Vdout0_13ck91 = 1.8 time = 1840
.meas tran vdout0_13ck91 FIND v(dout0_13) AT=1840.1n

* CHECK dout0_14 Vdout0_14ck91 = 1.8 time = 1840
.meas tran vdout0_14ck91 FIND v(dout0_14) AT=1840.1n

* CHECK dout0_15 Vdout0_15ck91 = 1.8 time = 1840
.meas tran vdout0_15ck91 FIND v(dout0_15) AT=1840.1n

* CHECK dout0_0 Vdout0_0ck92 = 1.8 time = 1860
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=1860.1n

* CHECK dout0_1 Vdout0_1ck92 = 0 time = 1860
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=1860.1n

* CHECK dout0_2 Vdout0_2ck92 = 0 time = 1860
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=1860.1n

* CHECK dout0_3 Vdout0_3ck92 = 1.8 time = 1860
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=1860.1n

* CHECK dout0_4 Vdout0_4ck92 = 1.8 time = 1860
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=1860.1n

* CHECK dout0_5 Vdout0_5ck92 = 0 time = 1860
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=1860.1n

* CHECK dout0_6 Vdout0_6ck92 = 1.8 time = 1860
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=1860.1n

* CHECK dout0_7 Vdout0_7ck92 = 1.8 time = 1860
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=1860.1n

* CHECK dout0_8 Vdout0_8ck92 = 1.8 time = 1860
.meas tran vdout0_8ck92 FIND v(dout0_8) AT=1860.1n

* CHECK dout0_9 Vdout0_9ck92 = 1.8 time = 1860
.meas tran vdout0_9ck92 FIND v(dout0_9) AT=1860.1n

* CHECK dout0_10 Vdout0_10ck92 = 0 time = 1860
.meas tran vdout0_10ck92 FIND v(dout0_10) AT=1860.1n

* CHECK dout0_11 Vdout0_11ck92 = 0 time = 1860
.meas tran vdout0_11ck92 FIND v(dout0_11) AT=1860.1n

* CHECK dout0_12 Vdout0_12ck92 = 1.8 time = 1860
.meas tran vdout0_12ck92 FIND v(dout0_12) AT=1860.1n

* CHECK dout0_13 Vdout0_13ck92 = 0 time = 1860
.meas tran vdout0_13ck92 FIND v(dout0_13) AT=1860.1n

* CHECK dout0_14 Vdout0_14ck92 = 1.8 time = 1860
.meas tran vdout0_14ck92 FIND v(dout0_14) AT=1860.1n

* CHECK dout0_15 Vdout0_15ck92 = 1.8 time = 1860
.meas tran vdout0_15ck92 FIND v(dout0_15) AT=1860.1n

* CHECK dout0_0 Vdout0_0ck93 = 0 time = 1880
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=1880.1n

* CHECK dout0_1 Vdout0_1ck93 = 1.8 time = 1880
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=1880.1n

* CHECK dout0_2 Vdout0_2ck93 = 1.8 time = 1880
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=1880.1n

* CHECK dout0_3 Vdout0_3ck93 = 1.8 time = 1880
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=1880.1n

* CHECK dout0_4 Vdout0_4ck93 = 0 time = 1880
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=1880.1n

* CHECK dout0_5 Vdout0_5ck93 = 0 time = 1880
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=1880.1n

* CHECK dout0_6 Vdout0_6ck93 = 1.8 time = 1880
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=1880.1n

* CHECK dout0_7 Vdout0_7ck93 = 0 time = 1880
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=1880.1n

* CHECK dout0_8 Vdout0_8ck93 = 1.8 time = 1880
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=1880.1n

* CHECK dout0_9 Vdout0_9ck93 = 0 time = 1880
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=1880.1n

* CHECK dout0_10 Vdout0_10ck93 = 0 time = 1880
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=1880.1n

* CHECK dout0_11 Vdout0_11ck93 = 0 time = 1880
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=1880.1n

* CHECK dout0_12 Vdout0_12ck93 = 1.8 time = 1880
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=1880.1n

* CHECK dout0_13 Vdout0_13ck93 = 1.8 time = 1880
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=1880.1n

* CHECK dout0_14 Vdout0_14ck93 = 1.8 time = 1880
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=1880.1n

* CHECK dout0_15 Vdout0_15ck93 = 1.8 time = 1880
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=1880.1n

* CHECK dout0_0 Vdout0_0ck94 = 0 time = 1900
.meas tran vdout0_0ck94 FIND v(dout0_0) AT=1900.1n

* CHECK dout0_1 Vdout0_1ck94 = 1.8 time = 1900
.meas tran vdout0_1ck94 FIND v(dout0_1) AT=1900.1n

* CHECK dout0_2 Vdout0_2ck94 = 1.8 time = 1900
.meas tran vdout0_2ck94 FIND v(dout0_2) AT=1900.1n

* CHECK dout0_3 Vdout0_3ck94 = 1.8 time = 1900
.meas tran vdout0_3ck94 FIND v(dout0_3) AT=1900.1n

* CHECK dout0_4 Vdout0_4ck94 = 0 time = 1900
.meas tran vdout0_4ck94 FIND v(dout0_4) AT=1900.1n

* CHECK dout0_5 Vdout0_5ck94 = 0 time = 1900
.meas tran vdout0_5ck94 FIND v(dout0_5) AT=1900.1n

* CHECK dout0_6 Vdout0_6ck94 = 1.8 time = 1900
.meas tran vdout0_6ck94 FIND v(dout0_6) AT=1900.1n

* CHECK dout0_7 Vdout0_7ck94 = 0 time = 1900
.meas tran vdout0_7ck94 FIND v(dout0_7) AT=1900.1n

* CHECK dout0_8 Vdout0_8ck94 = 1.8 time = 1900
.meas tran vdout0_8ck94 FIND v(dout0_8) AT=1900.1n

* CHECK dout0_9 Vdout0_9ck94 = 0 time = 1900
.meas tran vdout0_9ck94 FIND v(dout0_9) AT=1900.1n

* CHECK dout0_10 Vdout0_10ck94 = 0 time = 1900
.meas tran vdout0_10ck94 FIND v(dout0_10) AT=1900.1n

* CHECK dout0_11 Vdout0_11ck94 = 0 time = 1900
.meas tran vdout0_11ck94 FIND v(dout0_11) AT=1900.1n

* CHECK dout0_12 Vdout0_12ck94 = 1.8 time = 1900
.meas tran vdout0_12ck94 FIND v(dout0_12) AT=1900.1n

* CHECK dout0_13 Vdout0_13ck94 = 1.8 time = 1900
.meas tran vdout0_13ck94 FIND v(dout0_13) AT=1900.1n

* CHECK dout0_14 Vdout0_14ck94 = 1.8 time = 1900
.meas tran vdout0_14ck94 FIND v(dout0_14) AT=1900.1n

* CHECK dout0_15 Vdout0_15ck94 = 1.8 time = 1900
.meas tran vdout0_15ck94 FIND v(dout0_15) AT=1900.1n

* CHECK dout0_0 Vdout0_0ck96 = 0 time = 1940
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=1940.1n

* CHECK dout0_1 Vdout0_1ck96 = 1.8 time = 1940
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=1940.1n

* CHECK dout0_2 Vdout0_2ck96 = 1.8 time = 1940
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=1940.1n

* CHECK dout0_3 Vdout0_3ck96 = 1.8 time = 1940
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=1940.1n

* CHECK dout0_4 Vdout0_4ck96 = 0 time = 1940
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=1940.1n

* CHECK dout0_5 Vdout0_5ck96 = 0 time = 1940
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=1940.1n

* CHECK dout0_6 Vdout0_6ck96 = 1.8 time = 1940
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=1940.1n

* CHECK dout0_7 Vdout0_7ck96 = 0 time = 1940
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=1940.1n

* CHECK dout0_8 Vdout0_8ck96 = 1.8 time = 1940
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=1940.1n

* CHECK dout0_9 Vdout0_9ck96 = 0 time = 1940
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=1940.1n

* CHECK dout0_10 Vdout0_10ck96 = 0 time = 1940
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=1940.1n

* CHECK dout0_11 Vdout0_11ck96 = 0 time = 1940
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=1940.1n

* CHECK dout0_12 Vdout0_12ck96 = 1.8 time = 1940
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=1940.1n

* CHECK dout0_13 Vdout0_13ck96 = 1.8 time = 1940
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=1940.1n

* CHECK dout0_14 Vdout0_14ck96 = 1.8 time = 1940
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=1940.1n

* CHECK dout0_15 Vdout0_15ck96 = 1.8 time = 1940
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=1940.1n

* CHECK dout0_0 Vdout0_0ck97 = 1.8 time = 1960
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=1960.1n

* CHECK dout0_1 Vdout0_1ck97 = 1.8 time = 1960
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=1960.1n

* CHECK dout0_2 Vdout0_2ck97 = 0 time = 1960
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=1960.1n

* CHECK dout0_3 Vdout0_3ck97 = 1.8 time = 1960
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=1960.1n

* CHECK dout0_4 Vdout0_4ck97 = 1.8 time = 1960
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=1960.1n

* CHECK dout0_5 Vdout0_5ck97 = 0 time = 1960
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=1960.1n

* CHECK dout0_6 Vdout0_6ck97 = 1.8 time = 1960
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=1960.1n

* CHECK dout0_7 Vdout0_7ck97 = 1.8 time = 1960
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=1960.1n

* CHECK dout0_8 Vdout0_8ck97 = 0 time = 1960
.meas tran vdout0_8ck97 FIND v(dout0_8) AT=1960.1n

* CHECK dout0_9 Vdout0_9ck97 = 1.8 time = 1960
.meas tran vdout0_9ck97 FIND v(dout0_9) AT=1960.1n

* CHECK dout0_10 Vdout0_10ck97 = 1.8 time = 1960
.meas tran vdout0_10ck97 FIND v(dout0_10) AT=1960.1n

* CHECK dout0_11 Vdout0_11ck97 = 1.8 time = 1960
.meas tran vdout0_11ck97 FIND v(dout0_11) AT=1960.1n

* CHECK dout0_12 Vdout0_12ck97 = 0 time = 1960
.meas tran vdout0_12ck97 FIND v(dout0_12) AT=1960.1n

* CHECK dout0_13 Vdout0_13ck97 = 1.8 time = 1960
.meas tran vdout0_13ck97 FIND v(dout0_13) AT=1960.1n

* CHECK dout0_14 Vdout0_14ck97 = 1.8 time = 1960
.meas tran vdout0_14ck97 FIND v(dout0_14) AT=1960.1n

* CHECK dout0_15 Vdout0_15ck97 = 1.8 time = 1960
.meas tran vdout0_15ck97 FIND v(dout0_15) AT=1960.1n

* CHECK dout0_0 Vdout0_0ck98 = 0 time = 1980
.meas tran vdout0_0ck98 FIND v(dout0_0) AT=1980.1n

* CHECK dout0_1 Vdout0_1ck98 = 1.8 time = 1980
.meas tran vdout0_1ck98 FIND v(dout0_1) AT=1980.1n

* CHECK dout0_2 Vdout0_2ck98 = 1.8 time = 1980
.meas tran vdout0_2ck98 FIND v(dout0_2) AT=1980.1n

* CHECK dout0_3 Vdout0_3ck98 = 1.8 time = 1980
.meas tran vdout0_3ck98 FIND v(dout0_3) AT=1980.1n

* CHECK dout0_4 Vdout0_4ck98 = 1.8 time = 1980
.meas tran vdout0_4ck98 FIND v(dout0_4) AT=1980.1n

* CHECK dout0_5 Vdout0_5ck98 = 0 time = 1980
.meas tran vdout0_5ck98 FIND v(dout0_5) AT=1980.1n

* CHECK dout0_6 Vdout0_6ck98 = 0 time = 1980
.meas tran vdout0_6ck98 FIND v(dout0_6) AT=1980.1n

* CHECK dout0_7 Vdout0_7ck98 = 1.8 time = 1980
.meas tran vdout0_7ck98 FIND v(dout0_7) AT=1980.1n

* CHECK dout0_8 Vdout0_8ck98 = 0 time = 1980
.meas tran vdout0_8ck98 FIND v(dout0_8) AT=1980.1n

* CHECK dout0_9 Vdout0_9ck98 = 0 time = 1980
.meas tran vdout0_9ck98 FIND v(dout0_9) AT=1980.1n

* CHECK dout0_10 Vdout0_10ck98 = 1.8 time = 1980
.meas tran vdout0_10ck98 FIND v(dout0_10) AT=1980.1n

* CHECK dout0_11 Vdout0_11ck98 = 0 time = 1980
.meas tran vdout0_11ck98 FIND v(dout0_11) AT=1980.1n

* CHECK dout0_12 Vdout0_12ck98 = 0 time = 1980
.meas tran vdout0_12ck98 FIND v(dout0_12) AT=1980.1n

* CHECK dout0_13 Vdout0_13ck98 = 1.8 time = 1980
.meas tran vdout0_13ck98 FIND v(dout0_13) AT=1980.1n

* CHECK dout0_14 Vdout0_14ck98 = 0 time = 1980
.meas tran vdout0_14ck98 FIND v(dout0_14) AT=1980.1n

* CHECK dout0_15 Vdout0_15ck98 = 0 time = 1980
.meas tran vdout0_15ck98 FIND v(dout0_15) AT=1980.1n

* CHECK dout0_0 Vdout0_0ck99 = 0 time = 2000
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=2000.1n

* CHECK dout0_1 Vdout0_1ck99 = 1.8 time = 2000
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=2000.1n

* CHECK dout0_2 Vdout0_2ck99 = 1.8 time = 2000
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=2000.1n

* CHECK dout0_3 Vdout0_3ck99 = 1.8 time = 2000
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=2000.1n

* CHECK dout0_4 Vdout0_4ck99 = 1.8 time = 2000
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=2000.1n

* CHECK dout0_5 Vdout0_5ck99 = 0 time = 2000
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=2000.1n

* CHECK dout0_6 Vdout0_6ck99 = 0 time = 2000
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=2000.1n

* CHECK dout0_7 Vdout0_7ck99 = 1.8 time = 2000
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=2000.1n

* CHECK dout0_8 Vdout0_8ck99 = 0 time = 2000
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=2000.1n

* CHECK dout0_9 Vdout0_9ck99 = 0 time = 2000
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=2000.1n

* CHECK dout0_10 Vdout0_10ck99 = 1.8 time = 2000
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=2000.1n

* CHECK dout0_11 Vdout0_11ck99 = 0 time = 2000
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=2000.1n

* CHECK dout0_12 Vdout0_12ck99 = 0 time = 2000
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=2000.1n

* CHECK dout0_13 Vdout0_13ck99 = 1.8 time = 2000
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=2000.1n

* CHECK dout0_14 Vdout0_14ck99 = 0 time = 2000
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=2000.1n

* CHECK dout0_15 Vdout0_15ck99 = 0 time = 2000
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=2000.1n

* CHECK dout0_0 Vdout0_0ck100 = 0 time = 2020
.meas tran vdout0_0ck100 FIND v(dout0_0) AT=2020.1n

* CHECK dout0_1 Vdout0_1ck100 = 1.8 time = 2020
.meas tran vdout0_1ck100 FIND v(dout0_1) AT=2020.1n

* CHECK dout0_2 Vdout0_2ck100 = 1.8 time = 2020
.meas tran vdout0_2ck100 FIND v(dout0_2) AT=2020.1n

* CHECK dout0_3 Vdout0_3ck100 = 1.8 time = 2020
.meas tran vdout0_3ck100 FIND v(dout0_3) AT=2020.1n

* CHECK dout0_4 Vdout0_4ck100 = 1.8 time = 2020
.meas tran vdout0_4ck100 FIND v(dout0_4) AT=2020.1n

* CHECK dout0_5 Vdout0_5ck100 = 0 time = 2020
.meas tran vdout0_5ck100 FIND v(dout0_5) AT=2020.1n

* CHECK dout0_6 Vdout0_6ck100 = 0 time = 2020
.meas tran vdout0_6ck100 FIND v(dout0_6) AT=2020.1n

* CHECK dout0_7 Vdout0_7ck100 = 1.8 time = 2020
.meas tran vdout0_7ck100 FIND v(dout0_7) AT=2020.1n

* CHECK dout0_8 Vdout0_8ck100 = 0 time = 2020
.meas tran vdout0_8ck100 FIND v(dout0_8) AT=2020.1n

* CHECK dout0_9 Vdout0_9ck100 = 0 time = 2020
.meas tran vdout0_9ck100 FIND v(dout0_9) AT=2020.1n

* CHECK dout0_10 Vdout0_10ck100 = 1.8 time = 2020
.meas tran vdout0_10ck100 FIND v(dout0_10) AT=2020.1n

* CHECK dout0_11 Vdout0_11ck100 = 0 time = 2020
.meas tran vdout0_11ck100 FIND v(dout0_11) AT=2020.1n

* CHECK dout0_12 Vdout0_12ck100 = 0 time = 2020
.meas tran vdout0_12ck100 FIND v(dout0_12) AT=2020.1n

* CHECK dout0_13 Vdout0_13ck100 = 1.8 time = 2020
.meas tran vdout0_13ck100 FIND v(dout0_13) AT=2020.1n

* CHECK dout0_14 Vdout0_14ck100 = 0 time = 2020
.meas tran vdout0_14ck100 FIND v(dout0_14) AT=2020.1n

* CHECK dout0_15 Vdout0_15ck100 = 0 time = 2020
.meas tran vdout0_15ck100 FIND v(dout0_15) AT=2020.1n

* CHECK dout0_0 Vdout0_0ck103 = 1.8 time = 2080
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=2080.1n

* CHECK dout0_1 Vdout0_1ck103 = 0 time = 2080
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=2080.1n

* CHECK dout0_2 Vdout0_2ck103 = 1.8 time = 2080
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=2080.1n

* CHECK dout0_3 Vdout0_3ck103 = 0 time = 2080
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=2080.1n

* CHECK dout0_4 Vdout0_4ck103 = 1.8 time = 2080
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=2080.1n

* CHECK dout0_5 Vdout0_5ck103 = 0 time = 2080
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=2080.1n

* CHECK dout0_6 Vdout0_6ck103 = 0 time = 2080
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=2080.1n

* CHECK dout0_7 Vdout0_7ck103 = 0 time = 2080
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=2080.1n

* CHECK dout0_8 Vdout0_8ck103 = 1.8 time = 2080
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=2080.1n

* CHECK dout0_9 Vdout0_9ck103 = 0 time = 2080
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=2080.1n

* CHECK dout0_10 Vdout0_10ck103 = 0 time = 2080
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=2080.1n

* CHECK dout0_11 Vdout0_11ck103 = 1.8 time = 2080
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=2080.1n

* CHECK dout0_12 Vdout0_12ck103 = 1.8 time = 2080
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=2080.1n

* CHECK dout0_13 Vdout0_13ck103 = 0 time = 2080
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=2080.1n

* CHECK dout0_14 Vdout0_14ck103 = 0 time = 2080
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=2080.1n

* CHECK dout0_15 Vdout0_15ck103 = 1.8 time = 2080
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=2080.1n

* CHECK dout0_0 Vdout0_0ck104 = 0 time = 2100
.meas tran vdout0_0ck104 FIND v(dout0_0) AT=2100.1n

* CHECK dout0_1 Vdout0_1ck104 = 1.8 time = 2100
.meas tran vdout0_1ck104 FIND v(dout0_1) AT=2100.1n

* CHECK dout0_2 Vdout0_2ck104 = 1.8 time = 2100
.meas tran vdout0_2ck104 FIND v(dout0_2) AT=2100.1n

* CHECK dout0_3 Vdout0_3ck104 = 1.8 time = 2100
.meas tran vdout0_3ck104 FIND v(dout0_3) AT=2100.1n

* CHECK dout0_4 Vdout0_4ck104 = 0 time = 2100
.meas tran vdout0_4ck104 FIND v(dout0_4) AT=2100.1n

* CHECK dout0_5 Vdout0_5ck104 = 0 time = 2100
.meas tran vdout0_5ck104 FIND v(dout0_5) AT=2100.1n

* CHECK dout0_6 Vdout0_6ck104 = 1.8 time = 2100
.meas tran vdout0_6ck104 FIND v(dout0_6) AT=2100.1n

* CHECK dout0_7 Vdout0_7ck104 = 0 time = 2100
.meas tran vdout0_7ck104 FIND v(dout0_7) AT=2100.1n

* CHECK dout0_8 Vdout0_8ck104 = 1.8 time = 2100
.meas tran vdout0_8ck104 FIND v(dout0_8) AT=2100.1n

* CHECK dout0_9 Vdout0_9ck104 = 0 time = 2100
.meas tran vdout0_9ck104 FIND v(dout0_9) AT=2100.1n

* CHECK dout0_10 Vdout0_10ck104 = 0 time = 2100
.meas tran vdout0_10ck104 FIND v(dout0_10) AT=2100.1n

* CHECK dout0_11 Vdout0_11ck104 = 0 time = 2100
.meas tran vdout0_11ck104 FIND v(dout0_11) AT=2100.1n

* CHECK dout0_12 Vdout0_12ck104 = 1.8 time = 2100
.meas tran vdout0_12ck104 FIND v(dout0_12) AT=2100.1n

* CHECK dout0_13 Vdout0_13ck104 = 1.8 time = 2100
.meas tran vdout0_13ck104 FIND v(dout0_13) AT=2100.1n

* CHECK dout0_14 Vdout0_14ck104 = 1.8 time = 2100
.meas tran vdout0_14ck104 FIND v(dout0_14) AT=2100.1n

* CHECK dout0_15 Vdout0_15ck104 = 1.8 time = 2100
.meas tran vdout0_15ck104 FIND v(dout0_15) AT=2100.1n

* CHECK dout0_0 Vdout0_0ck105 = 0 time = 2120
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=2120.1n

* CHECK dout0_1 Vdout0_1ck105 = 1.8 time = 2120
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=2120.1n

* CHECK dout0_2 Vdout0_2ck105 = 1.8 time = 2120
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=2120.1n

* CHECK dout0_3 Vdout0_3ck105 = 1.8 time = 2120
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=2120.1n

* CHECK dout0_4 Vdout0_4ck105 = 1.8 time = 2120
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=2120.1n

* CHECK dout0_5 Vdout0_5ck105 = 0 time = 2120
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=2120.1n

* CHECK dout0_6 Vdout0_6ck105 = 0 time = 2120
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=2120.1n

* CHECK dout0_7 Vdout0_7ck105 = 1.8 time = 2120
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=2120.1n

* CHECK dout0_8 Vdout0_8ck105 = 0 time = 2120
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=2120.1n

* CHECK dout0_9 Vdout0_9ck105 = 0 time = 2120
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=2120.1n

* CHECK dout0_10 Vdout0_10ck105 = 1.8 time = 2120
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=2120.1n

* CHECK dout0_11 Vdout0_11ck105 = 0 time = 2120
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=2120.1n

* CHECK dout0_12 Vdout0_12ck105 = 0 time = 2120
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=2120.1n

* CHECK dout0_13 Vdout0_13ck105 = 1.8 time = 2120
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=2120.1n

* CHECK dout0_14 Vdout0_14ck105 = 0 time = 2120
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=2120.1n

* CHECK dout0_15 Vdout0_15ck105 = 0 time = 2120
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=2120.1n

* CHECK dout0_0 Vdout0_0ck106 = 1.8 time = 2140
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=2140.1n

* CHECK dout0_1 Vdout0_1ck106 = 0 time = 2140
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=2140.1n

* CHECK dout0_2 Vdout0_2ck106 = 1.8 time = 2140
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=2140.1n

* CHECK dout0_3 Vdout0_3ck106 = 0 time = 2140
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=2140.1n

* CHECK dout0_4 Vdout0_4ck106 = 1.8 time = 2140
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=2140.1n

* CHECK dout0_5 Vdout0_5ck106 = 0 time = 2140
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=2140.1n

* CHECK dout0_6 Vdout0_6ck106 = 0 time = 2140
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=2140.1n

* CHECK dout0_7 Vdout0_7ck106 = 0 time = 2140
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=2140.1n

* CHECK dout0_8 Vdout0_8ck106 = 1.8 time = 2140
.meas tran vdout0_8ck106 FIND v(dout0_8) AT=2140.1n

* CHECK dout0_9 Vdout0_9ck106 = 0 time = 2140
.meas tran vdout0_9ck106 FIND v(dout0_9) AT=2140.1n

* CHECK dout0_10 Vdout0_10ck106 = 0 time = 2140
.meas tran vdout0_10ck106 FIND v(dout0_10) AT=2140.1n

* CHECK dout0_11 Vdout0_11ck106 = 1.8 time = 2140
.meas tran vdout0_11ck106 FIND v(dout0_11) AT=2140.1n

* CHECK dout0_12 Vdout0_12ck106 = 1.8 time = 2140
.meas tran vdout0_12ck106 FIND v(dout0_12) AT=2140.1n

* CHECK dout0_13 Vdout0_13ck106 = 0 time = 2140
.meas tran vdout0_13ck106 FIND v(dout0_13) AT=2140.1n

* CHECK dout0_14 Vdout0_14ck106 = 0 time = 2140
.meas tran vdout0_14ck106 FIND v(dout0_14) AT=2140.1n

* CHECK dout0_15 Vdout0_15ck106 = 1.8 time = 2140
.meas tran vdout0_15ck106 FIND v(dout0_15) AT=2140.1n

* CHECK dout0_0 Vdout0_0ck107 = 1.8 time = 2160
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=2160.1n

* CHECK dout0_1 Vdout0_1ck107 = 1.8 time = 2160
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=2160.1n

* CHECK dout0_2 Vdout0_2ck107 = 0 time = 2160
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=2160.1n

* CHECK dout0_3 Vdout0_3ck107 = 1.8 time = 2160
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=2160.1n

* CHECK dout0_4 Vdout0_4ck107 = 1.8 time = 2160
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=2160.1n

* CHECK dout0_5 Vdout0_5ck107 = 0 time = 2160
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=2160.1n

* CHECK dout0_6 Vdout0_6ck107 = 1.8 time = 2160
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=2160.1n

* CHECK dout0_7 Vdout0_7ck107 = 1.8 time = 2160
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=2160.1n

* CHECK dout0_8 Vdout0_8ck107 = 0 time = 2160
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=2160.1n

* CHECK dout0_9 Vdout0_9ck107 = 1.8 time = 2160
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=2160.1n

* CHECK dout0_10 Vdout0_10ck107 = 1.8 time = 2160
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=2160.1n

* CHECK dout0_11 Vdout0_11ck107 = 1.8 time = 2160
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=2160.1n

* CHECK dout0_12 Vdout0_12ck107 = 0 time = 2160
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=2160.1n

* CHECK dout0_13 Vdout0_13ck107 = 1.8 time = 2160
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=2160.1n

* CHECK dout0_14 Vdout0_14ck107 = 1.8 time = 2160
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=2160.1n

* CHECK dout0_15 Vdout0_15ck107 = 1.8 time = 2160
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=2160.1n

* CHECK dout0_0 Vdout0_0ck108 = 0 time = 2180
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=2180.1n

* CHECK dout0_1 Vdout0_1ck108 = 1.8 time = 2180
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=2180.1n

* CHECK dout0_2 Vdout0_2ck108 = 1.8 time = 2180
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=2180.1n

* CHECK dout0_3 Vdout0_3ck108 = 1.8 time = 2180
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=2180.1n

* CHECK dout0_4 Vdout0_4ck108 = 1.8 time = 2180
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=2180.1n

* CHECK dout0_5 Vdout0_5ck108 = 0 time = 2180
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=2180.1n

* CHECK dout0_6 Vdout0_6ck108 = 0 time = 2180
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=2180.1n

* CHECK dout0_7 Vdout0_7ck108 = 1.8 time = 2180
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=2180.1n

* CHECK dout0_8 Vdout0_8ck108 = 0 time = 2180
.meas tran vdout0_8ck108 FIND v(dout0_8) AT=2180.1n

* CHECK dout0_9 Vdout0_9ck108 = 0 time = 2180
.meas tran vdout0_9ck108 FIND v(dout0_9) AT=2180.1n

* CHECK dout0_10 Vdout0_10ck108 = 1.8 time = 2180
.meas tran vdout0_10ck108 FIND v(dout0_10) AT=2180.1n

* CHECK dout0_11 Vdout0_11ck108 = 0 time = 2180
.meas tran vdout0_11ck108 FIND v(dout0_11) AT=2180.1n

* CHECK dout0_12 Vdout0_12ck108 = 0 time = 2180
.meas tran vdout0_12ck108 FIND v(dout0_12) AT=2180.1n

* CHECK dout0_13 Vdout0_13ck108 = 1.8 time = 2180
.meas tran vdout0_13ck108 FIND v(dout0_13) AT=2180.1n

* CHECK dout0_14 Vdout0_14ck108 = 0 time = 2180
.meas tran vdout0_14ck108 FIND v(dout0_14) AT=2180.1n

* CHECK dout0_15 Vdout0_15ck108 = 0 time = 2180
.meas tran vdout0_15ck108 FIND v(dout0_15) AT=2180.1n

* CHECK dout0_0 Vdout0_0ck110 = 1.8 time = 2220
.meas tran vdout0_0ck110 FIND v(dout0_0) AT=2220.1n

* CHECK dout0_1 Vdout0_1ck110 = 1.8 time = 2220
.meas tran vdout0_1ck110 FIND v(dout0_1) AT=2220.1n

* CHECK dout0_2 Vdout0_2ck110 = 0 time = 2220
.meas tran vdout0_2ck110 FIND v(dout0_2) AT=2220.1n

* CHECK dout0_3 Vdout0_3ck110 = 1.8 time = 2220
.meas tran vdout0_3ck110 FIND v(dout0_3) AT=2220.1n

* CHECK dout0_4 Vdout0_4ck110 = 1.8 time = 2220
.meas tran vdout0_4ck110 FIND v(dout0_4) AT=2220.1n

* CHECK dout0_5 Vdout0_5ck110 = 0 time = 2220
.meas tran vdout0_5ck110 FIND v(dout0_5) AT=2220.1n

* CHECK dout0_6 Vdout0_6ck110 = 1.8 time = 2220
.meas tran vdout0_6ck110 FIND v(dout0_6) AT=2220.1n

* CHECK dout0_7 Vdout0_7ck110 = 1.8 time = 2220
.meas tran vdout0_7ck110 FIND v(dout0_7) AT=2220.1n

* CHECK dout0_8 Vdout0_8ck110 = 0 time = 2220
.meas tran vdout0_8ck110 FIND v(dout0_8) AT=2220.1n

* CHECK dout0_9 Vdout0_9ck110 = 1.8 time = 2220
.meas tran vdout0_9ck110 FIND v(dout0_9) AT=2220.1n

* CHECK dout0_10 Vdout0_10ck110 = 1.8 time = 2220
.meas tran vdout0_10ck110 FIND v(dout0_10) AT=2220.1n

* CHECK dout0_11 Vdout0_11ck110 = 1.8 time = 2220
.meas tran vdout0_11ck110 FIND v(dout0_11) AT=2220.1n

* CHECK dout0_12 Vdout0_12ck110 = 0 time = 2220
.meas tran vdout0_12ck110 FIND v(dout0_12) AT=2220.1n

* CHECK dout0_13 Vdout0_13ck110 = 1.8 time = 2220
.meas tran vdout0_13ck110 FIND v(dout0_13) AT=2220.1n

* CHECK dout0_14 Vdout0_14ck110 = 1.8 time = 2220
.meas tran vdout0_14ck110 FIND v(dout0_14) AT=2220.1n

* CHECK dout0_15 Vdout0_15ck110 = 1.8 time = 2220
.meas tran vdout0_15ck110 FIND v(dout0_15) AT=2220.1n

* CHECK dout0_0 Vdout0_0ck112 = 1.8 time = 2260
.meas tran vdout0_0ck112 FIND v(dout0_0) AT=2260.1n

* CHECK dout0_1 Vdout0_1ck112 = 0 time = 2260
.meas tran vdout0_1ck112 FIND v(dout0_1) AT=2260.1n

* CHECK dout0_2 Vdout0_2ck112 = 0 time = 2260
.meas tran vdout0_2ck112 FIND v(dout0_2) AT=2260.1n

* CHECK dout0_3 Vdout0_3ck112 = 1.8 time = 2260
.meas tran vdout0_3ck112 FIND v(dout0_3) AT=2260.1n

* CHECK dout0_4 Vdout0_4ck112 = 1.8 time = 2260
.meas tran vdout0_4ck112 FIND v(dout0_4) AT=2260.1n

* CHECK dout0_5 Vdout0_5ck112 = 0 time = 2260
.meas tran vdout0_5ck112 FIND v(dout0_5) AT=2260.1n

* CHECK dout0_6 Vdout0_6ck112 = 1.8 time = 2260
.meas tran vdout0_6ck112 FIND v(dout0_6) AT=2260.1n

* CHECK dout0_7 Vdout0_7ck112 = 1.8 time = 2260
.meas tran vdout0_7ck112 FIND v(dout0_7) AT=2260.1n

* CHECK dout0_8 Vdout0_8ck112 = 1.8 time = 2260
.meas tran vdout0_8ck112 FIND v(dout0_8) AT=2260.1n

* CHECK dout0_9 Vdout0_9ck112 = 1.8 time = 2260
.meas tran vdout0_9ck112 FIND v(dout0_9) AT=2260.1n

* CHECK dout0_10 Vdout0_10ck112 = 0 time = 2260
.meas tran vdout0_10ck112 FIND v(dout0_10) AT=2260.1n

* CHECK dout0_11 Vdout0_11ck112 = 0 time = 2260
.meas tran vdout0_11ck112 FIND v(dout0_11) AT=2260.1n

* CHECK dout0_12 Vdout0_12ck112 = 1.8 time = 2260
.meas tran vdout0_12ck112 FIND v(dout0_12) AT=2260.1n

* CHECK dout0_13 Vdout0_13ck112 = 0 time = 2260
.meas tran vdout0_13ck112 FIND v(dout0_13) AT=2260.1n

* CHECK dout0_14 Vdout0_14ck112 = 1.8 time = 2260
.meas tran vdout0_14ck112 FIND v(dout0_14) AT=2260.1n

* CHECK dout0_15 Vdout0_15ck112 = 1.8 time = 2260
.meas tran vdout0_15ck112 FIND v(dout0_15) AT=2260.1n

* CHECK dout0_0 Vdout0_0ck114 = 1.8 time = 2300
.meas tran vdout0_0ck114 FIND v(dout0_0) AT=2300.1n

* CHECK dout0_1 Vdout0_1ck114 = 0 time = 2300
.meas tran vdout0_1ck114 FIND v(dout0_1) AT=2300.1n

* CHECK dout0_2 Vdout0_2ck114 = 0 time = 2300
.meas tran vdout0_2ck114 FIND v(dout0_2) AT=2300.1n

* CHECK dout0_3 Vdout0_3ck114 = 1.8 time = 2300
.meas tran vdout0_3ck114 FIND v(dout0_3) AT=2300.1n

* CHECK dout0_4 Vdout0_4ck114 = 1.8 time = 2300
.meas tran vdout0_4ck114 FIND v(dout0_4) AT=2300.1n

* CHECK dout0_5 Vdout0_5ck114 = 0 time = 2300
.meas tran vdout0_5ck114 FIND v(dout0_5) AT=2300.1n

* CHECK dout0_6 Vdout0_6ck114 = 1.8 time = 2300
.meas tran vdout0_6ck114 FIND v(dout0_6) AT=2300.1n

* CHECK dout0_7 Vdout0_7ck114 = 1.8 time = 2300
.meas tran vdout0_7ck114 FIND v(dout0_7) AT=2300.1n

* CHECK dout0_8 Vdout0_8ck114 = 1.8 time = 2300
.meas tran vdout0_8ck114 FIND v(dout0_8) AT=2300.1n

* CHECK dout0_9 Vdout0_9ck114 = 1.8 time = 2300
.meas tran vdout0_9ck114 FIND v(dout0_9) AT=2300.1n

* CHECK dout0_10 Vdout0_10ck114 = 0 time = 2300
.meas tran vdout0_10ck114 FIND v(dout0_10) AT=2300.1n

* CHECK dout0_11 Vdout0_11ck114 = 0 time = 2300
.meas tran vdout0_11ck114 FIND v(dout0_11) AT=2300.1n

* CHECK dout0_12 Vdout0_12ck114 = 1.8 time = 2300
.meas tran vdout0_12ck114 FIND v(dout0_12) AT=2300.1n

* CHECK dout0_13 Vdout0_13ck114 = 0 time = 2300
.meas tran vdout0_13ck114 FIND v(dout0_13) AT=2300.1n

* CHECK dout0_14 Vdout0_14ck114 = 1.8 time = 2300
.meas tran vdout0_14ck114 FIND v(dout0_14) AT=2300.1n

* CHECK dout0_15 Vdout0_15ck114 = 1.8 time = 2300
.meas tran vdout0_15ck114 FIND v(dout0_15) AT=2300.1n

* CHECK dout0_0 Vdout0_0ck116 = 0 time = 2340
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=2340.1n

* CHECK dout0_1 Vdout0_1ck116 = 0 time = 2340
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=2340.1n

* CHECK dout0_2 Vdout0_2ck116 = 1.8 time = 2340
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=2340.1n

* CHECK dout0_3 Vdout0_3ck116 = 1.8 time = 2340
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=2340.1n

* CHECK dout0_4 Vdout0_4ck116 = 0 time = 2340
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=2340.1n

* CHECK dout0_5 Vdout0_5ck116 = 0 time = 2340
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=2340.1n

* CHECK dout0_6 Vdout0_6ck116 = 0 time = 2340
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=2340.1n

* CHECK dout0_7 Vdout0_7ck116 = 1.8 time = 2340
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=2340.1n

* CHECK dout0_8 Vdout0_8ck116 = 1.8 time = 2340
.meas tran vdout0_8ck116 FIND v(dout0_8) AT=2340.1n

* CHECK dout0_9 Vdout0_9ck116 = 1.8 time = 2340
.meas tran vdout0_9ck116 FIND v(dout0_9) AT=2340.1n

* CHECK dout0_10 Vdout0_10ck116 = 1.8 time = 2340
.meas tran vdout0_10ck116 FIND v(dout0_10) AT=2340.1n

* CHECK dout0_11 Vdout0_11ck116 = 0 time = 2340
.meas tran vdout0_11ck116 FIND v(dout0_11) AT=2340.1n

* CHECK dout0_12 Vdout0_12ck116 = 0 time = 2340
.meas tran vdout0_12ck116 FIND v(dout0_12) AT=2340.1n

* CHECK dout0_13 Vdout0_13ck116 = 0 time = 2340
.meas tran vdout0_13ck116 FIND v(dout0_13) AT=2340.1n

* CHECK dout0_14 Vdout0_14ck116 = 1.8 time = 2340
.meas tran vdout0_14ck116 FIND v(dout0_14) AT=2340.1n

* CHECK dout0_15 Vdout0_15ck116 = 0 time = 2340
.meas tran vdout0_15ck116 FIND v(dout0_15) AT=2340.1n

* CHECK dout0_0 Vdout0_0ck117 = 0 time = 2360
.meas tran vdout0_0ck117 FIND v(dout0_0) AT=2360.1n

* CHECK dout0_1 Vdout0_1ck117 = 1.8 time = 2360
.meas tran vdout0_1ck117 FIND v(dout0_1) AT=2360.1n

* CHECK dout0_2 Vdout0_2ck117 = 1.8 time = 2360
.meas tran vdout0_2ck117 FIND v(dout0_2) AT=2360.1n

* CHECK dout0_3 Vdout0_3ck117 = 1.8 time = 2360
.meas tran vdout0_3ck117 FIND v(dout0_3) AT=2360.1n

* CHECK dout0_4 Vdout0_4ck117 = 1.8 time = 2360
.meas tran vdout0_4ck117 FIND v(dout0_4) AT=2360.1n

* CHECK dout0_5 Vdout0_5ck117 = 0 time = 2360
.meas tran vdout0_5ck117 FIND v(dout0_5) AT=2360.1n

* CHECK dout0_6 Vdout0_6ck117 = 0 time = 2360
.meas tran vdout0_6ck117 FIND v(dout0_6) AT=2360.1n

* CHECK dout0_7 Vdout0_7ck117 = 1.8 time = 2360
.meas tran vdout0_7ck117 FIND v(dout0_7) AT=2360.1n

* CHECK dout0_8 Vdout0_8ck117 = 0 time = 2360
.meas tran vdout0_8ck117 FIND v(dout0_8) AT=2360.1n

* CHECK dout0_9 Vdout0_9ck117 = 0 time = 2360
.meas tran vdout0_9ck117 FIND v(dout0_9) AT=2360.1n

* CHECK dout0_10 Vdout0_10ck117 = 1.8 time = 2360
.meas tran vdout0_10ck117 FIND v(dout0_10) AT=2360.1n

* CHECK dout0_11 Vdout0_11ck117 = 0 time = 2360
.meas tran vdout0_11ck117 FIND v(dout0_11) AT=2360.1n

* CHECK dout0_12 Vdout0_12ck117 = 0 time = 2360
.meas tran vdout0_12ck117 FIND v(dout0_12) AT=2360.1n

* CHECK dout0_13 Vdout0_13ck117 = 1.8 time = 2360
.meas tran vdout0_13ck117 FIND v(dout0_13) AT=2360.1n

* CHECK dout0_14 Vdout0_14ck117 = 0 time = 2360
.meas tran vdout0_14ck117 FIND v(dout0_14) AT=2360.1n

* CHECK dout0_15 Vdout0_15ck117 = 0 time = 2360
.meas tran vdout0_15ck117 FIND v(dout0_15) AT=2360.1n

* CHECK dout0_0 Vdout0_0ck118 = 0 time = 2380
.meas tran vdout0_0ck118 FIND v(dout0_0) AT=2380.1n

* CHECK dout0_1 Vdout0_1ck118 = 0 time = 2380
.meas tran vdout0_1ck118 FIND v(dout0_1) AT=2380.1n

* CHECK dout0_2 Vdout0_2ck118 = 0 time = 2380
.meas tran vdout0_2ck118 FIND v(dout0_2) AT=2380.1n

* CHECK dout0_3 Vdout0_3ck118 = 0 time = 2380
.meas tran vdout0_3ck118 FIND v(dout0_3) AT=2380.1n

* CHECK dout0_4 Vdout0_4ck118 = 0 time = 2380
.meas tran vdout0_4ck118 FIND v(dout0_4) AT=2380.1n

* CHECK dout0_5 Vdout0_5ck118 = 1.8 time = 2380
.meas tran vdout0_5ck118 FIND v(dout0_5) AT=2380.1n

* CHECK dout0_6 Vdout0_6ck118 = 1.8 time = 2380
.meas tran vdout0_6ck118 FIND v(dout0_6) AT=2380.1n

* CHECK dout0_7 Vdout0_7ck118 = 1.8 time = 2380
.meas tran vdout0_7ck118 FIND v(dout0_7) AT=2380.1n

* CHECK dout0_8 Vdout0_8ck118 = 1.8 time = 2380
.meas tran vdout0_8ck118 FIND v(dout0_8) AT=2380.1n

* CHECK dout0_9 Vdout0_9ck118 = 0 time = 2380
.meas tran vdout0_9ck118 FIND v(dout0_9) AT=2380.1n

* CHECK dout0_10 Vdout0_10ck118 = 0 time = 2380
.meas tran vdout0_10ck118 FIND v(dout0_10) AT=2380.1n

* CHECK dout0_11 Vdout0_11ck118 = 0 time = 2380
.meas tran vdout0_11ck118 FIND v(dout0_11) AT=2380.1n

* CHECK dout0_12 Vdout0_12ck118 = 0 time = 2380
.meas tran vdout0_12ck118 FIND v(dout0_12) AT=2380.1n

* CHECK dout0_13 Vdout0_13ck118 = 0 time = 2380
.meas tran vdout0_13ck118 FIND v(dout0_13) AT=2380.1n

* CHECK dout0_14 Vdout0_14ck118 = 0 time = 2380
.meas tran vdout0_14ck118 FIND v(dout0_14) AT=2380.1n

* CHECK dout0_15 Vdout0_15ck118 = 0 time = 2380
.meas tran vdout0_15ck118 FIND v(dout0_15) AT=2380.1n

* CHECK dout0_0 Vdout0_0ck119 = 1.8 time = 2400
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=2400.1n

* CHECK dout0_1 Vdout0_1ck119 = 1.8 time = 2400
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=2400.1n

* CHECK dout0_2 Vdout0_2ck119 = 0 time = 2400
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=2400.1n

* CHECK dout0_3 Vdout0_3ck119 = 1.8 time = 2400
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=2400.1n

* CHECK dout0_4 Vdout0_4ck119 = 1.8 time = 2400
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=2400.1n

* CHECK dout0_5 Vdout0_5ck119 = 0 time = 2400
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=2400.1n

* CHECK dout0_6 Vdout0_6ck119 = 1.8 time = 2400
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=2400.1n

* CHECK dout0_7 Vdout0_7ck119 = 1.8 time = 2400
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=2400.1n

* CHECK dout0_8 Vdout0_8ck119 = 0 time = 2400
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=2400.1n

* CHECK dout0_9 Vdout0_9ck119 = 1.8 time = 2400
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=2400.1n

* CHECK dout0_10 Vdout0_10ck119 = 1.8 time = 2400
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=2400.1n

* CHECK dout0_11 Vdout0_11ck119 = 1.8 time = 2400
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=2400.1n

* CHECK dout0_12 Vdout0_12ck119 = 0 time = 2400
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=2400.1n

* CHECK dout0_13 Vdout0_13ck119 = 1.8 time = 2400
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=2400.1n

* CHECK dout0_14 Vdout0_14ck119 = 1.8 time = 2400
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=2400.1n

* CHECK dout0_15 Vdout0_15ck119 = 1.8 time = 2400
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=2400.1n

* CHECK dout0_0 Vdout0_0ck122 = 0 time = 2460
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=2460.1n

* CHECK dout0_1 Vdout0_1ck122 = 0 time = 2460
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=2460.1n

* CHECK dout0_2 Vdout0_2ck122 = 0 time = 2460
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=2460.1n

* CHECK dout0_3 Vdout0_3ck122 = 1.8 time = 2460
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=2460.1n

* CHECK dout0_4 Vdout0_4ck122 = 0 time = 2460
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=2460.1n

* CHECK dout0_5 Vdout0_5ck122 = 1.8 time = 2460
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=2460.1n

* CHECK dout0_6 Vdout0_6ck122 = 1.8 time = 2460
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=2460.1n

* CHECK dout0_7 Vdout0_7ck122 = 1.8 time = 2460
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=2460.1n

* CHECK dout0_8 Vdout0_8ck122 = 1.8 time = 2460
.meas tran vdout0_8ck122 FIND v(dout0_8) AT=2460.1n

* CHECK dout0_9 Vdout0_9ck122 = 0 time = 2460
.meas tran vdout0_9ck122 FIND v(dout0_9) AT=2460.1n

* CHECK dout0_10 Vdout0_10ck122 = 1.8 time = 2460
.meas tran vdout0_10ck122 FIND v(dout0_10) AT=2460.1n

* CHECK dout0_11 Vdout0_11ck122 = 0 time = 2460
.meas tran vdout0_11ck122 FIND v(dout0_11) AT=2460.1n

* CHECK dout0_12 Vdout0_12ck122 = 1.8 time = 2460
.meas tran vdout0_12ck122 FIND v(dout0_12) AT=2460.1n

* CHECK dout0_13 Vdout0_13ck122 = 0 time = 2460
.meas tran vdout0_13ck122 FIND v(dout0_13) AT=2460.1n

* CHECK dout0_14 Vdout0_14ck122 = 0 time = 2460
.meas tran vdout0_14ck122 FIND v(dout0_14) AT=2460.1n

* CHECK dout0_15 Vdout0_15ck122 = 1.8 time = 2460
.meas tran vdout0_15ck122 FIND v(dout0_15) AT=2460.1n

* CHECK dout0_0 Vdout0_0ck123 = 1.8 time = 2480
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=2480.1n

* CHECK dout0_1 Vdout0_1ck123 = 0 time = 2480
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=2480.1n

* CHECK dout0_2 Vdout0_2ck123 = 1.8 time = 2480
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=2480.1n

* CHECK dout0_3 Vdout0_3ck123 = 0 time = 2480
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=2480.1n

* CHECK dout0_4 Vdout0_4ck123 = 0 time = 2480
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=2480.1n

* CHECK dout0_5 Vdout0_5ck123 = 1.8 time = 2480
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=2480.1n

* CHECK dout0_6 Vdout0_6ck123 = 0 time = 2480
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=2480.1n

* CHECK dout0_7 Vdout0_7ck123 = 0 time = 2480
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=2480.1n

* CHECK dout0_8 Vdout0_8ck123 = 1.8 time = 2480
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=2480.1n

* CHECK dout0_9 Vdout0_9ck123 = 1.8 time = 2480
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=2480.1n

* CHECK dout0_10 Vdout0_10ck123 = 0 time = 2480
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=2480.1n

* CHECK dout0_11 Vdout0_11ck123 = 0 time = 2480
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=2480.1n

* CHECK dout0_12 Vdout0_12ck123 = 0 time = 2480
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=2480.1n

* CHECK dout0_13 Vdout0_13ck123 = 0 time = 2480
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=2480.1n

* CHECK dout0_14 Vdout0_14ck123 = 0 time = 2480
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=2480.1n

* CHECK dout0_15 Vdout0_15ck123 = 0 time = 2480
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=2480.1n

* CHECK dout0_0 Vdout0_0ck124 = 0 time = 2500
.meas tran vdout0_0ck124 FIND v(dout0_0) AT=2500.1n

* CHECK dout0_1 Vdout0_1ck124 = 0 time = 2500
.meas tran vdout0_1ck124 FIND v(dout0_1) AT=2500.1n

* CHECK dout0_2 Vdout0_2ck124 = 0 time = 2500
.meas tran vdout0_2ck124 FIND v(dout0_2) AT=2500.1n

* CHECK dout0_3 Vdout0_3ck124 = 0 time = 2500
.meas tran vdout0_3ck124 FIND v(dout0_3) AT=2500.1n

* CHECK dout0_4 Vdout0_4ck124 = 1.8 time = 2500
.meas tran vdout0_4ck124 FIND v(dout0_4) AT=2500.1n

* CHECK dout0_5 Vdout0_5ck124 = 0 time = 2500
.meas tran vdout0_5ck124 FIND v(dout0_5) AT=2500.1n

* CHECK dout0_6 Vdout0_6ck124 = 0 time = 2500
.meas tran vdout0_6ck124 FIND v(dout0_6) AT=2500.1n

* CHECK dout0_7 Vdout0_7ck124 = 0 time = 2500
.meas tran vdout0_7ck124 FIND v(dout0_7) AT=2500.1n

* CHECK dout0_8 Vdout0_8ck124 = 0 time = 2500
.meas tran vdout0_8ck124 FIND v(dout0_8) AT=2500.1n

* CHECK dout0_9 Vdout0_9ck124 = 1.8 time = 2500
.meas tran vdout0_9ck124 FIND v(dout0_9) AT=2500.1n

* CHECK dout0_10 Vdout0_10ck124 = 1.8 time = 2500
.meas tran vdout0_10ck124 FIND v(dout0_10) AT=2500.1n

* CHECK dout0_11 Vdout0_11ck124 = 0 time = 2500
.meas tran vdout0_11ck124 FIND v(dout0_11) AT=2500.1n

* CHECK dout0_12 Vdout0_12ck124 = 1.8 time = 2500
.meas tran vdout0_12ck124 FIND v(dout0_12) AT=2500.1n

* CHECK dout0_13 Vdout0_13ck124 = 0 time = 2500
.meas tran vdout0_13ck124 FIND v(dout0_13) AT=2500.1n

* CHECK dout0_14 Vdout0_14ck124 = 0 time = 2500
.meas tran vdout0_14ck124 FIND v(dout0_14) AT=2500.1n

* CHECK dout0_15 Vdout0_15ck124 = 0 time = 2500
.meas tran vdout0_15ck124 FIND v(dout0_15) AT=2500.1n

* CHECK dout0_0 Vdout0_0ck126 = 1.8 time = 2540
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=2540.1n

* CHECK dout0_1 Vdout0_1ck126 = 0 time = 2540
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=2540.1n

* CHECK dout0_2 Vdout0_2ck126 = 1.8 time = 2540
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=2540.1n

* CHECK dout0_3 Vdout0_3ck126 = 0 time = 2540
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=2540.1n

* CHECK dout0_4 Vdout0_4ck126 = 1.8 time = 2540
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=2540.1n

* CHECK dout0_5 Vdout0_5ck126 = 0 time = 2540
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=2540.1n

* CHECK dout0_6 Vdout0_6ck126 = 0 time = 2540
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=2540.1n

* CHECK dout0_7 Vdout0_7ck126 = 0 time = 2540
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=2540.1n

* CHECK dout0_8 Vdout0_8ck126 = 1.8 time = 2540
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=2540.1n

* CHECK dout0_9 Vdout0_9ck126 = 0 time = 2540
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=2540.1n

* CHECK dout0_10 Vdout0_10ck126 = 0 time = 2540
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=2540.1n

* CHECK dout0_11 Vdout0_11ck126 = 1.8 time = 2540
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=2540.1n

* CHECK dout0_12 Vdout0_12ck126 = 1.8 time = 2540
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=2540.1n

* CHECK dout0_13 Vdout0_13ck126 = 0 time = 2540
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=2540.1n

* CHECK dout0_14 Vdout0_14ck126 = 0 time = 2540
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=2540.1n

* CHECK dout0_15 Vdout0_15ck126 = 1.8 time = 2540
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=2540.1n

* CHECK dout0_0 Vdout0_0ck131 = 0 time = 2640
.meas tran vdout0_0ck131 FIND v(dout0_0) AT=2640.1n

* CHECK dout0_1 Vdout0_1ck131 = 0 time = 2640
.meas tran vdout0_1ck131 FIND v(dout0_1) AT=2640.1n

* CHECK dout0_2 Vdout0_2ck131 = 1.8 time = 2640
.meas tran vdout0_2ck131 FIND v(dout0_2) AT=2640.1n

* CHECK dout0_3 Vdout0_3ck131 = 1.8 time = 2640
.meas tran vdout0_3ck131 FIND v(dout0_3) AT=2640.1n

* CHECK dout0_4 Vdout0_4ck131 = 0 time = 2640
.meas tran vdout0_4ck131 FIND v(dout0_4) AT=2640.1n

* CHECK dout0_5 Vdout0_5ck131 = 0 time = 2640
.meas tran vdout0_5ck131 FIND v(dout0_5) AT=2640.1n

* CHECK dout0_6 Vdout0_6ck131 = 0 time = 2640
.meas tran vdout0_6ck131 FIND v(dout0_6) AT=2640.1n

* CHECK dout0_7 Vdout0_7ck131 = 1.8 time = 2640
.meas tran vdout0_7ck131 FIND v(dout0_7) AT=2640.1n

* CHECK dout0_8 Vdout0_8ck131 = 1.8 time = 2640
.meas tran vdout0_8ck131 FIND v(dout0_8) AT=2640.1n

* CHECK dout0_9 Vdout0_9ck131 = 1.8 time = 2640
.meas tran vdout0_9ck131 FIND v(dout0_9) AT=2640.1n

* CHECK dout0_10 Vdout0_10ck131 = 1.8 time = 2640
.meas tran vdout0_10ck131 FIND v(dout0_10) AT=2640.1n

* CHECK dout0_11 Vdout0_11ck131 = 0 time = 2640
.meas tran vdout0_11ck131 FIND v(dout0_11) AT=2640.1n

* CHECK dout0_12 Vdout0_12ck131 = 0 time = 2640
.meas tran vdout0_12ck131 FIND v(dout0_12) AT=2640.1n

* CHECK dout0_13 Vdout0_13ck131 = 0 time = 2640
.meas tran vdout0_13ck131 FIND v(dout0_13) AT=2640.1n

* CHECK dout0_14 Vdout0_14ck131 = 1.8 time = 2640
.meas tran vdout0_14ck131 FIND v(dout0_14) AT=2640.1n

* CHECK dout0_15 Vdout0_15ck131 = 0 time = 2640
.meas tran vdout0_15ck131 FIND v(dout0_15) AT=2640.1n

* CHECK dout0_0 Vdout0_0ck133 = 0 time = 2680
.meas tran vdout0_0ck133 FIND v(dout0_0) AT=2680.1n

* CHECK dout0_1 Vdout0_1ck133 = 1.8 time = 2680
.meas tran vdout0_1ck133 FIND v(dout0_1) AT=2680.1n

* CHECK dout0_2 Vdout0_2ck133 = 1.8 time = 2680
.meas tran vdout0_2ck133 FIND v(dout0_2) AT=2680.1n

* CHECK dout0_3 Vdout0_3ck133 = 1.8 time = 2680
.meas tran vdout0_3ck133 FIND v(dout0_3) AT=2680.1n

* CHECK dout0_4 Vdout0_4ck133 = 0 time = 2680
.meas tran vdout0_4ck133 FIND v(dout0_4) AT=2680.1n

* CHECK dout0_5 Vdout0_5ck133 = 0 time = 2680
.meas tran vdout0_5ck133 FIND v(dout0_5) AT=2680.1n

* CHECK dout0_6 Vdout0_6ck133 = 1.8 time = 2680
.meas tran vdout0_6ck133 FIND v(dout0_6) AT=2680.1n

* CHECK dout0_7 Vdout0_7ck133 = 0 time = 2680
.meas tran vdout0_7ck133 FIND v(dout0_7) AT=2680.1n

* CHECK dout0_8 Vdout0_8ck133 = 1.8 time = 2680
.meas tran vdout0_8ck133 FIND v(dout0_8) AT=2680.1n

* CHECK dout0_9 Vdout0_9ck133 = 0 time = 2680
.meas tran vdout0_9ck133 FIND v(dout0_9) AT=2680.1n

* CHECK dout0_10 Vdout0_10ck133 = 0 time = 2680
.meas tran vdout0_10ck133 FIND v(dout0_10) AT=2680.1n

* CHECK dout0_11 Vdout0_11ck133 = 0 time = 2680
.meas tran vdout0_11ck133 FIND v(dout0_11) AT=2680.1n

* CHECK dout0_12 Vdout0_12ck133 = 1.8 time = 2680
.meas tran vdout0_12ck133 FIND v(dout0_12) AT=2680.1n

* CHECK dout0_13 Vdout0_13ck133 = 1.8 time = 2680
.meas tran vdout0_13ck133 FIND v(dout0_13) AT=2680.1n

* CHECK dout0_14 Vdout0_14ck133 = 1.8 time = 2680
.meas tran vdout0_14ck133 FIND v(dout0_14) AT=2680.1n

* CHECK dout0_15 Vdout0_15ck133 = 1.8 time = 2680
.meas tran vdout0_15ck133 FIND v(dout0_15) AT=2680.1n

* CHECK dout0_0 Vdout0_0ck136 = 0 time = 2740
.meas tran vdout0_0ck136 FIND v(dout0_0) AT=2740.1n

* CHECK dout0_1 Vdout0_1ck136 = 0 time = 2740
.meas tran vdout0_1ck136 FIND v(dout0_1) AT=2740.1n

* CHECK dout0_2 Vdout0_2ck136 = 1.8 time = 2740
.meas tran vdout0_2ck136 FIND v(dout0_2) AT=2740.1n

* CHECK dout0_3 Vdout0_3ck136 = 1.8 time = 2740
.meas tran vdout0_3ck136 FIND v(dout0_3) AT=2740.1n

* CHECK dout0_4 Vdout0_4ck136 = 0 time = 2740
.meas tran vdout0_4ck136 FIND v(dout0_4) AT=2740.1n

* CHECK dout0_5 Vdout0_5ck136 = 0 time = 2740
.meas tran vdout0_5ck136 FIND v(dout0_5) AT=2740.1n

* CHECK dout0_6 Vdout0_6ck136 = 0 time = 2740
.meas tran vdout0_6ck136 FIND v(dout0_6) AT=2740.1n

* CHECK dout0_7 Vdout0_7ck136 = 1.8 time = 2740
.meas tran vdout0_7ck136 FIND v(dout0_7) AT=2740.1n

* CHECK dout0_8 Vdout0_8ck136 = 1.8 time = 2740
.meas tran vdout0_8ck136 FIND v(dout0_8) AT=2740.1n

* CHECK dout0_9 Vdout0_9ck136 = 1.8 time = 2740
.meas tran vdout0_9ck136 FIND v(dout0_9) AT=2740.1n

* CHECK dout0_10 Vdout0_10ck136 = 1.8 time = 2740
.meas tran vdout0_10ck136 FIND v(dout0_10) AT=2740.1n

* CHECK dout0_11 Vdout0_11ck136 = 0 time = 2740
.meas tran vdout0_11ck136 FIND v(dout0_11) AT=2740.1n

* CHECK dout0_12 Vdout0_12ck136 = 0 time = 2740
.meas tran vdout0_12ck136 FIND v(dout0_12) AT=2740.1n

* CHECK dout0_13 Vdout0_13ck136 = 0 time = 2740
.meas tran vdout0_13ck136 FIND v(dout0_13) AT=2740.1n

* CHECK dout0_14 Vdout0_14ck136 = 1.8 time = 2740
.meas tran vdout0_14ck136 FIND v(dout0_14) AT=2740.1n

* CHECK dout0_15 Vdout0_15ck136 = 0 time = 2740
.meas tran vdout0_15ck136 FIND v(dout0_15) AT=2740.1n

* CHECK dout0_0 Vdout0_0ck139 = 0 time = 2800
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=2800.1n

* CHECK dout0_1 Vdout0_1ck139 = 0 time = 2800
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=2800.1n

* CHECK dout0_2 Vdout0_2ck139 = 0 time = 2800
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=2800.1n

* CHECK dout0_3 Vdout0_3ck139 = 0 time = 2800
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=2800.1n

* CHECK dout0_4 Vdout0_4ck139 = 1.8 time = 2800
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=2800.1n

* CHECK dout0_5 Vdout0_5ck139 = 0 time = 2800
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=2800.1n

* CHECK dout0_6 Vdout0_6ck139 = 0 time = 2800
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=2800.1n

* CHECK dout0_7 Vdout0_7ck139 = 0 time = 2800
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=2800.1n

* CHECK dout0_8 Vdout0_8ck139 = 0 time = 2800
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=2800.1n

* CHECK dout0_9 Vdout0_9ck139 = 1.8 time = 2800
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=2800.1n

* CHECK dout0_10 Vdout0_10ck139 = 1.8 time = 2800
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=2800.1n

* CHECK dout0_11 Vdout0_11ck139 = 0 time = 2800
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=2800.1n

* CHECK dout0_12 Vdout0_12ck139 = 1.8 time = 2800
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=2800.1n

* CHECK dout0_13 Vdout0_13ck139 = 0 time = 2800
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=2800.1n

* CHECK dout0_14 Vdout0_14ck139 = 0 time = 2800
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=2800.1n

* CHECK dout0_15 Vdout0_15ck139 = 0 time = 2800
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=2800.1n

* CHECK dout0_0 Vdout0_0ck141 = 0 time = 2840
.meas tran vdout0_0ck141 FIND v(dout0_0) AT=2840.1n

* CHECK dout0_1 Vdout0_1ck141 = 1.8 time = 2840
.meas tran vdout0_1ck141 FIND v(dout0_1) AT=2840.1n

* CHECK dout0_2 Vdout0_2ck141 = 1.8 time = 2840
.meas tran vdout0_2ck141 FIND v(dout0_2) AT=2840.1n

* CHECK dout0_3 Vdout0_3ck141 = 1.8 time = 2840
.meas tran vdout0_3ck141 FIND v(dout0_3) AT=2840.1n

* CHECK dout0_4 Vdout0_4ck141 = 0 time = 2840
.meas tran vdout0_4ck141 FIND v(dout0_4) AT=2840.1n

* CHECK dout0_5 Vdout0_5ck141 = 0 time = 2840
.meas tran vdout0_5ck141 FIND v(dout0_5) AT=2840.1n

* CHECK dout0_6 Vdout0_6ck141 = 1.8 time = 2840
.meas tran vdout0_6ck141 FIND v(dout0_6) AT=2840.1n

* CHECK dout0_7 Vdout0_7ck141 = 0 time = 2840
.meas tran vdout0_7ck141 FIND v(dout0_7) AT=2840.1n

* CHECK dout0_8 Vdout0_8ck141 = 1.8 time = 2840
.meas tran vdout0_8ck141 FIND v(dout0_8) AT=2840.1n

* CHECK dout0_9 Vdout0_9ck141 = 0 time = 2840
.meas tran vdout0_9ck141 FIND v(dout0_9) AT=2840.1n

* CHECK dout0_10 Vdout0_10ck141 = 0 time = 2840
.meas tran vdout0_10ck141 FIND v(dout0_10) AT=2840.1n

* CHECK dout0_11 Vdout0_11ck141 = 0 time = 2840
.meas tran vdout0_11ck141 FIND v(dout0_11) AT=2840.1n

* CHECK dout0_12 Vdout0_12ck141 = 1.8 time = 2840
.meas tran vdout0_12ck141 FIND v(dout0_12) AT=2840.1n

* CHECK dout0_13 Vdout0_13ck141 = 1.8 time = 2840
.meas tran vdout0_13ck141 FIND v(dout0_13) AT=2840.1n

* CHECK dout0_14 Vdout0_14ck141 = 1.8 time = 2840
.meas tran vdout0_14ck141 FIND v(dout0_14) AT=2840.1n

* CHECK dout0_15 Vdout0_15ck141 = 1.8 time = 2840
.meas tran vdout0_15ck141 FIND v(dout0_15) AT=2840.1n

* CHECK dout0_0 Vdout0_0ck142 = 0 time = 2860
.meas tran vdout0_0ck142 FIND v(dout0_0) AT=2860.1n

* CHECK dout0_1 Vdout0_1ck142 = 1.8 time = 2860
.meas tran vdout0_1ck142 FIND v(dout0_1) AT=2860.1n

* CHECK dout0_2 Vdout0_2ck142 = 1.8 time = 2860
.meas tran vdout0_2ck142 FIND v(dout0_2) AT=2860.1n

* CHECK dout0_3 Vdout0_3ck142 = 0 time = 2860
.meas tran vdout0_3ck142 FIND v(dout0_3) AT=2860.1n

* CHECK dout0_4 Vdout0_4ck142 = 0 time = 2860
.meas tran vdout0_4ck142 FIND v(dout0_4) AT=2860.1n

* CHECK dout0_5 Vdout0_5ck142 = 1.8 time = 2860
.meas tran vdout0_5ck142 FIND v(dout0_5) AT=2860.1n

* CHECK dout0_6 Vdout0_6ck142 = 1.8 time = 2860
.meas tran vdout0_6ck142 FIND v(dout0_6) AT=2860.1n

* CHECK dout0_7 Vdout0_7ck142 = 1.8 time = 2860
.meas tran vdout0_7ck142 FIND v(dout0_7) AT=2860.1n

* CHECK dout0_8 Vdout0_8ck142 = 1.8 time = 2860
.meas tran vdout0_8ck142 FIND v(dout0_8) AT=2860.1n

* CHECK dout0_9 Vdout0_9ck142 = 1.8 time = 2860
.meas tran vdout0_9ck142 FIND v(dout0_9) AT=2860.1n

* CHECK dout0_10 Vdout0_10ck142 = 0 time = 2860
.meas tran vdout0_10ck142 FIND v(dout0_10) AT=2860.1n

* CHECK dout0_11 Vdout0_11ck142 = 1.8 time = 2860
.meas tran vdout0_11ck142 FIND v(dout0_11) AT=2860.1n

* CHECK dout0_12 Vdout0_12ck142 = 1.8 time = 2860
.meas tran vdout0_12ck142 FIND v(dout0_12) AT=2860.1n

* CHECK dout0_13 Vdout0_13ck142 = 0 time = 2860
.meas tran vdout0_13ck142 FIND v(dout0_13) AT=2860.1n

* CHECK dout0_14 Vdout0_14ck142 = 0 time = 2860
.meas tran vdout0_14ck142 FIND v(dout0_14) AT=2860.1n

* CHECK dout0_15 Vdout0_15ck142 = 1.8 time = 2860
.meas tran vdout0_15ck142 FIND v(dout0_15) AT=2860.1n

* CHECK dout0_0 Vdout0_0ck144 = 0 time = 2900
.meas tran vdout0_0ck144 FIND v(dout0_0) AT=2900.1n

* CHECK dout0_1 Vdout0_1ck144 = 1.8 time = 2900
.meas tran vdout0_1ck144 FIND v(dout0_1) AT=2900.1n

* CHECK dout0_2 Vdout0_2ck144 = 1.8 time = 2900
.meas tran vdout0_2ck144 FIND v(dout0_2) AT=2900.1n

* CHECK dout0_3 Vdout0_3ck144 = 1.8 time = 2900
.meas tran vdout0_3ck144 FIND v(dout0_3) AT=2900.1n

* CHECK dout0_4 Vdout0_4ck144 = 0 time = 2900
.meas tran vdout0_4ck144 FIND v(dout0_4) AT=2900.1n

* CHECK dout0_5 Vdout0_5ck144 = 0 time = 2900
.meas tran vdout0_5ck144 FIND v(dout0_5) AT=2900.1n

* CHECK dout0_6 Vdout0_6ck144 = 1.8 time = 2900
.meas tran vdout0_6ck144 FIND v(dout0_6) AT=2900.1n

* CHECK dout0_7 Vdout0_7ck144 = 0 time = 2900
.meas tran vdout0_7ck144 FIND v(dout0_7) AT=2900.1n

* CHECK dout0_8 Vdout0_8ck144 = 1.8 time = 2900
.meas tran vdout0_8ck144 FIND v(dout0_8) AT=2900.1n

* CHECK dout0_9 Vdout0_9ck144 = 0 time = 2900
.meas tran vdout0_9ck144 FIND v(dout0_9) AT=2900.1n

* CHECK dout0_10 Vdout0_10ck144 = 0 time = 2900
.meas tran vdout0_10ck144 FIND v(dout0_10) AT=2900.1n

* CHECK dout0_11 Vdout0_11ck144 = 0 time = 2900
.meas tran vdout0_11ck144 FIND v(dout0_11) AT=2900.1n

* CHECK dout0_12 Vdout0_12ck144 = 1.8 time = 2900
.meas tran vdout0_12ck144 FIND v(dout0_12) AT=2900.1n

* CHECK dout0_13 Vdout0_13ck144 = 1.8 time = 2900
.meas tran vdout0_13ck144 FIND v(dout0_13) AT=2900.1n

* CHECK dout0_14 Vdout0_14ck144 = 1.8 time = 2900
.meas tran vdout0_14ck144 FIND v(dout0_14) AT=2900.1n

* CHECK dout0_15 Vdout0_15ck144 = 1.8 time = 2900
.meas tran vdout0_15ck144 FIND v(dout0_15) AT=2900.1n

* CHECK dout0_0 Vdout0_0ck155 = 1.8 time = 3120
.meas tran vdout0_0ck155 FIND v(dout0_0) AT=3120.1n

* CHECK dout0_1 Vdout0_1ck155 = 0 time = 3120
.meas tran vdout0_1ck155 FIND v(dout0_1) AT=3120.1n

* CHECK dout0_2 Vdout0_2ck155 = 1.8 time = 3120
.meas tran vdout0_2ck155 FIND v(dout0_2) AT=3120.1n

* CHECK dout0_3 Vdout0_3ck155 = 1.8 time = 3120
.meas tran vdout0_3ck155 FIND v(dout0_3) AT=3120.1n

* CHECK dout0_4 Vdout0_4ck155 = 1.8 time = 3120
.meas tran vdout0_4ck155 FIND v(dout0_4) AT=3120.1n

* CHECK dout0_5 Vdout0_5ck155 = 1.8 time = 3120
.meas tran vdout0_5ck155 FIND v(dout0_5) AT=3120.1n

* CHECK dout0_6 Vdout0_6ck155 = 1.8 time = 3120
.meas tran vdout0_6ck155 FIND v(dout0_6) AT=3120.1n

* CHECK dout0_7 Vdout0_7ck155 = 1.8 time = 3120
.meas tran vdout0_7ck155 FIND v(dout0_7) AT=3120.1n

* CHECK dout0_8 Vdout0_8ck155 = 0 time = 3120
.meas tran vdout0_8ck155 FIND v(dout0_8) AT=3120.1n

* CHECK dout0_9 Vdout0_9ck155 = 0 time = 3120
.meas tran vdout0_9ck155 FIND v(dout0_9) AT=3120.1n

* CHECK dout0_10 Vdout0_10ck155 = 1.8 time = 3120
.meas tran vdout0_10ck155 FIND v(dout0_10) AT=3120.1n

* CHECK dout0_11 Vdout0_11ck155 = 0 time = 3120
.meas tran vdout0_11ck155 FIND v(dout0_11) AT=3120.1n

* CHECK dout0_12 Vdout0_12ck155 = 0 time = 3120
.meas tran vdout0_12ck155 FIND v(dout0_12) AT=3120.1n

* CHECK dout0_13 Vdout0_13ck155 = 0 time = 3120
.meas tran vdout0_13ck155 FIND v(dout0_13) AT=3120.1n

* CHECK dout0_14 Vdout0_14ck155 = 1.8 time = 3120
.meas tran vdout0_14ck155 FIND v(dout0_14) AT=3120.1n

* CHECK dout0_15 Vdout0_15ck155 = 1.8 time = 3120
.meas tran vdout0_15ck155 FIND v(dout0_15) AT=3120.1n

* CHECK dout0_0 Vdout0_0ck156 = 0 time = 3140
.meas tran vdout0_0ck156 FIND v(dout0_0) AT=3140.1n

* CHECK dout0_1 Vdout0_1ck156 = 1.8 time = 3140
.meas tran vdout0_1ck156 FIND v(dout0_1) AT=3140.1n

* CHECK dout0_2 Vdout0_2ck156 = 0 time = 3140
.meas tran vdout0_2ck156 FIND v(dout0_2) AT=3140.1n

* CHECK dout0_3 Vdout0_3ck156 = 1.8 time = 3140
.meas tran vdout0_3ck156 FIND v(dout0_3) AT=3140.1n

* CHECK dout0_4 Vdout0_4ck156 = 1.8 time = 3140
.meas tran vdout0_4ck156 FIND v(dout0_4) AT=3140.1n

* CHECK dout0_5 Vdout0_5ck156 = 1.8 time = 3140
.meas tran vdout0_5ck156 FIND v(dout0_5) AT=3140.1n

* CHECK dout0_6 Vdout0_6ck156 = 0 time = 3140
.meas tran vdout0_6ck156 FIND v(dout0_6) AT=3140.1n

* CHECK dout0_7 Vdout0_7ck156 = 1.8 time = 3140
.meas tran vdout0_7ck156 FIND v(dout0_7) AT=3140.1n

* CHECK dout0_8 Vdout0_8ck156 = 0 time = 3140
.meas tran vdout0_8ck156 FIND v(dout0_8) AT=3140.1n

* CHECK dout0_9 Vdout0_9ck156 = 0 time = 3140
.meas tran vdout0_9ck156 FIND v(dout0_9) AT=3140.1n

* CHECK dout0_10 Vdout0_10ck156 = 1.8 time = 3140
.meas tran vdout0_10ck156 FIND v(dout0_10) AT=3140.1n

* CHECK dout0_11 Vdout0_11ck156 = 1.8 time = 3140
.meas tran vdout0_11ck156 FIND v(dout0_11) AT=3140.1n

* CHECK dout0_12 Vdout0_12ck156 = 1.8 time = 3140
.meas tran vdout0_12ck156 FIND v(dout0_12) AT=3140.1n

* CHECK dout0_13 Vdout0_13ck156 = 1.8 time = 3140
.meas tran vdout0_13ck156 FIND v(dout0_13) AT=3140.1n

* CHECK dout0_14 Vdout0_14ck156 = 1.8 time = 3140
.meas tran vdout0_14ck156 FIND v(dout0_14) AT=3140.1n

* CHECK dout0_15 Vdout0_15ck156 = 0 time = 3140
.meas tran vdout0_15ck156 FIND v(dout0_15) AT=3140.1n

* CHECK dout0_0 Vdout0_0ck157 = 0 time = 3160
.meas tran vdout0_0ck157 FIND v(dout0_0) AT=3160.1n

* CHECK dout0_1 Vdout0_1ck157 = 1.8 time = 3160
.meas tran vdout0_1ck157 FIND v(dout0_1) AT=3160.1n

* CHECK dout0_2 Vdout0_2ck157 = 1.8 time = 3160
.meas tran vdout0_2ck157 FIND v(dout0_2) AT=3160.1n

* CHECK dout0_3 Vdout0_3ck157 = 0 time = 3160
.meas tran vdout0_3ck157 FIND v(dout0_3) AT=3160.1n

* CHECK dout0_4 Vdout0_4ck157 = 1.8 time = 3160
.meas tran vdout0_4ck157 FIND v(dout0_4) AT=3160.1n

* CHECK dout0_5 Vdout0_5ck157 = 1.8 time = 3160
.meas tran vdout0_5ck157 FIND v(dout0_5) AT=3160.1n

* CHECK dout0_6 Vdout0_6ck157 = 1.8 time = 3160
.meas tran vdout0_6ck157 FIND v(dout0_6) AT=3160.1n

* CHECK dout0_7 Vdout0_7ck157 = 0 time = 3160
.meas tran vdout0_7ck157 FIND v(dout0_7) AT=3160.1n

* CHECK dout0_8 Vdout0_8ck157 = 1.8 time = 3160
.meas tran vdout0_8ck157 FIND v(dout0_8) AT=3160.1n

* CHECK dout0_9 Vdout0_9ck157 = 0 time = 3160
.meas tran vdout0_9ck157 FIND v(dout0_9) AT=3160.1n

* CHECK dout0_10 Vdout0_10ck157 = 0 time = 3160
.meas tran vdout0_10ck157 FIND v(dout0_10) AT=3160.1n

* CHECK dout0_11 Vdout0_11ck157 = 1.8 time = 3160
.meas tran vdout0_11ck157 FIND v(dout0_11) AT=3160.1n

* CHECK dout0_12 Vdout0_12ck157 = 0 time = 3160
.meas tran vdout0_12ck157 FIND v(dout0_12) AT=3160.1n

* CHECK dout0_13 Vdout0_13ck157 = 0 time = 3160
.meas tran vdout0_13ck157 FIND v(dout0_13) AT=3160.1n

* CHECK dout0_14 Vdout0_14ck157 = 1.8 time = 3160
.meas tran vdout0_14ck157 FIND v(dout0_14) AT=3160.1n

* CHECK dout0_15 Vdout0_15ck157 = 0 time = 3160
.meas tran vdout0_15ck157 FIND v(dout0_15) AT=3160.1n

* CHECK dout0_0 Vdout0_0ck158 = 0 time = 3180
.meas tran vdout0_0ck158 FIND v(dout0_0) AT=3180.1n

* CHECK dout0_1 Vdout0_1ck158 = 1.8 time = 3180
.meas tran vdout0_1ck158 FIND v(dout0_1) AT=3180.1n

* CHECK dout0_2 Vdout0_2ck158 = 0 time = 3180
.meas tran vdout0_2ck158 FIND v(dout0_2) AT=3180.1n

* CHECK dout0_3 Vdout0_3ck158 = 1.8 time = 3180
.meas tran vdout0_3ck158 FIND v(dout0_3) AT=3180.1n

* CHECK dout0_4 Vdout0_4ck158 = 1.8 time = 3180
.meas tran vdout0_4ck158 FIND v(dout0_4) AT=3180.1n

* CHECK dout0_5 Vdout0_5ck158 = 1.8 time = 3180
.meas tran vdout0_5ck158 FIND v(dout0_5) AT=3180.1n

* CHECK dout0_6 Vdout0_6ck158 = 0 time = 3180
.meas tran vdout0_6ck158 FIND v(dout0_6) AT=3180.1n

* CHECK dout0_7 Vdout0_7ck158 = 1.8 time = 3180
.meas tran vdout0_7ck158 FIND v(dout0_7) AT=3180.1n

* CHECK dout0_8 Vdout0_8ck158 = 0 time = 3180
.meas tran vdout0_8ck158 FIND v(dout0_8) AT=3180.1n

* CHECK dout0_9 Vdout0_9ck158 = 0 time = 3180
.meas tran vdout0_9ck158 FIND v(dout0_9) AT=3180.1n

* CHECK dout0_10 Vdout0_10ck158 = 1.8 time = 3180
.meas tran vdout0_10ck158 FIND v(dout0_10) AT=3180.1n

* CHECK dout0_11 Vdout0_11ck158 = 1.8 time = 3180
.meas tran vdout0_11ck158 FIND v(dout0_11) AT=3180.1n

* CHECK dout0_12 Vdout0_12ck158 = 1.8 time = 3180
.meas tran vdout0_12ck158 FIND v(dout0_12) AT=3180.1n

* CHECK dout0_13 Vdout0_13ck158 = 1.8 time = 3180
.meas tran vdout0_13ck158 FIND v(dout0_13) AT=3180.1n

* CHECK dout0_14 Vdout0_14ck158 = 1.8 time = 3180
.meas tran vdout0_14ck158 FIND v(dout0_14) AT=3180.1n

* CHECK dout0_15 Vdout0_15ck158 = 0 time = 3180
.meas tran vdout0_15ck158 FIND v(dout0_15) AT=3180.1n

* CHECK dout0_0 Vdout0_0ck159 = 0 time = 3200
.meas tran vdout0_0ck159 FIND v(dout0_0) AT=3200.1n

* CHECK dout0_1 Vdout0_1ck159 = 1.8 time = 3200
.meas tran vdout0_1ck159 FIND v(dout0_1) AT=3200.1n

* CHECK dout0_2 Vdout0_2ck159 = 1.8 time = 3200
.meas tran vdout0_2ck159 FIND v(dout0_2) AT=3200.1n

* CHECK dout0_3 Vdout0_3ck159 = 0 time = 3200
.meas tran vdout0_3ck159 FIND v(dout0_3) AT=3200.1n

* CHECK dout0_4 Vdout0_4ck159 = 1.8 time = 3200
.meas tran vdout0_4ck159 FIND v(dout0_4) AT=3200.1n

* CHECK dout0_5 Vdout0_5ck159 = 1.8 time = 3200
.meas tran vdout0_5ck159 FIND v(dout0_5) AT=3200.1n

* CHECK dout0_6 Vdout0_6ck159 = 1.8 time = 3200
.meas tran vdout0_6ck159 FIND v(dout0_6) AT=3200.1n

* CHECK dout0_7 Vdout0_7ck159 = 0 time = 3200
.meas tran vdout0_7ck159 FIND v(dout0_7) AT=3200.1n

* CHECK dout0_8 Vdout0_8ck159 = 1.8 time = 3200
.meas tran vdout0_8ck159 FIND v(dout0_8) AT=3200.1n

* CHECK dout0_9 Vdout0_9ck159 = 0 time = 3200
.meas tran vdout0_9ck159 FIND v(dout0_9) AT=3200.1n

* CHECK dout0_10 Vdout0_10ck159 = 0 time = 3200
.meas tran vdout0_10ck159 FIND v(dout0_10) AT=3200.1n

* CHECK dout0_11 Vdout0_11ck159 = 1.8 time = 3200
.meas tran vdout0_11ck159 FIND v(dout0_11) AT=3200.1n

* CHECK dout0_12 Vdout0_12ck159 = 0 time = 3200
.meas tran vdout0_12ck159 FIND v(dout0_12) AT=3200.1n

* CHECK dout0_13 Vdout0_13ck159 = 0 time = 3200
.meas tran vdout0_13ck159 FIND v(dout0_13) AT=3200.1n

* CHECK dout0_14 Vdout0_14ck159 = 1.8 time = 3200
.meas tran vdout0_14ck159 FIND v(dout0_14) AT=3200.1n

* CHECK dout0_15 Vdout0_15ck159 = 0 time = 3200
.meas tran vdout0_15ck159 FIND v(dout0_15) AT=3200.1n

* CHECK dout0_0 Vdout0_0ck161 = 1.8 time = 3240
.meas tran vdout0_0ck161 FIND v(dout0_0) AT=3240.1n

* CHECK dout0_1 Vdout0_1ck161 = 0 time = 3240
.meas tran vdout0_1ck161 FIND v(dout0_1) AT=3240.1n

* CHECK dout0_2 Vdout0_2ck161 = 1.8 time = 3240
.meas tran vdout0_2ck161 FIND v(dout0_2) AT=3240.1n

* CHECK dout0_3 Vdout0_3ck161 = 0 time = 3240
.meas tran vdout0_3ck161 FIND v(dout0_3) AT=3240.1n

* CHECK dout0_4 Vdout0_4ck161 = 0 time = 3240
.meas tran vdout0_4ck161 FIND v(dout0_4) AT=3240.1n

* CHECK dout0_5 Vdout0_5ck161 = 0 time = 3240
.meas tran vdout0_5ck161 FIND v(dout0_5) AT=3240.1n

* CHECK dout0_6 Vdout0_6ck161 = 1.8 time = 3240
.meas tran vdout0_6ck161 FIND v(dout0_6) AT=3240.1n

* CHECK dout0_7 Vdout0_7ck161 = 1.8 time = 3240
.meas tran vdout0_7ck161 FIND v(dout0_7) AT=3240.1n

* CHECK dout0_8 Vdout0_8ck161 = 0 time = 3240
.meas tran vdout0_8ck161 FIND v(dout0_8) AT=3240.1n

* CHECK dout0_9 Vdout0_9ck161 = 1.8 time = 3240
.meas tran vdout0_9ck161 FIND v(dout0_9) AT=3240.1n

* CHECK dout0_10 Vdout0_10ck161 = 0 time = 3240
.meas tran vdout0_10ck161 FIND v(dout0_10) AT=3240.1n

* CHECK dout0_11 Vdout0_11ck161 = 1.8 time = 3240
.meas tran vdout0_11ck161 FIND v(dout0_11) AT=3240.1n

* CHECK dout0_12 Vdout0_12ck161 = 1.8 time = 3240
.meas tran vdout0_12ck161 FIND v(dout0_12) AT=3240.1n

* CHECK dout0_13 Vdout0_13ck161 = 0 time = 3240
.meas tran vdout0_13ck161 FIND v(dout0_13) AT=3240.1n

* CHECK dout0_14 Vdout0_14ck161 = 1.8 time = 3240
.meas tran vdout0_14ck161 FIND v(dout0_14) AT=3240.1n

* CHECK dout0_15 Vdout0_15ck161 = 1.8 time = 3240
.meas tran vdout0_15ck161 FIND v(dout0_15) AT=3240.1n

* CHECK dout0_0 Vdout0_0ck165 = 0 time = 3320
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=3320.1n

* CHECK dout0_1 Vdout0_1ck165 = 1.8 time = 3320
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=3320.1n

* CHECK dout0_2 Vdout0_2ck165 = 0 time = 3320
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=3320.1n

* CHECK dout0_3 Vdout0_3ck165 = 0 time = 3320
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=3320.1n

* CHECK dout0_4 Vdout0_4ck165 = 0 time = 3320
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=3320.1n

* CHECK dout0_5 Vdout0_5ck165 = 0 time = 3320
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=3320.1n

* CHECK dout0_6 Vdout0_6ck165 = 1.8 time = 3320
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=3320.1n

* CHECK dout0_7 Vdout0_7ck165 = 1.8 time = 3320
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=3320.1n

* CHECK dout0_8 Vdout0_8ck165 = 0 time = 3320
.meas tran vdout0_8ck165 FIND v(dout0_8) AT=3320.1n

* CHECK dout0_9 Vdout0_9ck165 = 0 time = 3320
.meas tran vdout0_9ck165 FIND v(dout0_9) AT=3320.1n

* CHECK dout0_10 Vdout0_10ck165 = 0 time = 3320
.meas tran vdout0_10ck165 FIND v(dout0_10) AT=3320.1n

* CHECK dout0_11 Vdout0_11ck165 = 0 time = 3320
.meas tran vdout0_11ck165 FIND v(dout0_11) AT=3320.1n

* CHECK dout0_12 Vdout0_12ck165 = 1.8 time = 3320
.meas tran vdout0_12ck165 FIND v(dout0_12) AT=3320.1n

* CHECK dout0_13 Vdout0_13ck165 = 1.8 time = 3320
.meas tran vdout0_13ck165 FIND v(dout0_13) AT=3320.1n

* CHECK dout0_14 Vdout0_14ck165 = 0 time = 3320
.meas tran vdout0_14ck165 FIND v(dout0_14) AT=3320.1n

* CHECK dout0_15 Vdout0_15ck165 = 1.8 time = 3320
.meas tran vdout0_15ck165 FIND v(dout0_15) AT=3320.1n

* CHECK dout0_0 Vdout0_0ck166 = 0 time = 3340
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=3340.1n

* CHECK dout0_1 Vdout0_1ck166 = 1.8 time = 3340
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=3340.1n

* CHECK dout0_2 Vdout0_2ck166 = 0 time = 3340
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=3340.1n

* CHECK dout0_3 Vdout0_3ck166 = 0 time = 3340
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=3340.1n

* CHECK dout0_4 Vdout0_4ck166 = 0 time = 3340
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=3340.1n

* CHECK dout0_5 Vdout0_5ck166 = 1.8 time = 3340
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=3340.1n

* CHECK dout0_6 Vdout0_6ck166 = 1.8 time = 3340
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=3340.1n

* CHECK dout0_7 Vdout0_7ck166 = 0 time = 3340
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=3340.1n

* CHECK dout0_8 Vdout0_8ck166 = 1.8 time = 3340
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=3340.1n

* CHECK dout0_9 Vdout0_9ck166 = 0 time = 3340
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=3340.1n

* CHECK dout0_10 Vdout0_10ck166 = 1.8 time = 3340
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=3340.1n

* CHECK dout0_11 Vdout0_11ck166 = 1.8 time = 3340
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=3340.1n

* CHECK dout0_12 Vdout0_12ck166 = 1.8 time = 3340
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=3340.1n

* CHECK dout0_13 Vdout0_13ck166 = 1.8 time = 3340
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=3340.1n

* CHECK dout0_14 Vdout0_14ck166 = 0 time = 3340
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=3340.1n

* CHECK dout0_15 Vdout0_15ck166 = 0 time = 3340
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=3340.1n

* CHECK dout0_0 Vdout0_0ck167 = 0 time = 3360
.meas tran vdout0_0ck167 FIND v(dout0_0) AT=3360.1n

* CHECK dout0_1 Vdout0_1ck167 = 0 time = 3360
.meas tran vdout0_1ck167 FIND v(dout0_1) AT=3360.1n

* CHECK dout0_2 Vdout0_2ck167 = 0 time = 3360
.meas tran vdout0_2ck167 FIND v(dout0_2) AT=3360.1n

* CHECK dout0_3 Vdout0_3ck167 = 1.8 time = 3360
.meas tran vdout0_3ck167 FIND v(dout0_3) AT=3360.1n

* CHECK dout0_4 Vdout0_4ck167 = 0 time = 3360
.meas tran vdout0_4ck167 FIND v(dout0_4) AT=3360.1n

* CHECK dout0_5 Vdout0_5ck167 = 1.8 time = 3360
.meas tran vdout0_5ck167 FIND v(dout0_5) AT=3360.1n

* CHECK dout0_6 Vdout0_6ck167 = 1.8 time = 3360
.meas tran vdout0_6ck167 FIND v(dout0_6) AT=3360.1n

* CHECK dout0_7 Vdout0_7ck167 = 1.8 time = 3360
.meas tran vdout0_7ck167 FIND v(dout0_7) AT=3360.1n

* CHECK dout0_8 Vdout0_8ck167 = 1.8 time = 3360
.meas tran vdout0_8ck167 FIND v(dout0_8) AT=3360.1n

* CHECK dout0_9 Vdout0_9ck167 = 0 time = 3360
.meas tran vdout0_9ck167 FIND v(dout0_9) AT=3360.1n

* CHECK dout0_10 Vdout0_10ck167 = 1.8 time = 3360
.meas tran vdout0_10ck167 FIND v(dout0_10) AT=3360.1n

* CHECK dout0_11 Vdout0_11ck167 = 0 time = 3360
.meas tran vdout0_11ck167 FIND v(dout0_11) AT=3360.1n

* CHECK dout0_12 Vdout0_12ck167 = 1.8 time = 3360
.meas tran vdout0_12ck167 FIND v(dout0_12) AT=3360.1n

* CHECK dout0_13 Vdout0_13ck167 = 0 time = 3360
.meas tran vdout0_13ck167 FIND v(dout0_13) AT=3360.1n

* CHECK dout0_14 Vdout0_14ck167 = 0 time = 3360
.meas tran vdout0_14ck167 FIND v(dout0_14) AT=3360.1n

* CHECK dout0_15 Vdout0_15ck167 = 1.8 time = 3360
.meas tran vdout0_15ck167 FIND v(dout0_15) AT=3360.1n

* CHECK dout0_0 Vdout0_0ck168 = 1.8 time = 3380
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=3380.1n

* CHECK dout0_1 Vdout0_1ck168 = 1.8 time = 3380
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=3380.1n

* CHECK dout0_2 Vdout0_2ck168 = 1.8 time = 3380
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=3380.1n

* CHECK dout0_3 Vdout0_3ck168 = 1.8 time = 3380
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=3380.1n

* CHECK dout0_4 Vdout0_4ck168 = 1.8 time = 3380
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=3380.1n

* CHECK dout0_5 Vdout0_5ck168 = 1.8 time = 3380
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=3380.1n

* CHECK dout0_6 Vdout0_6ck168 = 1.8 time = 3380
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=3380.1n

* CHECK dout0_7 Vdout0_7ck168 = 0 time = 3380
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=3380.1n

* CHECK dout0_8 Vdout0_8ck168 = 0 time = 3380
.meas tran vdout0_8ck168 FIND v(dout0_8) AT=3380.1n

* CHECK dout0_9 Vdout0_9ck168 = 0 time = 3380
.meas tran vdout0_9ck168 FIND v(dout0_9) AT=3380.1n

* CHECK dout0_10 Vdout0_10ck168 = 1.8 time = 3380
.meas tran vdout0_10ck168 FIND v(dout0_10) AT=3380.1n

* CHECK dout0_11 Vdout0_11ck168 = 1.8 time = 3380
.meas tran vdout0_11ck168 FIND v(dout0_11) AT=3380.1n

* CHECK dout0_12 Vdout0_12ck168 = 1.8 time = 3380
.meas tran vdout0_12ck168 FIND v(dout0_12) AT=3380.1n

* CHECK dout0_13 Vdout0_13ck168 = 0 time = 3380
.meas tran vdout0_13ck168 FIND v(dout0_13) AT=3380.1n

* CHECK dout0_14 Vdout0_14ck168 = 1.8 time = 3380
.meas tran vdout0_14ck168 FIND v(dout0_14) AT=3380.1n

* CHECK dout0_15 Vdout0_15ck168 = 0 time = 3380
.meas tran vdout0_15ck168 FIND v(dout0_15) AT=3380.1n

* CHECK dout0_0 Vdout0_0ck169 = 1.8 time = 3400
.meas tran vdout0_0ck169 FIND v(dout0_0) AT=3400.1n

* CHECK dout0_1 Vdout0_1ck169 = 1.8 time = 3400
.meas tran vdout0_1ck169 FIND v(dout0_1) AT=3400.1n

* CHECK dout0_2 Vdout0_2ck169 = 1.8 time = 3400
.meas tran vdout0_2ck169 FIND v(dout0_2) AT=3400.1n

* CHECK dout0_3 Vdout0_3ck169 = 0 time = 3400
.meas tran vdout0_3ck169 FIND v(dout0_3) AT=3400.1n

* CHECK dout0_4 Vdout0_4ck169 = 1.8 time = 3400
.meas tran vdout0_4ck169 FIND v(dout0_4) AT=3400.1n

* CHECK dout0_5 Vdout0_5ck169 = 0 time = 3400
.meas tran vdout0_5ck169 FIND v(dout0_5) AT=3400.1n

* CHECK dout0_6 Vdout0_6ck169 = 0 time = 3400
.meas tran vdout0_6ck169 FIND v(dout0_6) AT=3400.1n

* CHECK dout0_7 Vdout0_7ck169 = 0 time = 3400
.meas tran vdout0_7ck169 FIND v(dout0_7) AT=3400.1n

* CHECK dout0_8 Vdout0_8ck169 = 0 time = 3400
.meas tran vdout0_8ck169 FIND v(dout0_8) AT=3400.1n

* CHECK dout0_9 Vdout0_9ck169 = 1.8 time = 3400
.meas tran vdout0_9ck169 FIND v(dout0_9) AT=3400.1n

* CHECK dout0_10 Vdout0_10ck169 = 1.8 time = 3400
.meas tran vdout0_10ck169 FIND v(dout0_10) AT=3400.1n

* CHECK dout0_11 Vdout0_11ck169 = 1.8 time = 3400
.meas tran vdout0_11ck169 FIND v(dout0_11) AT=3400.1n

* CHECK dout0_12 Vdout0_12ck169 = 0 time = 3400
.meas tran vdout0_12ck169 FIND v(dout0_12) AT=3400.1n

* CHECK dout0_13 Vdout0_13ck169 = 1.8 time = 3400
.meas tran vdout0_13ck169 FIND v(dout0_13) AT=3400.1n

* CHECK dout0_14 Vdout0_14ck169 = 0 time = 3400
.meas tran vdout0_14ck169 FIND v(dout0_14) AT=3400.1n

* CHECK dout0_15 Vdout0_15ck169 = 1.8 time = 3400
.meas tran vdout0_15ck169 FIND v(dout0_15) AT=3400.1n

* CHECK dout0_0 Vdout0_0ck170 = 0 time = 3420
.meas tran vdout0_0ck170 FIND v(dout0_0) AT=3420.1n

* CHECK dout0_1 Vdout0_1ck170 = 0 time = 3420
.meas tran vdout0_1ck170 FIND v(dout0_1) AT=3420.1n

* CHECK dout0_2 Vdout0_2ck170 = 0 time = 3420
.meas tran vdout0_2ck170 FIND v(dout0_2) AT=3420.1n

* CHECK dout0_3 Vdout0_3ck170 = 1.8 time = 3420
.meas tran vdout0_3ck170 FIND v(dout0_3) AT=3420.1n

* CHECK dout0_4 Vdout0_4ck170 = 0 time = 3420
.meas tran vdout0_4ck170 FIND v(dout0_4) AT=3420.1n

* CHECK dout0_5 Vdout0_5ck170 = 1.8 time = 3420
.meas tran vdout0_5ck170 FIND v(dout0_5) AT=3420.1n

* CHECK dout0_6 Vdout0_6ck170 = 1.8 time = 3420
.meas tran vdout0_6ck170 FIND v(dout0_6) AT=3420.1n

* CHECK dout0_7 Vdout0_7ck170 = 1.8 time = 3420
.meas tran vdout0_7ck170 FIND v(dout0_7) AT=3420.1n

* CHECK dout0_8 Vdout0_8ck170 = 1.8 time = 3420
.meas tran vdout0_8ck170 FIND v(dout0_8) AT=3420.1n

* CHECK dout0_9 Vdout0_9ck170 = 0 time = 3420
.meas tran vdout0_9ck170 FIND v(dout0_9) AT=3420.1n

* CHECK dout0_10 Vdout0_10ck170 = 1.8 time = 3420
.meas tran vdout0_10ck170 FIND v(dout0_10) AT=3420.1n

* CHECK dout0_11 Vdout0_11ck170 = 0 time = 3420
.meas tran vdout0_11ck170 FIND v(dout0_11) AT=3420.1n

* CHECK dout0_12 Vdout0_12ck170 = 1.8 time = 3420
.meas tran vdout0_12ck170 FIND v(dout0_12) AT=3420.1n

* CHECK dout0_13 Vdout0_13ck170 = 0 time = 3420
.meas tran vdout0_13ck170 FIND v(dout0_13) AT=3420.1n

* CHECK dout0_14 Vdout0_14ck170 = 0 time = 3420
.meas tran vdout0_14ck170 FIND v(dout0_14) AT=3420.1n

* CHECK dout0_15 Vdout0_15ck170 = 1.8 time = 3420
.meas tran vdout0_15ck170 FIND v(dout0_15) AT=3420.1n

* CHECK dout0_0 Vdout0_0ck173 = 1.8 time = 3480
.meas tran vdout0_0ck173 FIND v(dout0_0) AT=3480.1n

* CHECK dout0_1 Vdout0_1ck173 = 0 time = 3480
.meas tran vdout0_1ck173 FIND v(dout0_1) AT=3480.1n

* CHECK dout0_2 Vdout0_2ck173 = 1.8 time = 3480
.meas tran vdout0_2ck173 FIND v(dout0_2) AT=3480.1n

* CHECK dout0_3 Vdout0_3ck173 = 1.8 time = 3480
.meas tran vdout0_3ck173 FIND v(dout0_3) AT=3480.1n

* CHECK dout0_4 Vdout0_4ck173 = 0 time = 3480
.meas tran vdout0_4ck173 FIND v(dout0_4) AT=3480.1n

* CHECK dout0_5 Vdout0_5ck173 = 0 time = 3480
.meas tran vdout0_5ck173 FIND v(dout0_5) AT=3480.1n

* CHECK dout0_6 Vdout0_6ck173 = 0 time = 3480
.meas tran vdout0_6ck173 FIND v(dout0_6) AT=3480.1n

* CHECK dout0_7 Vdout0_7ck173 = 0 time = 3480
.meas tran vdout0_7ck173 FIND v(dout0_7) AT=3480.1n

* CHECK dout0_8 Vdout0_8ck173 = 1.8 time = 3480
.meas tran vdout0_8ck173 FIND v(dout0_8) AT=3480.1n

* CHECK dout0_9 Vdout0_9ck173 = 0 time = 3480
.meas tran vdout0_9ck173 FIND v(dout0_9) AT=3480.1n

* CHECK dout0_10 Vdout0_10ck173 = 0 time = 3480
.meas tran vdout0_10ck173 FIND v(dout0_10) AT=3480.1n

* CHECK dout0_11 Vdout0_11ck173 = 0 time = 3480
.meas tran vdout0_11ck173 FIND v(dout0_11) AT=3480.1n

* CHECK dout0_12 Vdout0_12ck173 = 1.8 time = 3480
.meas tran vdout0_12ck173 FIND v(dout0_12) AT=3480.1n

* CHECK dout0_13 Vdout0_13ck173 = 0 time = 3480
.meas tran vdout0_13ck173 FIND v(dout0_13) AT=3480.1n

* CHECK dout0_14 Vdout0_14ck173 = 0 time = 3480
.meas tran vdout0_14ck173 FIND v(dout0_14) AT=3480.1n

* CHECK dout0_15 Vdout0_15ck173 = 0 time = 3480
.meas tran vdout0_15ck173 FIND v(dout0_15) AT=3480.1n

* CHECK dout0_0 Vdout0_0ck174 = 1.8 time = 3500
.meas tran vdout0_0ck174 FIND v(dout0_0) AT=3500.1n

* CHECK dout0_1 Vdout0_1ck174 = 0 time = 3500
.meas tran vdout0_1ck174 FIND v(dout0_1) AT=3500.1n

* CHECK dout0_2 Vdout0_2ck174 = 1.8 time = 3500
.meas tran vdout0_2ck174 FIND v(dout0_2) AT=3500.1n

* CHECK dout0_3 Vdout0_3ck174 = 0 time = 3500
.meas tran vdout0_3ck174 FIND v(dout0_3) AT=3500.1n

* CHECK dout0_4 Vdout0_4ck174 = 0 time = 3500
.meas tran vdout0_4ck174 FIND v(dout0_4) AT=3500.1n

* CHECK dout0_5 Vdout0_5ck174 = 0 time = 3500
.meas tran vdout0_5ck174 FIND v(dout0_5) AT=3500.1n

* CHECK dout0_6 Vdout0_6ck174 = 1.8 time = 3500
.meas tran vdout0_6ck174 FIND v(dout0_6) AT=3500.1n

* CHECK dout0_7 Vdout0_7ck174 = 1.8 time = 3500
.meas tran vdout0_7ck174 FIND v(dout0_7) AT=3500.1n

* CHECK dout0_8 Vdout0_8ck174 = 0 time = 3500
.meas tran vdout0_8ck174 FIND v(dout0_8) AT=3500.1n

* CHECK dout0_9 Vdout0_9ck174 = 1.8 time = 3500
.meas tran vdout0_9ck174 FIND v(dout0_9) AT=3500.1n

* CHECK dout0_10 Vdout0_10ck174 = 0 time = 3500
.meas tran vdout0_10ck174 FIND v(dout0_10) AT=3500.1n

* CHECK dout0_11 Vdout0_11ck174 = 1.8 time = 3500
.meas tran vdout0_11ck174 FIND v(dout0_11) AT=3500.1n

* CHECK dout0_12 Vdout0_12ck174 = 1.8 time = 3500
.meas tran vdout0_12ck174 FIND v(dout0_12) AT=3500.1n

* CHECK dout0_13 Vdout0_13ck174 = 0 time = 3500
.meas tran vdout0_13ck174 FIND v(dout0_13) AT=3500.1n

* CHECK dout0_14 Vdout0_14ck174 = 1.8 time = 3500
.meas tran vdout0_14ck174 FIND v(dout0_14) AT=3500.1n

* CHECK dout0_15 Vdout0_15ck174 = 1.8 time = 3500
.meas tran vdout0_15ck174 FIND v(dout0_15) AT=3500.1n

* CHECK dout0_0 Vdout0_0ck176 = 1.8 time = 3540
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=3540.1n

* CHECK dout0_1 Vdout0_1ck176 = 1.8 time = 3540
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=3540.1n

* CHECK dout0_2 Vdout0_2ck176 = 1.8 time = 3540
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=3540.1n

* CHECK dout0_3 Vdout0_3ck176 = 1.8 time = 3540
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=3540.1n

* CHECK dout0_4 Vdout0_4ck176 = 1.8 time = 3540
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=3540.1n

* CHECK dout0_5 Vdout0_5ck176 = 1.8 time = 3540
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=3540.1n

* CHECK dout0_6 Vdout0_6ck176 = 1.8 time = 3540
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=3540.1n

* CHECK dout0_7 Vdout0_7ck176 = 0 time = 3540
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=3540.1n

* CHECK dout0_8 Vdout0_8ck176 = 0 time = 3540
.meas tran vdout0_8ck176 FIND v(dout0_8) AT=3540.1n

* CHECK dout0_9 Vdout0_9ck176 = 0 time = 3540
.meas tran vdout0_9ck176 FIND v(dout0_9) AT=3540.1n

* CHECK dout0_10 Vdout0_10ck176 = 1.8 time = 3540
.meas tran vdout0_10ck176 FIND v(dout0_10) AT=3540.1n

* CHECK dout0_11 Vdout0_11ck176 = 1.8 time = 3540
.meas tran vdout0_11ck176 FIND v(dout0_11) AT=3540.1n

* CHECK dout0_12 Vdout0_12ck176 = 1.8 time = 3540
.meas tran vdout0_12ck176 FIND v(dout0_12) AT=3540.1n

* CHECK dout0_13 Vdout0_13ck176 = 0 time = 3540
.meas tran vdout0_13ck176 FIND v(dout0_13) AT=3540.1n

* CHECK dout0_14 Vdout0_14ck176 = 1.8 time = 3540
.meas tran vdout0_14ck176 FIND v(dout0_14) AT=3540.1n

* CHECK dout0_15 Vdout0_15ck176 = 0 time = 3540
.meas tran vdout0_15ck176 FIND v(dout0_15) AT=3540.1n

* CHECK dout0_0 Vdout0_0ck177 = 1.8 time = 3560
.meas tran vdout0_0ck177 FIND v(dout0_0) AT=3560.1n

* CHECK dout0_1 Vdout0_1ck177 = 0 time = 3560
.meas tran vdout0_1ck177 FIND v(dout0_1) AT=3560.1n

* CHECK dout0_2 Vdout0_2ck177 = 1.8 time = 3560
.meas tran vdout0_2ck177 FIND v(dout0_2) AT=3560.1n

* CHECK dout0_3 Vdout0_3ck177 = 1.8 time = 3560
.meas tran vdout0_3ck177 FIND v(dout0_3) AT=3560.1n

* CHECK dout0_4 Vdout0_4ck177 = 0 time = 3560
.meas tran vdout0_4ck177 FIND v(dout0_4) AT=3560.1n

* CHECK dout0_5 Vdout0_5ck177 = 0 time = 3560
.meas tran vdout0_5ck177 FIND v(dout0_5) AT=3560.1n

* CHECK dout0_6 Vdout0_6ck177 = 0 time = 3560
.meas tran vdout0_6ck177 FIND v(dout0_6) AT=3560.1n

* CHECK dout0_7 Vdout0_7ck177 = 0 time = 3560
.meas tran vdout0_7ck177 FIND v(dout0_7) AT=3560.1n

* CHECK dout0_8 Vdout0_8ck177 = 1.8 time = 3560
.meas tran vdout0_8ck177 FIND v(dout0_8) AT=3560.1n

* CHECK dout0_9 Vdout0_9ck177 = 0 time = 3560
.meas tran vdout0_9ck177 FIND v(dout0_9) AT=3560.1n

* CHECK dout0_10 Vdout0_10ck177 = 0 time = 3560
.meas tran vdout0_10ck177 FIND v(dout0_10) AT=3560.1n

* CHECK dout0_11 Vdout0_11ck177 = 0 time = 3560
.meas tran vdout0_11ck177 FIND v(dout0_11) AT=3560.1n

* CHECK dout0_12 Vdout0_12ck177 = 1.8 time = 3560
.meas tran vdout0_12ck177 FIND v(dout0_12) AT=3560.1n

* CHECK dout0_13 Vdout0_13ck177 = 0 time = 3560
.meas tran vdout0_13ck177 FIND v(dout0_13) AT=3560.1n

* CHECK dout0_14 Vdout0_14ck177 = 0 time = 3560
.meas tran vdout0_14ck177 FIND v(dout0_14) AT=3560.1n

* CHECK dout0_15 Vdout0_15ck177 = 0 time = 3560
.meas tran vdout0_15ck177 FIND v(dout0_15) AT=3560.1n

* CHECK dout0_0 Vdout0_0ck180 = 0 time = 3620
.meas tran vdout0_0ck180 FIND v(dout0_0) AT=3620.1n

* CHECK dout0_1 Vdout0_1ck180 = 0 time = 3620
.meas tran vdout0_1ck180 FIND v(dout0_1) AT=3620.1n

* CHECK dout0_2 Vdout0_2ck180 = 1.8 time = 3620
.meas tran vdout0_2ck180 FIND v(dout0_2) AT=3620.1n

* CHECK dout0_3 Vdout0_3ck180 = 0 time = 3620
.meas tran vdout0_3ck180 FIND v(dout0_3) AT=3620.1n

* CHECK dout0_4 Vdout0_4ck180 = 1.8 time = 3620
.meas tran vdout0_4ck180 FIND v(dout0_4) AT=3620.1n

* CHECK dout0_5 Vdout0_5ck180 = 0 time = 3620
.meas tran vdout0_5ck180 FIND v(dout0_5) AT=3620.1n

* CHECK dout0_6 Vdout0_6ck180 = 0 time = 3620
.meas tran vdout0_6ck180 FIND v(dout0_6) AT=3620.1n

* CHECK dout0_7 Vdout0_7ck180 = 1.8 time = 3620
.meas tran vdout0_7ck180 FIND v(dout0_7) AT=3620.1n

* CHECK dout0_8 Vdout0_8ck180 = 0 time = 3620
.meas tran vdout0_8ck180 FIND v(dout0_8) AT=3620.1n

* CHECK dout0_9 Vdout0_9ck180 = 0 time = 3620
.meas tran vdout0_9ck180 FIND v(dout0_9) AT=3620.1n

* CHECK dout0_10 Vdout0_10ck180 = 0 time = 3620
.meas tran vdout0_10ck180 FIND v(dout0_10) AT=3620.1n

* CHECK dout0_11 Vdout0_11ck180 = 1.8 time = 3620
.meas tran vdout0_11ck180 FIND v(dout0_11) AT=3620.1n

* CHECK dout0_12 Vdout0_12ck180 = 0 time = 3620
.meas tran vdout0_12ck180 FIND v(dout0_12) AT=3620.1n

* CHECK dout0_13 Vdout0_13ck180 = 1.8 time = 3620
.meas tran vdout0_13ck180 FIND v(dout0_13) AT=3620.1n

* CHECK dout0_14 Vdout0_14ck180 = 1.8 time = 3620
.meas tran vdout0_14ck180 FIND v(dout0_14) AT=3620.1n

* CHECK dout0_15 Vdout0_15ck180 = 1.8 time = 3620
.meas tran vdout0_15ck180 FIND v(dout0_15) AT=3620.1n

* CHECK dout0_0 Vdout0_0ck181 = 1.8 time = 3640
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=3640.1n

* CHECK dout0_1 Vdout0_1ck181 = 0 time = 3640
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=3640.1n

* CHECK dout0_2 Vdout0_2ck181 = 1.8 time = 3640
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=3640.1n

* CHECK dout0_3 Vdout0_3ck181 = 1.8 time = 3640
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=3640.1n

* CHECK dout0_4 Vdout0_4ck181 = 0 time = 3640
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=3640.1n

* CHECK dout0_5 Vdout0_5ck181 = 0 time = 3640
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=3640.1n

* CHECK dout0_6 Vdout0_6ck181 = 0 time = 3640
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=3640.1n

* CHECK dout0_7 Vdout0_7ck181 = 0 time = 3640
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=3640.1n

* CHECK dout0_8 Vdout0_8ck181 = 1.8 time = 3640
.meas tran vdout0_8ck181 FIND v(dout0_8) AT=3640.1n

* CHECK dout0_9 Vdout0_9ck181 = 0 time = 3640
.meas tran vdout0_9ck181 FIND v(dout0_9) AT=3640.1n

* CHECK dout0_10 Vdout0_10ck181 = 0 time = 3640
.meas tran vdout0_10ck181 FIND v(dout0_10) AT=3640.1n

* CHECK dout0_11 Vdout0_11ck181 = 0 time = 3640
.meas tran vdout0_11ck181 FIND v(dout0_11) AT=3640.1n

* CHECK dout0_12 Vdout0_12ck181 = 1.8 time = 3640
.meas tran vdout0_12ck181 FIND v(dout0_12) AT=3640.1n

* CHECK dout0_13 Vdout0_13ck181 = 0 time = 3640
.meas tran vdout0_13ck181 FIND v(dout0_13) AT=3640.1n

* CHECK dout0_14 Vdout0_14ck181 = 0 time = 3640
.meas tran vdout0_14ck181 FIND v(dout0_14) AT=3640.1n

* CHECK dout0_15 Vdout0_15ck181 = 0 time = 3640
.meas tran vdout0_15ck181 FIND v(dout0_15) AT=3640.1n

* CHECK dout0_0 Vdout0_0ck183 = 0 time = 3680
.meas tran vdout0_0ck183 FIND v(dout0_0) AT=3680.1n

* CHECK dout0_1 Vdout0_1ck183 = 0 time = 3680
.meas tran vdout0_1ck183 FIND v(dout0_1) AT=3680.1n

* CHECK dout0_2 Vdout0_2ck183 = 1.8 time = 3680
.meas tran vdout0_2ck183 FIND v(dout0_2) AT=3680.1n

* CHECK dout0_3 Vdout0_3ck183 = 0 time = 3680
.meas tran vdout0_3ck183 FIND v(dout0_3) AT=3680.1n

* CHECK dout0_4 Vdout0_4ck183 = 1.8 time = 3680
.meas tran vdout0_4ck183 FIND v(dout0_4) AT=3680.1n

* CHECK dout0_5 Vdout0_5ck183 = 0 time = 3680
.meas tran vdout0_5ck183 FIND v(dout0_5) AT=3680.1n

* CHECK dout0_6 Vdout0_6ck183 = 0 time = 3680
.meas tran vdout0_6ck183 FIND v(dout0_6) AT=3680.1n

* CHECK dout0_7 Vdout0_7ck183 = 1.8 time = 3680
.meas tran vdout0_7ck183 FIND v(dout0_7) AT=3680.1n

* CHECK dout0_8 Vdout0_8ck183 = 0 time = 3680
.meas tran vdout0_8ck183 FIND v(dout0_8) AT=3680.1n

* CHECK dout0_9 Vdout0_9ck183 = 0 time = 3680
.meas tran vdout0_9ck183 FIND v(dout0_9) AT=3680.1n

* CHECK dout0_10 Vdout0_10ck183 = 0 time = 3680
.meas tran vdout0_10ck183 FIND v(dout0_10) AT=3680.1n

* CHECK dout0_11 Vdout0_11ck183 = 1.8 time = 3680
.meas tran vdout0_11ck183 FIND v(dout0_11) AT=3680.1n

* CHECK dout0_12 Vdout0_12ck183 = 0 time = 3680
.meas tran vdout0_12ck183 FIND v(dout0_12) AT=3680.1n

* CHECK dout0_13 Vdout0_13ck183 = 1.8 time = 3680
.meas tran vdout0_13ck183 FIND v(dout0_13) AT=3680.1n

* CHECK dout0_14 Vdout0_14ck183 = 1.8 time = 3680
.meas tran vdout0_14ck183 FIND v(dout0_14) AT=3680.1n

* CHECK dout0_15 Vdout0_15ck183 = 1.8 time = 3680
.meas tran vdout0_15ck183 FIND v(dout0_15) AT=3680.1n

* CHECK dout0_0 Vdout0_0ck187 = 0 time = 3760
.meas tran vdout0_0ck187 FIND v(dout0_0) AT=3760.1n

* CHECK dout0_1 Vdout0_1ck187 = 0 time = 3760
.meas tran vdout0_1ck187 FIND v(dout0_1) AT=3760.1n

* CHECK dout0_2 Vdout0_2ck187 = 1.8 time = 3760
.meas tran vdout0_2ck187 FIND v(dout0_2) AT=3760.1n

* CHECK dout0_3 Vdout0_3ck187 = 0 time = 3760
.meas tran vdout0_3ck187 FIND v(dout0_3) AT=3760.1n

* CHECK dout0_4 Vdout0_4ck187 = 1.8 time = 3760
.meas tran vdout0_4ck187 FIND v(dout0_4) AT=3760.1n

* CHECK dout0_5 Vdout0_5ck187 = 0 time = 3760
.meas tran vdout0_5ck187 FIND v(dout0_5) AT=3760.1n

* CHECK dout0_6 Vdout0_6ck187 = 0 time = 3760
.meas tran vdout0_6ck187 FIND v(dout0_6) AT=3760.1n

* CHECK dout0_7 Vdout0_7ck187 = 1.8 time = 3760
.meas tran vdout0_7ck187 FIND v(dout0_7) AT=3760.1n

* CHECK dout0_8 Vdout0_8ck187 = 0 time = 3760
.meas tran vdout0_8ck187 FIND v(dout0_8) AT=3760.1n

* CHECK dout0_9 Vdout0_9ck187 = 0 time = 3760
.meas tran vdout0_9ck187 FIND v(dout0_9) AT=3760.1n

* CHECK dout0_10 Vdout0_10ck187 = 0 time = 3760
.meas tran vdout0_10ck187 FIND v(dout0_10) AT=3760.1n

* CHECK dout0_11 Vdout0_11ck187 = 1.8 time = 3760
.meas tran vdout0_11ck187 FIND v(dout0_11) AT=3760.1n

* CHECK dout0_12 Vdout0_12ck187 = 0 time = 3760
.meas tran vdout0_12ck187 FIND v(dout0_12) AT=3760.1n

* CHECK dout0_13 Vdout0_13ck187 = 1.8 time = 3760
.meas tran vdout0_13ck187 FIND v(dout0_13) AT=3760.1n

* CHECK dout0_14 Vdout0_14ck187 = 1.8 time = 3760
.meas tran vdout0_14ck187 FIND v(dout0_14) AT=3760.1n

* CHECK dout0_15 Vdout0_15ck187 = 1.8 time = 3760
.meas tran vdout0_15ck187 FIND v(dout0_15) AT=3760.1n

* CHECK dout0_0 Vdout0_0ck189 = 0 time = 3800
.meas tran vdout0_0ck189 FIND v(dout0_0) AT=3800.1n

* CHECK dout0_1 Vdout0_1ck189 = 1.8 time = 3800
.meas tran vdout0_1ck189 FIND v(dout0_1) AT=3800.1n

* CHECK dout0_2 Vdout0_2ck189 = 0 time = 3800
.meas tran vdout0_2ck189 FIND v(dout0_2) AT=3800.1n

* CHECK dout0_3 Vdout0_3ck189 = 0 time = 3800
.meas tran vdout0_3ck189 FIND v(dout0_3) AT=3800.1n

* CHECK dout0_4 Vdout0_4ck189 = 0 time = 3800
.meas tran vdout0_4ck189 FIND v(dout0_4) AT=3800.1n

* CHECK dout0_5 Vdout0_5ck189 = 0 time = 3800
.meas tran vdout0_5ck189 FIND v(dout0_5) AT=3800.1n

* CHECK dout0_6 Vdout0_6ck189 = 1.8 time = 3800
.meas tran vdout0_6ck189 FIND v(dout0_6) AT=3800.1n

* CHECK dout0_7 Vdout0_7ck189 = 1.8 time = 3800
.meas tran vdout0_7ck189 FIND v(dout0_7) AT=3800.1n

* CHECK dout0_8 Vdout0_8ck189 = 0 time = 3800
.meas tran vdout0_8ck189 FIND v(dout0_8) AT=3800.1n

* CHECK dout0_9 Vdout0_9ck189 = 0 time = 3800
.meas tran vdout0_9ck189 FIND v(dout0_9) AT=3800.1n

* CHECK dout0_10 Vdout0_10ck189 = 0 time = 3800
.meas tran vdout0_10ck189 FIND v(dout0_10) AT=3800.1n

* CHECK dout0_11 Vdout0_11ck189 = 0 time = 3800
.meas tran vdout0_11ck189 FIND v(dout0_11) AT=3800.1n

* CHECK dout0_12 Vdout0_12ck189 = 1.8 time = 3800
.meas tran vdout0_12ck189 FIND v(dout0_12) AT=3800.1n

* CHECK dout0_13 Vdout0_13ck189 = 1.8 time = 3800
.meas tran vdout0_13ck189 FIND v(dout0_13) AT=3800.1n

* CHECK dout0_14 Vdout0_14ck189 = 0 time = 3800
.meas tran vdout0_14ck189 FIND v(dout0_14) AT=3800.1n

* CHECK dout0_15 Vdout0_15ck189 = 1.8 time = 3800
.meas tran vdout0_15ck189 FIND v(dout0_15) AT=3800.1n

* CHECK dout0_0 Vdout0_0ck190 = 1.8 time = 3820
.meas tran vdout0_0ck190 FIND v(dout0_0) AT=3820.1n

* CHECK dout0_1 Vdout0_1ck190 = 0 time = 3820
.meas tran vdout0_1ck190 FIND v(dout0_1) AT=3820.1n

* CHECK dout0_2 Vdout0_2ck190 = 1.8 time = 3820
.meas tran vdout0_2ck190 FIND v(dout0_2) AT=3820.1n

* CHECK dout0_3 Vdout0_3ck190 = 1.8 time = 3820
.meas tran vdout0_3ck190 FIND v(dout0_3) AT=3820.1n

* CHECK dout0_4 Vdout0_4ck190 = 0 time = 3820
.meas tran vdout0_4ck190 FIND v(dout0_4) AT=3820.1n

* CHECK dout0_5 Vdout0_5ck190 = 0 time = 3820
.meas tran vdout0_5ck190 FIND v(dout0_5) AT=3820.1n

* CHECK dout0_6 Vdout0_6ck190 = 0 time = 3820
.meas tran vdout0_6ck190 FIND v(dout0_6) AT=3820.1n

* CHECK dout0_7 Vdout0_7ck190 = 0 time = 3820
.meas tran vdout0_7ck190 FIND v(dout0_7) AT=3820.1n

* CHECK dout0_8 Vdout0_8ck190 = 1.8 time = 3820
.meas tran vdout0_8ck190 FIND v(dout0_8) AT=3820.1n

* CHECK dout0_9 Vdout0_9ck190 = 0 time = 3820
.meas tran vdout0_9ck190 FIND v(dout0_9) AT=3820.1n

* CHECK dout0_10 Vdout0_10ck190 = 0 time = 3820
.meas tran vdout0_10ck190 FIND v(dout0_10) AT=3820.1n

* CHECK dout0_11 Vdout0_11ck190 = 0 time = 3820
.meas tran vdout0_11ck190 FIND v(dout0_11) AT=3820.1n

* CHECK dout0_12 Vdout0_12ck190 = 1.8 time = 3820
.meas tran vdout0_12ck190 FIND v(dout0_12) AT=3820.1n

* CHECK dout0_13 Vdout0_13ck190 = 0 time = 3820
.meas tran vdout0_13ck190 FIND v(dout0_13) AT=3820.1n

* CHECK dout0_14 Vdout0_14ck190 = 0 time = 3820
.meas tran vdout0_14ck190 FIND v(dout0_14) AT=3820.1n

* CHECK dout0_15 Vdout0_15ck190 = 0 time = 3820
.meas tran vdout0_15ck190 FIND v(dout0_15) AT=3820.1n

* CHECK dout0_0 Vdout0_0ck192 = 1.8 time = 3860
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=3860.1n

* CHECK dout0_1 Vdout0_1ck192 = 0 time = 3860
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=3860.1n

* CHECK dout0_2 Vdout0_2ck192 = 0 time = 3860
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=3860.1n

* CHECK dout0_3 Vdout0_3ck192 = 0 time = 3860
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=3860.1n

* CHECK dout0_4 Vdout0_4ck192 = 1.8 time = 3860
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=3860.1n

* CHECK dout0_5 Vdout0_5ck192 = 0 time = 3860
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=3860.1n

* CHECK dout0_6 Vdout0_6ck192 = 0 time = 3860
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=3860.1n

* CHECK dout0_7 Vdout0_7ck192 = 1.8 time = 3860
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=3860.1n

* CHECK dout0_8 Vdout0_8ck192 = 1.8 time = 3860
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=3860.1n

* CHECK dout0_9 Vdout0_9ck192 = 1.8 time = 3860
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=3860.1n

* CHECK dout0_10 Vdout0_10ck192 = 0 time = 3860
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=3860.1n

* CHECK dout0_11 Vdout0_11ck192 = 1.8 time = 3860
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=3860.1n

* CHECK dout0_12 Vdout0_12ck192 = 0 time = 3860
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=3860.1n

* CHECK dout0_13 Vdout0_13ck192 = 1.8 time = 3860
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=3860.1n

* CHECK dout0_14 Vdout0_14ck192 = 1.8 time = 3860
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=3860.1n

* CHECK dout0_15 Vdout0_15ck192 = 0 time = 3860
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=3860.1n

* CHECK dout0_0 Vdout0_0ck194 = 1.8 time = 3900
.meas tran vdout0_0ck194 FIND v(dout0_0) AT=3900.1n

* CHECK dout0_1 Vdout0_1ck194 = 1.8 time = 3900
.meas tran vdout0_1ck194 FIND v(dout0_1) AT=3900.1n

* CHECK dout0_2 Vdout0_2ck194 = 1.8 time = 3900
.meas tran vdout0_2ck194 FIND v(dout0_2) AT=3900.1n

* CHECK dout0_3 Vdout0_3ck194 = 1.8 time = 3900
.meas tran vdout0_3ck194 FIND v(dout0_3) AT=3900.1n

* CHECK dout0_4 Vdout0_4ck194 = 1.8 time = 3900
.meas tran vdout0_4ck194 FIND v(dout0_4) AT=3900.1n

* CHECK dout0_5 Vdout0_5ck194 = 1.8 time = 3900
.meas tran vdout0_5ck194 FIND v(dout0_5) AT=3900.1n

* CHECK dout0_6 Vdout0_6ck194 = 1.8 time = 3900
.meas tran vdout0_6ck194 FIND v(dout0_6) AT=3900.1n

* CHECK dout0_7 Vdout0_7ck194 = 0 time = 3900
.meas tran vdout0_7ck194 FIND v(dout0_7) AT=3900.1n

* CHECK dout0_8 Vdout0_8ck194 = 0 time = 3900
.meas tran vdout0_8ck194 FIND v(dout0_8) AT=3900.1n

* CHECK dout0_9 Vdout0_9ck194 = 0 time = 3900
.meas tran vdout0_9ck194 FIND v(dout0_9) AT=3900.1n

* CHECK dout0_10 Vdout0_10ck194 = 1.8 time = 3900
.meas tran vdout0_10ck194 FIND v(dout0_10) AT=3900.1n

* CHECK dout0_11 Vdout0_11ck194 = 1.8 time = 3900
.meas tran vdout0_11ck194 FIND v(dout0_11) AT=3900.1n

* CHECK dout0_12 Vdout0_12ck194 = 1.8 time = 3900
.meas tran vdout0_12ck194 FIND v(dout0_12) AT=3900.1n

* CHECK dout0_13 Vdout0_13ck194 = 0 time = 3900
.meas tran vdout0_13ck194 FIND v(dout0_13) AT=3900.1n

* CHECK dout0_14 Vdout0_14ck194 = 1.8 time = 3900
.meas tran vdout0_14ck194 FIND v(dout0_14) AT=3900.1n

* CHECK dout0_15 Vdout0_15ck194 = 0 time = 3900
.meas tran vdout0_15ck194 FIND v(dout0_15) AT=3900.1n

* CHECK dout0_0 Vdout0_0ck195 = 0 time = 3920
.meas tran vdout0_0ck195 FIND v(dout0_0) AT=3920.1n

* CHECK dout0_1 Vdout0_1ck195 = 0 time = 3920
.meas tran vdout0_1ck195 FIND v(dout0_1) AT=3920.1n

* CHECK dout0_2 Vdout0_2ck195 = 0 time = 3920
.meas tran vdout0_2ck195 FIND v(dout0_2) AT=3920.1n

* CHECK dout0_3 Vdout0_3ck195 = 0 time = 3920
.meas tran vdout0_3ck195 FIND v(dout0_3) AT=3920.1n

* CHECK dout0_4 Vdout0_4ck195 = 0 time = 3920
.meas tran vdout0_4ck195 FIND v(dout0_4) AT=3920.1n

* CHECK dout0_5 Vdout0_5ck195 = 1.8 time = 3920
.meas tran vdout0_5ck195 FIND v(dout0_5) AT=3920.1n

* CHECK dout0_6 Vdout0_6ck195 = 1.8 time = 3920
.meas tran vdout0_6ck195 FIND v(dout0_6) AT=3920.1n

* CHECK dout0_7 Vdout0_7ck195 = 0 time = 3920
.meas tran vdout0_7ck195 FIND v(dout0_7) AT=3920.1n

* CHECK dout0_8 Vdout0_8ck195 = 0 time = 3920
.meas tran vdout0_8ck195 FIND v(dout0_8) AT=3920.1n

* CHECK dout0_9 Vdout0_9ck195 = 1.8 time = 3920
.meas tran vdout0_9ck195 FIND v(dout0_9) AT=3920.1n

* CHECK dout0_10 Vdout0_10ck195 = 0 time = 3920
.meas tran vdout0_10ck195 FIND v(dout0_10) AT=3920.1n

* CHECK dout0_11 Vdout0_11ck195 = 1.8 time = 3920
.meas tran vdout0_11ck195 FIND v(dout0_11) AT=3920.1n

* CHECK dout0_12 Vdout0_12ck195 = 0 time = 3920
.meas tran vdout0_12ck195 FIND v(dout0_12) AT=3920.1n

* CHECK dout0_13 Vdout0_13ck195 = 0 time = 3920
.meas tran vdout0_13ck195 FIND v(dout0_13) AT=3920.1n

* CHECK dout0_14 Vdout0_14ck195 = 1.8 time = 3920
.meas tran vdout0_14ck195 FIND v(dout0_14) AT=3920.1n

* CHECK dout0_15 Vdout0_15ck195 = 0 time = 3920
.meas tran vdout0_15ck195 FIND v(dout0_15) AT=3920.1n

* CHECK dout0_0 Vdout0_0ck197 = 0 time = 3960
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=3960.1n

* CHECK dout0_1 Vdout0_1ck197 = 0 time = 3960
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=3960.1n

* CHECK dout0_2 Vdout0_2ck197 = 1.8 time = 3960
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=3960.1n

* CHECK dout0_3 Vdout0_3ck197 = 0 time = 3960
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=3960.1n

* CHECK dout0_4 Vdout0_4ck197 = 1.8 time = 3960
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=3960.1n

* CHECK dout0_5 Vdout0_5ck197 = 0 time = 3960
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=3960.1n

* CHECK dout0_6 Vdout0_6ck197 = 0 time = 3960
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=3960.1n

* CHECK dout0_7 Vdout0_7ck197 = 1.8 time = 3960
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=3960.1n

* CHECK dout0_8 Vdout0_8ck197 = 0 time = 3960
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=3960.1n

* CHECK dout0_9 Vdout0_9ck197 = 0 time = 3960
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=3960.1n

* CHECK dout0_10 Vdout0_10ck197 = 0 time = 3960
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=3960.1n

* CHECK dout0_11 Vdout0_11ck197 = 1.8 time = 3960
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=3960.1n

* CHECK dout0_12 Vdout0_12ck197 = 0 time = 3960
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=3960.1n

* CHECK dout0_13 Vdout0_13ck197 = 1.8 time = 3960
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=3960.1n

* CHECK dout0_14 Vdout0_14ck197 = 1.8 time = 3960
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=3960.1n

* CHECK dout0_15 Vdout0_15ck197 = 1.8 time = 3960
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=3960.1n

* CHECK dout0_0 Vdout0_0ck199 = 0 time = 4000
.meas tran vdout0_0ck199 FIND v(dout0_0) AT=4000.1n

* CHECK dout0_1 Vdout0_1ck199 = 1.8 time = 4000
.meas tran vdout0_1ck199 FIND v(dout0_1) AT=4000.1n

* CHECK dout0_2 Vdout0_2ck199 = 0 time = 4000
.meas tran vdout0_2ck199 FIND v(dout0_2) AT=4000.1n

* CHECK dout0_3 Vdout0_3ck199 = 1.8 time = 4000
.meas tran vdout0_3ck199 FIND v(dout0_3) AT=4000.1n

* CHECK dout0_4 Vdout0_4ck199 = 0 time = 4000
.meas tran vdout0_4ck199 FIND v(dout0_4) AT=4000.1n

* CHECK dout0_5 Vdout0_5ck199 = 1.8 time = 4000
.meas tran vdout0_5ck199 FIND v(dout0_5) AT=4000.1n

* CHECK dout0_6 Vdout0_6ck199 = 0 time = 4000
.meas tran vdout0_6ck199 FIND v(dout0_6) AT=4000.1n

* CHECK dout0_7 Vdout0_7ck199 = 0 time = 4000
.meas tran vdout0_7ck199 FIND v(dout0_7) AT=4000.1n

* CHECK dout0_8 Vdout0_8ck199 = 1.8 time = 4000
.meas tran vdout0_8ck199 FIND v(dout0_8) AT=4000.1n

* CHECK dout0_9 Vdout0_9ck199 = 0 time = 4000
.meas tran vdout0_9ck199 FIND v(dout0_9) AT=4000.1n

* CHECK dout0_10 Vdout0_10ck199 = 1.8 time = 4000
.meas tran vdout0_10ck199 FIND v(dout0_10) AT=4000.1n

* CHECK dout0_11 Vdout0_11ck199 = 0 time = 4000
.meas tran vdout0_11ck199 FIND v(dout0_11) AT=4000.1n

* CHECK dout0_12 Vdout0_12ck199 = 1.8 time = 4000
.meas tran vdout0_12ck199 FIND v(dout0_12) AT=4000.1n

* CHECK dout0_13 Vdout0_13ck199 = 1.8 time = 4000
.meas tran vdout0_13ck199 FIND v(dout0_13) AT=4000.1n

* CHECK dout0_14 Vdout0_14ck199 = 0 time = 4000
.meas tran vdout0_14ck199 FIND v(dout0_14) AT=4000.1n

* CHECK dout0_15 Vdout0_15ck199 = 0 time = 4000
.meas tran vdout0_15ck199 FIND v(dout0_15) AT=4000.1n

* CHECK dout0_0 Vdout0_0ck203 = 1.8 time = 4080
.meas tran vdout0_0ck203 FIND v(dout0_0) AT=4080.1n

* CHECK dout0_1 Vdout0_1ck203 = 0 time = 4080
.meas tran vdout0_1ck203 FIND v(dout0_1) AT=4080.1n

* CHECK dout0_2 Vdout0_2ck203 = 0 time = 4080
.meas tran vdout0_2ck203 FIND v(dout0_2) AT=4080.1n

* CHECK dout0_3 Vdout0_3ck203 = 0 time = 4080
.meas tran vdout0_3ck203 FIND v(dout0_3) AT=4080.1n

* CHECK dout0_4 Vdout0_4ck203 = 1.8 time = 4080
.meas tran vdout0_4ck203 FIND v(dout0_4) AT=4080.1n

* CHECK dout0_5 Vdout0_5ck203 = 0 time = 4080
.meas tran vdout0_5ck203 FIND v(dout0_5) AT=4080.1n

* CHECK dout0_6 Vdout0_6ck203 = 0 time = 4080
.meas tran vdout0_6ck203 FIND v(dout0_6) AT=4080.1n

* CHECK dout0_7 Vdout0_7ck203 = 1.8 time = 4080
.meas tran vdout0_7ck203 FIND v(dout0_7) AT=4080.1n

* CHECK dout0_8 Vdout0_8ck203 = 1.8 time = 4080
.meas tran vdout0_8ck203 FIND v(dout0_8) AT=4080.1n

* CHECK dout0_9 Vdout0_9ck203 = 1.8 time = 4080
.meas tran vdout0_9ck203 FIND v(dout0_9) AT=4080.1n

* CHECK dout0_10 Vdout0_10ck203 = 0 time = 4080
.meas tran vdout0_10ck203 FIND v(dout0_10) AT=4080.1n

* CHECK dout0_11 Vdout0_11ck203 = 1.8 time = 4080
.meas tran vdout0_11ck203 FIND v(dout0_11) AT=4080.1n

* CHECK dout0_12 Vdout0_12ck203 = 0 time = 4080
.meas tran vdout0_12ck203 FIND v(dout0_12) AT=4080.1n

* CHECK dout0_13 Vdout0_13ck203 = 1.8 time = 4080
.meas tran vdout0_13ck203 FIND v(dout0_13) AT=4080.1n

* CHECK dout0_14 Vdout0_14ck203 = 1.8 time = 4080
.meas tran vdout0_14ck203 FIND v(dout0_14) AT=4080.1n

* CHECK dout0_15 Vdout0_15ck203 = 0 time = 4080
.meas tran vdout0_15ck203 FIND v(dout0_15) AT=4080.1n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
