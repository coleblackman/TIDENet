* Functional test stimulus file for 20ns period

* TT process corner
.include "/home/mm4uz/Documents/openram/vsdsram_sky130/OpenRAM/technology/sky130A/models/tt.sp"
.include "conv1_rm_sram_16_336_sky130A.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xconv1_rm_sram_16_336_sky130A din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 a0_8 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 vdd gnd conv1_rm_sram_16_336_sky130A

* SRAM output loads
CD00 dout0_0  0 39.2968f
CD01 dout0_1  0 39.2968f
CD02 dout0_2  0 39.2968f
CD03 dout0_3  0 39.2968f
CD04 dout0_4  0 39.2968f
CD05 dout0_5  0 39.2968f
CD06 dout0_6  0 39.2968f
CD07 dout0_7  0 39.2968f
CD08 dout0_8  0 39.2968f
CD09 dout0_9  0 39.2968f
CD010 dout0_10  0 39.2968f
CD011 dout0_11  0 39.2968f
CD012 dout0_12  0 39.2968f
CD013 dout0_13  0 39.2968f
CD014 dout0_14  0 39.2968f
CD015 dout0_15  0 39.2968f

* Important signals for debug
* bl:	xconv1_rm_sram_16_336_sky130a.xbank0.bl_0_0
* br:	xconv1_rm_sram_16_336_sky130a.xbank0.br_0_0
* s_en:	xconv1_rm_sram_16_336_sky130a.s_en
* q:	xconv1_rm_sram_16_336_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xconv1_rm_sram_16_336_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 20ns)
*	Writing 1000010010011100  to  address 000000010 (from port 0) during cycle 1 (20ns - 40ns)
*	Writing 0100010111010000  to  address 000000001 (from port 0) during cycle 2 (40ns - 60ns)
*	Writing 0110111000110011  to  address 101001101 (from port 0) during cycle 3 (60ns - 80ns)
*	Reading 0110111000110011 from address 101001101 (from port 0) during cycle 4 (80ns - 100ns)
*	Writing 0001001110111100  to  address 101001011 (from port 0) during cycle 5 (100ns - 120ns)
*	Reading 0100010111010000 from address 000000001 (from port 0) during cycle 8 (160ns - 180ns)
*	Reading 0001001110111100 from address 101001011 (from port 0) during cycle 10 (200ns - 220ns)
*	Reading 1000010010011100 from address 000000010 (from port 0) during cycle 11 (220ns - 240ns)
*	Reading 1000010010011100 from address 000000010 (from port 0) during cycle 12 (240ns - 260ns)
*	Writing 1100101011101100  to  address 000000001 (from port 0) during cycle 13 (260ns - 280ns)
*	Reading 0110111000110011 from address 101001101 (from port 0) during cycle 14 (280ns - 300ns)
*	Writing 1010110100111011  to  address 101001110 (from port 0) during cycle 15 (300ns - 320ns)
*	Writing 1111111101101011  to  address 000000000 (from port 0) during cycle 16 (320ns - 340ns)
*	Reading 1000010010011100 from address 000000010 (from port 0) during cycle 18 (360ns - 380ns)
*	Reading 1010110100111011 from address 101001110 (from port 0) during cycle 19 (380ns - 400ns)
*	Reading 0110111000110011 from address 101001101 (from port 0) during cycle 22 (440ns - 460ns)
*	Reading 1010110100111011 from address 101001110 (from port 0) during cycle 23 (460ns - 480ns)
*	Writing 0001001010011110  to  address 000000011 (from port 0) during cycle 24 (480ns - 500ns)
*	Writing 0100101101111100  to  address 101001011 (from port 0) during cycle 25 (500ns - 520ns)
*	Reading 1111111101101011 from address 000000000 (from port 0) during cycle 26 (520ns - 540ns)
*	Reading 0001001010011110 from address 000000011 (from port 0) during cycle 27 (540ns - 560ns)
*	Writing 0111101110000101  to  address 000000010 (from port 0) during cycle 28 (560ns - 580ns)
*	Reading 0110111000110011 from address 101001101 (from port 0) during cycle 29 (580ns - 600ns)
*	Reading 1111111101101011 from address 000000000 (from port 0) during cycle 32 (640ns - 660ns)
*	Reading 1111111101101011 from address 000000000 (from port 0) during cycle 34 (680ns - 700ns)
*	Reading 0001001010011110 from address 000000011 (from port 0) during cycle 35 (700ns - 720ns)
*	Reading 1111111101101011 from address 000000000 (from port 0) during cycle 37 (740ns - 760ns)
*	Reading 0110111000110011 from address 101001101 (from port 0) during cycle 41 (820ns - 840ns)
*	Reading 1010110100111011 from address 101001110 (from port 0) during cycle 43 (860ns - 880ns)
*	Reading 1100101011101100 from address 000000001 (from port 0) during cycle 44 (880ns - 900ns)
*	Reading 0001001010011110 from address 000000011 (from port 0) during cycle 46 (920ns - 940ns)
*	Reading 1010110100111011 from address 101001110 (from port 0) during cycle 47 (940ns - 960ns)
*	Writing 0011000111101100  to  address 101001100 (from port 0) during cycle 49 (980ns - 1000ns)
*	Reading 0011000111101100 from address 101001100 (from port 0) during cycle 50 (1000ns - 1020ns)
*	Reading 0001001010011110 from address 000000011 (from port 0) during cycle 51 (1020ns - 1040ns)
*	Reading 0100101101111100 from address 101001011 (from port 0) during cycle 52 (1040ns - 1060ns)
*	Reading 0011000111101100 from address 101001100 (from port 0) during cycle 54 (1080ns - 1100ns)
*	Reading 0111101110000101 from address 000000010 (from port 0) during cycle 56 (1120ns - 1140ns)
*	Writing 0011100011110011  to  address 101001100 (from port 0) during cycle 57 (1140ns - 1160ns)
*	Reading 0100101101111100 from address 101001011 (from port 0) during cycle 58 (1160ns - 1180ns)
*	Writing 1100101000010011  to  address 000000001 (from port 0) during cycle 59 (1180ns - 1200ns)
*	Reading 1010110100111011 from address 101001110 (from port 0) during cycle 61 (1220ns - 1240ns)
*	Writing 0100010111101101  to  address 000000010 (from port 0) during cycle 62 (1240ns - 1260ns)
*	Reading 0100010111101101 from address 000000010 (from port 0) during cycle 63 (1260ns - 1280ns)
*	Reading 1100101000010011 from address 000000001 (from port 0) during cycle 65 (1300ns - 1320ns)
*	Reading 1111111101101011 from address 000000000 (from port 0) during cycle 66 (1320ns - 1340ns)
*	Writing 1010111101101100  to  address 000000010 (from port 0) during cycle 67 (1340ns - 1360ns)
*	Reading 1010110100111011 from address 101001110 (from port 0) during cycle 68 (1360ns - 1380ns)
*	Reading 1111111101101011 from address 000000000 (from port 0) during cycle 69 (1380ns - 1400ns)
*	Reading 0011100011110011 from address 101001100 (from port 0) during cycle 70 (1400ns - 1420ns)
*	Writing 0110100010100001  to  address 101001110 (from port 0) during cycle 71 (1420ns - 1440ns)
*	Reading 0110100010100001 from address 101001110 (from port 0) during cycle 72 (1440ns - 1460ns)
*	Reading 0110111000110011 from address 101001101 (from port 0) during cycle 73 (1460ns - 1480ns)
*	Reading 1111111101101011 from address 000000000 (from port 0) during cycle 74 (1480ns - 1500ns)
*	Reading 0110111000110011 from address 101001101 (from port 0) during cycle 75 (1500ns - 1520ns)
*	Writing 1110001011110001  to  address 101001011 (from port 0) during cycle 77 (1540ns - 1560ns)
*	Reading 0110100010100001 from address 101001110 (from port 0) during cycle 78 (1560ns - 1580ns)
*	Reading 1100101000010011 from address 000000001 (from port 0) during cycle 80 (1600ns - 1620ns)
*	Writing 1011010100010101  to  address 000000011 (from port 0) during cycle 81 (1620ns - 1640ns)
*	Reading 0110111000110011 from address 101001101 (from port 0) during cycle 82 (1640ns - 1660ns)
*	Reading 0110100010100001 from address 101001110 (from port 0) during cycle 83 (1660ns - 1680ns)
*	Reading 1100101000010011 from address 000000001 (from port 0) during cycle 84 (1680ns - 1700ns)
*	Reading 0110100010100001 from address 101001110 (from port 0) during cycle 86 (1720ns - 1740ns)
*	Reading 1100101000010011 from address 000000001 (from port 0) during cycle 87 (1740ns - 1760ns)
*	Writing 1010101101101100  to  address 101001110 (from port 0) during cycle 89 (1780ns - 1800ns)
*	Writing 0111110100100011  to  address 000000000 (from port 0) during cycle 90 (1800ns - 1820ns)
*	Reading 0111110100100011 from address 000000000 (from port 0) during cycle 91 (1820ns - 1840ns)
*	Reading 1110001011110001 from address 101001011 (from port 0) during cycle 92 (1840ns - 1860ns)
*	Reading 1110001011110001 from address 101001011 (from port 0) during cycle 93 (1860ns - 1880ns)
*	Reading 1110001011110001 from address 101001011 (from port 0) during cycle 96 (1920ns - 1940ns)
*	Reading 0111110100100011 from address 000000000 (from port 0) during cycle 98 (1960ns - 1980ns)
*	Reading 1011010100010101 from address 000000011 (from port 0) during cycle 99 (1980ns - 2000ns)
*	Reading 1110001011110001 from address 101001011 (from port 0) during cycle 101 (2020ns - 2040ns)
*	Reading 1100101000010011 from address 000000001 (from port 0) during cycle 102 (2040ns - 2060ns)
*	Writing 0011111000001111  to  address 101001110 (from port 0) during cycle 103 (2060ns - 2080ns)
*	Writing 0000100101000111  to  address 000000010 (from port 0) during cycle 104 (2080ns - 2100ns)
*	Reading 1110001011110001 from address 101001011 (from port 0) during cycle 105 (2100ns - 2120ns)
*	Reading 0110111000110011 from address 101001101 (from port 0) during cycle 106 (2120ns - 2140ns)
*	Reading 0110111000110011 from address 101001101 (from port 0) during cycle 107 (2140ns - 2160ns)
*	Reading 1100101000010011 from address 000000001 (from port 0) during cycle 109 (2180ns - 2200ns)
*	Writing 1011110100011111  to  address 000000010 (from port 0) during cycle 110 (2200ns - 2220ns)
*	Reading 1011010100010101 from address 000000011 (from port 0) during cycle 111 (2220ns - 2240ns)
*	Reading 1011010100010101 from address 000000011 (from port 0) during cycle 112 (2240ns - 2260ns)
*	Reading 0110111000110011 from address 101001101 (from port 0) during cycle 113 (2260ns - 2280ns)
*	Writing 0110111000001110  to  address 101001101 (from port 0) during cycle 114 (2280ns - 2300ns)
*	Reading 0011111000001111 from address 101001110 (from port 0) during cycle 115 (2300ns - 2320ns)
*	Reading 1011110100011111 from address 000000010 (from port 0) during cycle 116 (2320ns - 2340ns)
*	Writing 1010000111100100  to  address 101001011 (from port 0) during cycle 117 (2340ns - 2360ns)
*	Reading 1100101000010011 from address 000000001 (from port 0) during cycle 118 (2360ns - 2380ns)
*	Reading 0111110100100011 from address 000000000 (from port 0) during cycle 119 (2380ns - 2400ns)
*	Writing 0111011111100101  to  address 101001101 (from port 0) during cycle 120 (2400ns - 2420ns)
*	Writing 0111011100001100  to  address 101001110 (from port 0) during cycle 121 (2420ns - 2440ns)
*	Reading 0011100011110011 from address 101001100 (from port 0) during cycle 122 (2440ns - 2460ns)
*	Reading 1010000111100100 from address 101001011 (from port 0) during cycle 123 (2460ns - 2480ns)
*	Reading 0111011111100101 from address 101001101 (from port 0) during cycle 124 (2480ns - 2500ns)
*	Reading 0111011100001100 from address 101001110 (from port 0) during cycle 126 (2520ns - 2540ns)
*	Reading 0111110100100011 from address 000000000 (from port 0) during cycle 127 (2540ns - 2560ns)
*	Reading 0111011100001100 from address 101001110 (from port 0) during cycle 129 (2580ns - 2600ns)
*	Reading 0111110100100011 from address 000000000 (from port 0) during cycle 130 (2600ns - 2620ns)
*	Reading 1011110100011111 from address 000000010 (from port 0) during cycle 131 (2620ns - 2640ns)
*	Reading 1010000111100100 from address 101001011 (from port 0) during cycle 133 (2660ns - 2680ns)
*	Writing 0010010001001101  to  address 101001101 (from port 0) during cycle 135 (2700ns - 2720ns)
*	Writing 0100011110010110  to  address 101001110 (from port 0) during cycle 136 (2720ns - 2740ns)
*	Writing 1111111000110000  to  address 000000010 (from port 0) during cycle 137 (2740ns - 2760ns)
*	Reading 0111110100100011 from address 000000000 (from port 0) during cycle 138 (2760ns - 2780ns)
*	Writing 1111010111111000  to  address 000000000 (from port 0) during cycle 139 (2780ns - 2800ns)
*	Writing 1000000100011110  to  address 000000001 (from port 0) during cycle 140 (2800ns - 2820ns)
*	Reading 1011010100010101 from address 000000011 (from port 0) during cycle 141 (2820ns - 2840ns)
*	Writing 0001001110011101  to  address 000000001 (from port 0) during cycle 142 (2840ns - 2860ns)
*	Reading 0100011110010110 from address 101001110 (from port 0) during cycle 143 (2860ns - 2880ns)
*	Writing 1111001001100111  to  address 101001101 (from port 0) during cycle 144 (2880ns - 2900ns)
*	Reading 0100011110010110 from address 101001110 (from port 0) during cycle 145 (2900ns - 2920ns)
*	Reading 1010000111100100 from address 101001011 (from port 0) during cycle 146 (2920ns - 2940ns)
*	Writing 1110110110001101  to  address 101001011 (from port 0) during cycle 147 (2940ns - 2960ns)
*	Reading 0100011110010110 from address 101001110 (from port 0) during cycle 148 (2960ns - 2980ns)
*	Reading 1111010111111000 from address 000000000 (from port 0) during cycle 149 (2980ns - 3000ns)
*	Writing 0000001010011110  to  address 101001100 (from port 0) during cycle 150 (3000ns - 3020ns)
*	Reading 1110110110001101 from address 101001011 (from port 0) during cycle 151 (3020ns - 3040ns)
*	Reading 0100011110010110 from address 101001110 (from port 0) during cycle 153 (3060ns - 3080ns)
*	Writing 1010111101101010  to  address 000000011 (from port 0) during cycle 154 (3080ns - 3100ns)
*	Reading 1110110110001101 from address 101001011 (from port 0) during cycle 157 (3140ns - 3160ns)
*	Reading 1111001001100111 from address 101001101 (from port 0) during cycle 158 (3160ns - 3180ns)
*	Reading 1110110110001101 from address 101001011 (from port 0) during cycle 159 (3180ns - 3200ns)
*	Writing 0111001010011111  to  address 000000000 (from port 0) during cycle 160 (3200ns - 3220ns)
*	Reading 1111001001100111 from address 101001101 (from port 0) during cycle 161 (3220ns - 3240ns)
*	Reading 0000001010011110 from address 101001100 (from port 0) during cycle 163 (3260ns - 3280ns)
*	Writing 0110011010100101  to  address 000000000 (from port 0) during cycle 164 (3280ns - 3300ns)
*	Reading 0001001110011101 from address 000000001 (from port 0) during cycle 165 (3300ns - 3320ns)
*	Writing 1010001001100111  to  address 000000000 (from port 0) during cycle 166 (3320ns - 3340ns)
*	Reading 0100011110010110 from address 101001110 (from port 0) during cycle 167 (3340ns - 3360ns)
*	Reading 1010111101101010 from address 000000011 (from port 0) during cycle 168 (3360ns - 3380ns)
*	Writing 1001001011011000  to  address 000000011 (from port 0) during cycle 169 (3380ns - 3400ns)
*	Reading 1010001001100111 from address 000000000 (from port 0) during cycle 170 (3400ns - 3420ns)
*	Reading 1001001011011000 from address 000000011 (from port 0) during cycle 171 (3420ns - 3440ns)
*	Writing 1100001010000111  to  address 101001110 (from port 0) during cycle 172 (3440ns - 3460ns)
*	Writing 0111111110111110  to  address 000000000 (from port 0) during cycle 173 (3460ns - 3480ns)
*	Reading 0111111110111110 from address 000000000 (from port 0) during cycle 175 (3500ns - 3520ns)
*	Reading 1110110110001101 from address 101001011 (from port 0) during cycle 176 (3520ns - 3540ns)
*	Reading 1100001010000111 from address 101001110 (from port 0) during cycle 178 (3560ns - 3580ns)
*	Writing 1001101111001001  to  address 101001110 (from port 0) during cycle 179 (3580ns - 3600ns)
*	Reading 1001101111001001 from address 101001110 (from port 0) during cycle 180 (3600ns - 3620ns)
*	Reading 1111001001100111 from address 101001101 (from port 0) during cycle 181 (3620ns - 3640ns)
*	Writing 1010111100101001  to  address 000000011 (from port 0) during cycle 182 (3640ns - 3660ns)
*	Reading 0000001010011110 from address 101001100 (from port 0) during cycle 183 (3660ns - 3680ns)
*	Writing 0011000110001111  to  address 000000010 (from port 0) during cycle 184 (3680ns - 3700ns)
*	Reading 1010111100101001 from address 000000011 (from port 0) during cycle 186 (3720ns - 3740ns)
*	Reading 0011000110001111 from address 000000010 (from port 0) during cycle 187 (3740ns - 3760ns)
*	Writing 1100110010110010  to  address 000000001 (from port 0) during cycle 188 (3760ns - 3780ns)
*	Writing 1100111011001000  to  address 101001110 (from port 0) during cycle 189 (3780ns - 3800ns)
*	Writing 0010101101110000  to  address 101001110 (from port 0) during cycle 191 (3820ns - 3840ns)
*	Reading 0000001010011110 from address 101001100 (from port 0) during cycle 192 (3840ns - 3860ns)
*	Reading 1111001001100111 from address 101001101 (from port 0) during cycle 194 (3880ns - 3900ns)
*	Reading 0111111110111110 from address 000000000 (from port 0) during cycle 195 (3900ns - 3920ns)
*	Writing 1000001001110110  to  address 000000011 (from port 0) during cycle 196 (3920ns - 3940ns)
*	Reading 0111111110111110 from address 000000000 (from port 0) during cycle 197 (3940ns - 3960ns)
*	Reading 1100110010110010 from address 000000001 (from port 0) during cycle 198 (3960ns - 3980ns)
*	Reading 1111001001100111 from address 101001101 (from port 0) during cycle 199 (3980ns - 4000ns)
*	Reading 1110110110001101 from address 101001011 (from port 0) during cycle 200 (4000ns - 4020ns)
*	Writing 0011110111010001  to  address 101001100 (from port 0) during cycle 202 (4040ns - 4060ns)
*	Writing 1011001101001100  to  address 101001011 (from port 0) during cycle 204 (4080ns - 4100ns)
*	Idle during cycle 205 (4100ns - 4120ns)

* Generation of data and address signals
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 1), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 1), (520, 1), (540, 1), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 0), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 1), (520, 1), (540, 1), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 0), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 0), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 1), (520, 1), (540, 1), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 0), (520, 0), (540, 0), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 0), (2760, 0), (2780, 1), (2800, 0), (2820, 0), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 1), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 0), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 1), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 0), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 0), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 1), (2760, 1), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 0), (520, 0), (540, 0), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 0), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 0), (240, 0), (260, 1), (280, 1), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 0), (480, 1), (500, 1), (520, 0), (540, 1), (560, 0), (580, 1), (600, 1), (620, 1), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 0), (760, 0), (780, 0), (800, 0), (820, 1), (840, 1), (860, 0), (880, 1), (900, 1), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 1), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 1), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 1), (1620, 1), (1640, 1), (1660, 0), (1680, 1), (1700, 1), (1720, 0), (1740, 1), (1760, 1), (1780, 0), (1800, 0), (1820, 0), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 0), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 1), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 1), (2900, 0), (2920, 1), (2940, 1), (2960, 0), (2980, 0), (3000, 0), (3020, 1), (3040, 1), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 1), (3320, 0), (3340, 0), (3360, 1), (3380, 1), (3400, 0), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 0), (3580, 0), (3600, 0), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 0), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 0), (3920, 1), (3940, 0), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 1), (320, 0), (340, 0), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 1), (480, 1), (500, 1), (520, 0), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 0), (900, 0), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 1), (1180, 0), (1200, 0), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 0), (1620, 1), (1640, 0), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 0), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 0), (2380, 0), (2400, 0), (2420, 1), (2440, 0), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 0), (2560, 0), (2580, 1), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 1), (2840, 0), (2860, 1), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 0), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 1), (3380, 1), (3400, 0), (3420, 1), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 0), (3640, 1), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 1), (600, 1), (620, 1), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 1), (840, 1), (860, 1), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 1), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 0), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 1), (1540, 0), (1560, 1), (1580, 1), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 1), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 1), (2460, 0), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 0), (2940, 0), (2960, 1), (2980, 0), (3000, 1), (3020, 0), (3040, 0), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 1), (220, 0), (240, 0), (260, 0), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 1), (520, 0), (540, 0), (560, 0), (580, 1), (600, 1), (620, 1), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 1), (840, 1), (860, 1), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 0), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 0), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 0), (2340, 1), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 1), (220, 0), (240, 0), (260, 0), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 1), (520, 0), (540, 0), (560, 0), (580, 1), (600, 1), (620, 1), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 1), (840, 1), (860, 1), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 0), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 0), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 0), (2340, 1), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_6  a0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 1), (220, 0), (240, 0), (260, 0), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 1), (520, 0), (540, 0), (560, 0), (580, 1), (600, 1), (620, 1), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 1), (840, 1), (860, 1), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 0), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 1), (1160, 1), (1180, 0), (1200, 0), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 0), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 0), (2340, 1), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_8  a0_8  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )

 * Generation of control signals
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 1), (140, 1), (160, 0), (180, 1), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 1), (360, 0), (380, 0), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 0), (660, 1), (680, 0), (700, 0), (720, 1), (740, 0), (760, 1), (780, 1), (800, 1), (820, 0), (840, 1), (860, 0), (880, 0), (900, 1), (920, 0), (940, 0), (960, 1), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 1), (1080, 0), (1100, 1), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 1), (1220, 0), (1240, 0), (1260, 0), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 1), (1540, 0), (1560, 0), (1580, 1), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 1), (1720, 0), (1740, 0), (1760, 1), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 1), (1900, 1), (1920, 0), (1940, 1), (1960, 0), (1980, 0), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 0), (2540, 0), (2560, 1), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 0), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 0), (3080, 0), (3100, 1), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 1), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 0), (3540, 1), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 1), (3820, 0), (3840, 0), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 0), (4060, 1), (4080, 0), (4100, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 0.0v 658.95n 0.0v 659.05n 1.8v 678.95n 1.8v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 1.8v )
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 1), (100, 0), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 1), (300, 0), (320, 0), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 1), (540, 1), (560, 0), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 1), (1180, 0), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 0), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 0), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 0), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 1), (2340, 0), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 0), (2860, 1), (2880, 0), (2900, 1), (2920, 1), (2940, 0), (2960, 1), (2980, 1), (3000, 0), (3020, 1), (3040, 1), (3060, 1), (3080, 0), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 1), (3320, 0), (3340, 1), (3360, 1), (3380, 0), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 0), (3600, 1), (3620, 1), (3640, 0), (3660, 1), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 0), (3800, 1), (3820, 0), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 1), (4080, 0), (4100, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 1.8v )
* PULSE: period=20
Vclk0 clk0 0 PULSE (0 1.8 19.95n 0.1n 0.1n 9.899999999999999n 20n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 1.8 time = 100
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=100.1n

* CHECK dout0_1 Vdout0_1ck4 = 1.8 time = 100
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=100.1n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 100
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=100.1n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 100
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=100.1n

* CHECK dout0_4 Vdout0_4ck4 = 1.8 time = 100
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=100.1n

* CHECK dout0_5 Vdout0_5ck4 = 1.8 time = 100
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=100.1n

* CHECK dout0_6 Vdout0_6ck4 = 0 time = 100
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=100.1n

* CHECK dout0_7 Vdout0_7ck4 = 0 time = 100
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=100.1n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 100
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=100.1n

* CHECK dout0_9 Vdout0_9ck4 = 1.8 time = 100
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=100.1n

* CHECK dout0_10 Vdout0_10ck4 = 1.8 time = 100
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=100.1n

* CHECK dout0_11 Vdout0_11ck4 = 1.8 time = 100
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=100.1n

* CHECK dout0_12 Vdout0_12ck4 = 0 time = 100
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=100.1n

* CHECK dout0_13 Vdout0_13ck4 = 1.8 time = 100
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=100.1n

* CHECK dout0_14 Vdout0_14ck4 = 1.8 time = 100
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=100.1n

* CHECK dout0_15 Vdout0_15ck4 = 0 time = 100
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=100.1n

* CHECK dout0_0 Vdout0_0ck8 = 0 time = 180
.meas tran vdout0_0ck8 FIND v(dout0_0) AT=180.1n

* CHECK dout0_1 Vdout0_1ck8 = 0 time = 180
.meas tran vdout0_1ck8 FIND v(dout0_1) AT=180.1n

* CHECK dout0_2 Vdout0_2ck8 = 0 time = 180
.meas tran vdout0_2ck8 FIND v(dout0_2) AT=180.1n

* CHECK dout0_3 Vdout0_3ck8 = 0 time = 180
.meas tran vdout0_3ck8 FIND v(dout0_3) AT=180.1n

* CHECK dout0_4 Vdout0_4ck8 = 1.8 time = 180
.meas tran vdout0_4ck8 FIND v(dout0_4) AT=180.1n

* CHECK dout0_5 Vdout0_5ck8 = 0 time = 180
.meas tran vdout0_5ck8 FIND v(dout0_5) AT=180.1n

* CHECK dout0_6 Vdout0_6ck8 = 1.8 time = 180
.meas tran vdout0_6ck8 FIND v(dout0_6) AT=180.1n

* CHECK dout0_7 Vdout0_7ck8 = 1.8 time = 180
.meas tran vdout0_7ck8 FIND v(dout0_7) AT=180.1n

* CHECK dout0_8 Vdout0_8ck8 = 1.8 time = 180
.meas tran vdout0_8ck8 FIND v(dout0_8) AT=180.1n

* CHECK dout0_9 Vdout0_9ck8 = 0 time = 180
.meas tran vdout0_9ck8 FIND v(dout0_9) AT=180.1n

* CHECK dout0_10 Vdout0_10ck8 = 1.8 time = 180
.meas tran vdout0_10ck8 FIND v(dout0_10) AT=180.1n

* CHECK dout0_11 Vdout0_11ck8 = 0 time = 180
.meas tran vdout0_11ck8 FIND v(dout0_11) AT=180.1n

* CHECK dout0_12 Vdout0_12ck8 = 0 time = 180
.meas tran vdout0_12ck8 FIND v(dout0_12) AT=180.1n

* CHECK dout0_13 Vdout0_13ck8 = 0 time = 180
.meas tran vdout0_13ck8 FIND v(dout0_13) AT=180.1n

* CHECK dout0_14 Vdout0_14ck8 = 1.8 time = 180
.meas tran vdout0_14ck8 FIND v(dout0_14) AT=180.1n

* CHECK dout0_15 Vdout0_15ck8 = 0 time = 180
.meas tran vdout0_15ck8 FIND v(dout0_15) AT=180.1n

* CHECK dout0_0 Vdout0_0ck10 = 0 time = 220
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=220.1n

* CHECK dout0_1 Vdout0_1ck10 = 0 time = 220
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=220.1n

* CHECK dout0_2 Vdout0_2ck10 = 1.8 time = 220
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=220.1n

* CHECK dout0_3 Vdout0_3ck10 = 1.8 time = 220
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=220.1n

* CHECK dout0_4 Vdout0_4ck10 = 1.8 time = 220
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=220.1n

* CHECK dout0_5 Vdout0_5ck10 = 1.8 time = 220
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=220.1n

* CHECK dout0_6 Vdout0_6ck10 = 0 time = 220
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=220.1n

* CHECK dout0_7 Vdout0_7ck10 = 1.8 time = 220
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=220.1n

* CHECK dout0_8 Vdout0_8ck10 = 1.8 time = 220
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=220.1n

* CHECK dout0_9 Vdout0_9ck10 = 1.8 time = 220
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=220.1n

* CHECK dout0_10 Vdout0_10ck10 = 0 time = 220
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=220.1n

* CHECK dout0_11 Vdout0_11ck10 = 0 time = 220
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=220.1n

* CHECK dout0_12 Vdout0_12ck10 = 1.8 time = 220
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=220.1n

* CHECK dout0_13 Vdout0_13ck10 = 0 time = 220
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=220.1n

* CHECK dout0_14 Vdout0_14ck10 = 0 time = 220
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=220.1n

* CHECK dout0_15 Vdout0_15ck10 = 0 time = 220
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=220.1n

* CHECK dout0_0 Vdout0_0ck11 = 0 time = 240
.meas tran vdout0_0ck11 FIND v(dout0_0) AT=240.1n

* CHECK dout0_1 Vdout0_1ck11 = 0 time = 240
.meas tran vdout0_1ck11 FIND v(dout0_1) AT=240.1n

* CHECK dout0_2 Vdout0_2ck11 = 1.8 time = 240
.meas tran vdout0_2ck11 FIND v(dout0_2) AT=240.1n

* CHECK dout0_3 Vdout0_3ck11 = 1.8 time = 240
.meas tran vdout0_3ck11 FIND v(dout0_3) AT=240.1n

* CHECK dout0_4 Vdout0_4ck11 = 1.8 time = 240
.meas tran vdout0_4ck11 FIND v(dout0_4) AT=240.1n

* CHECK dout0_5 Vdout0_5ck11 = 0 time = 240
.meas tran vdout0_5ck11 FIND v(dout0_5) AT=240.1n

* CHECK dout0_6 Vdout0_6ck11 = 0 time = 240
.meas tran vdout0_6ck11 FIND v(dout0_6) AT=240.1n

* CHECK dout0_7 Vdout0_7ck11 = 1.8 time = 240
.meas tran vdout0_7ck11 FIND v(dout0_7) AT=240.1n

* CHECK dout0_8 Vdout0_8ck11 = 0 time = 240
.meas tran vdout0_8ck11 FIND v(dout0_8) AT=240.1n

* CHECK dout0_9 Vdout0_9ck11 = 0 time = 240
.meas tran vdout0_9ck11 FIND v(dout0_9) AT=240.1n

* CHECK dout0_10 Vdout0_10ck11 = 1.8 time = 240
.meas tran vdout0_10ck11 FIND v(dout0_10) AT=240.1n

* CHECK dout0_11 Vdout0_11ck11 = 0 time = 240
.meas tran vdout0_11ck11 FIND v(dout0_11) AT=240.1n

* CHECK dout0_12 Vdout0_12ck11 = 0 time = 240
.meas tran vdout0_12ck11 FIND v(dout0_12) AT=240.1n

* CHECK dout0_13 Vdout0_13ck11 = 0 time = 240
.meas tran vdout0_13ck11 FIND v(dout0_13) AT=240.1n

* CHECK dout0_14 Vdout0_14ck11 = 0 time = 240
.meas tran vdout0_14ck11 FIND v(dout0_14) AT=240.1n

* CHECK dout0_15 Vdout0_15ck11 = 1.8 time = 240
.meas tran vdout0_15ck11 FIND v(dout0_15) AT=240.1n

* CHECK dout0_0 Vdout0_0ck12 = 0 time = 260
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=260.1n

* CHECK dout0_1 Vdout0_1ck12 = 0 time = 260
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=260.1n

* CHECK dout0_2 Vdout0_2ck12 = 1.8 time = 260
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=260.1n

* CHECK dout0_3 Vdout0_3ck12 = 1.8 time = 260
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=260.1n

* CHECK dout0_4 Vdout0_4ck12 = 1.8 time = 260
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=260.1n

* CHECK dout0_5 Vdout0_5ck12 = 0 time = 260
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=260.1n

* CHECK dout0_6 Vdout0_6ck12 = 0 time = 260
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=260.1n

* CHECK dout0_7 Vdout0_7ck12 = 1.8 time = 260
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=260.1n

* CHECK dout0_8 Vdout0_8ck12 = 0 time = 260
.meas tran vdout0_8ck12 FIND v(dout0_8) AT=260.1n

* CHECK dout0_9 Vdout0_9ck12 = 0 time = 260
.meas tran vdout0_9ck12 FIND v(dout0_9) AT=260.1n

* CHECK dout0_10 Vdout0_10ck12 = 1.8 time = 260
.meas tran vdout0_10ck12 FIND v(dout0_10) AT=260.1n

* CHECK dout0_11 Vdout0_11ck12 = 0 time = 260
.meas tran vdout0_11ck12 FIND v(dout0_11) AT=260.1n

* CHECK dout0_12 Vdout0_12ck12 = 0 time = 260
.meas tran vdout0_12ck12 FIND v(dout0_12) AT=260.1n

* CHECK dout0_13 Vdout0_13ck12 = 0 time = 260
.meas tran vdout0_13ck12 FIND v(dout0_13) AT=260.1n

* CHECK dout0_14 Vdout0_14ck12 = 0 time = 260
.meas tran vdout0_14ck12 FIND v(dout0_14) AT=260.1n

* CHECK dout0_15 Vdout0_15ck12 = 1.8 time = 260
.meas tran vdout0_15ck12 FIND v(dout0_15) AT=260.1n

* CHECK dout0_0 Vdout0_0ck14 = 1.8 time = 300
.meas tran vdout0_0ck14 FIND v(dout0_0) AT=300.1n

* CHECK dout0_1 Vdout0_1ck14 = 1.8 time = 300
.meas tran vdout0_1ck14 FIND v(dout0_1) AT=300.1n

* CHECK dout0_2 Vdout0_2ck14 = 0 time = 300
.meas tran vdout0_2ck14 FIND v(dout0_2) AT=300.1n

* CHECK dout0_3 Vdout0_3ck14 = 0 time = 300
.meas tran vdout0_3ck14 FIND v(dout0_3) AT=300.1n

* CHECK dout0_4 Vdout0_4ck14 = 1.8 time = 300
.meas tran vdout0_4ck14 FIND v(dout0_4) AT=300.1n

* CHECK dout0_5 Vdout0_5ck14 = 1.8 time = 300
.meas tran vdout0_5ck14 FIND v(dout0_5) AT=300.1n

* CHECK dout0_6 Vdout0_6ck14 = 0 time = 300
.meas tran vdout0_6ck14 FIND v(dout0_6) AT=300.1n

* CHECK dout0_7 Vdout0_7ck14 = 0 time = 300
.meas tran vdout0_7ck14 FIND v(dout0_7) AT=300.1n

* CHECK dout0_8 Vdout0_8ck14 = 0 time = 300
.meas tran vdout0_8ck14 FIND v(dout0_8) AT=300.1n

* CHECK dout0_9 Vdout0_9ck14 = 1.8 time = 300
.meas tran vdout0_9ck14 FIND v(dout0_9) AT=300.1n

* CHECK dout0_10 Vdout0_10ck14 = 1.8 time = 300
.meas tran vdout0_10ck14 FIND v(dout0_10) AT=300.1n

* CHECK dout0_11 Vdout0_11ck14 = 1.8 time = 300
.meas tran vdout0_11ck14 FIND v(dout0_11) AT=300.1n

* CHECK dout0_12 Vdout0_12ck14 = 0 time = 300
.meas tran vdout0_12ck14 FIND v(dout0_12) AT=300.1n

* CHECK dout0_13 Vdout0_13ck14 = 1.8 time = 300
.meas tran vdout0_13ck14 FIND v(dout0_13) AT=300.1n

* CHECK dout0_14 Vdout0_14ck14 = 1.8 time = 300
.meas tran vdout0_14ck14 FIND v(dout0_14) AT=300.1n

* CHECK dout0_15 Vdout0_15ck14 = 0 time = 300
.meas tran vdout0_15ck14 FIND v(dout0_15) AT=300.1n

* CHECK dout0_0 Vdout0_0ck18 = 0 time = 380
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=380.1n

* CHECK dout0_1 Vdout0_1ck18 = 0 time = 380
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=380.1n

* CHECK dout0_2 Vdout0_2ck18 = 1.8 time = 380
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=380.1n

* CHECK dout0_3 Vdout0_3ck18 = 1.8 time = 380
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=380.1n

* CHECK dout0_4 Vdout0_4ck18 = 1.8 time = 380
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=380.1n

* CHECK dout0_5 Vdout0_5ck18 = 0 time = 380
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=380.1n

* CHECK dout0_6 Vdout0_6ck18 = 0 time = 380
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=380.1n

* CHECK dout0_7 Vdout0_7ck18 = 1.8 time = 380
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=380.1n

* CHECK dout0_8 Vdout0_8ck18 = 0 time = 380
.meas tran vdout0_8ck18 FIND v(dout0_8) AT=380.1n

* CHECK dout0_9 Vdout0_9ck18 = 0 time = 380
.meas tran vdout0_9ck18 FIND v(dout0_9) AT=380.1n

* CHECK dout0_10 Vdout0_10ck18 = 1.8 time = 380
.meas tran vdout0_10ck18 FIND v(dout0_10) AT=380.1n

* CHECK dout0_11 Vdout0_11ck18 = 0 time = 380
.meas tran vdout0_11ck18 FIND v(dout0_11) AT=380.1n

* CHECK dout0_12 Vdout0_12ck18 = 0 time = 380
.meas tran vdout0_12ck18 FIND v(dout0_12) AT=380.1n

* CHECK dout0_13 Vdout0_13ck18 = 0 time = 380
.meas tran vdout0_13ck18 FIND v(dout0_13) AT=380.1n

* CHECK dout0_14 Vdout0_14ck18 = 0 time = 380
.meas tran vdout0_14ck18 FIND v(dout0_14) AT=380.1n

* CHECK dout0_15 Vdout0_15ck18 = 1.8 time = 380
.meas tran vdout0_15ck18 FIND v(dout0_15) AT=380.1n

* CHECK dout0_0 Vdout0_0ck19 = 1.8 time = 400
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=400.1n

* CHECK dout0_1 Vdout0_1ck19 = 1.8 time = 400
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=400.1n

* CHECK dout0_2 Vdout0_2ck19 = 0 time = 400
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=400.1n

* CHECK dout0_3 Vdout0_3ck19 = 1.8 time = 400
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=400.1n

* CHECK dout0_4 Vdout0_4ck19 = 1.8 time = 400
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=400.1n

* CHECK dout0_5 Vdout0_5ck19 = 1.8 time = 400
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=400.1n

* CHECK dout0_6 Vdout0_6ck19 = 0 time = 400
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=400.1n

* CHECK dout0_7 Vdout0_7ck19 = 0 time = 400
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=400.1n

* CHECK dout0_8 Vdout0_8ck19 = 1.8 time = 400
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=400.1n

* CHECK dout0_9 Vdout0_9ck19 = 0 time = 400
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=400.1n

* CHECK dout0_10 Vdout0_10ck19 = 1.8 time = 400
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=400.1n

* CHECK dout0_11 Vdout0_11ck19 = 1.8 time = 400
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=400.1n

* CHECK dout0_12 Vdout0_12ck19 = 0 time = 400
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=400.1n

* CHECK dout0_13 Vdout0_13ck19 = 1.8 time = 400
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=400.1n

* CHECK dout0_14 Vdout0_14ck19 = 0 time = 400
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=400.1n

* CHECK dout0_15 Vdout0_15ck19 = 1.8 time = 400
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=400.1n

* CHECK dout0_0 Vdout0_0ck22 = 1.8 time = 460
.meas tran vdout0_0ck22 FIND v(dout0_0) AT=460.1n

* CHECK dout0_1 Vdout0_1ck22 = 1.8 time = 460
.meas tran vdout0_1ck22 FIND v(dout0_1) AT=460.1n

* CHECK dout0_2 Vdout0_2ck22 = 0 time = 460
.meas tran vdout0_2ck22 FIND v(dout0_2) AT=460.1n

* CHECK dout0_3 Vdout0_3ck22 = 0 time = 460
.meas tran vdout0_3ck22 FIND v(dout0_3) AT=460.1n

* CHECK dout0_4 Vdout0_4ck22 = 1.8 time = 460
.meas tran vdout0_4ck22 FIND v(dout0_4) AT=460.1n

* CHECK dout0_5 Vdout0_5ck22 = 1.8 time = 460
.meas tran vdout0_5ck22 FIND v(dout0_5) AT=460.1n

* CHECK dout0_6 Vdout0_6ck22 = 0 time = 460
.meas tran vdout0_6ck22 FIND v(dout0_6) AT=460.1n

* CHECK dout0_7 Vdout0_7ck22 = 0 time = 460
.meas tran vdout0_7ck22 FIND v(dout0_7) AT=460.1n

* CHECK dout0_8 Vdout0_8ck22 = 0 time = 460
.meas tran vdout0_8ck22 FIND v(dout0_8) AT=460.1n

* CHECK dout0_9 Vdout0_9ck22 = 1.8 time = 460
.meas tran vdout0_9ck22 FIND v(dout0_9) AT=460.1n

* CHECK dout0_10 Vdout0_10ck22 = 1.8 time = 460
.meas tran vdout0_10ck22 FIND v(dout0_10) AT=460.1n

* CHECK dout0_11 Vdout0_11ck22 = 1.8 time = 460
.meas tran vdout0_11ck22 FIND v(dout0_11) AT=460.1n

* CHECK dout0_12 Vdout0_12ck22 = 0 time = 460
.meas tran vdout0_12ck22 FIND v(dout0_12) AT=460.1n

* CHECK dout0_13 Vdout0_13ck22 = 1.8 time = 460
.meas tran vdout0_13ck22 FIND v(dout0_13) AT=460.1n

* CHECK dout0_14 Vdout0_14ck22 = 1.8 time = 460
.meas tran vdout0_14ck22 FIND v(dout0_14) AT=460.1n

* CHECK dout0_15 Vdout0_15ck22 = 0 time = 460
.meas tran vdout0_15ck22 FIND v(dout0_15) AT=460.1n

* CHECK dout0_0 Vdout0_0ck23 = 1.8 time = 480
.meas tran vdout0_0ck23 FIND v(dout0_0) AT=480.1n

* CHECK dout0_1 Vdout0_1ck23 = 1.8 time = 480
.meas tran vdout0_1ck23 FIND v(dout0_1) AT=480.1n

* CHECK dout0_2 Vdout0_2ck23 = 0 time = 480
.meas tran vdout0_2ck23 FIND v(dout0_2) AT=480.1n

* CHECK dout0_3 Vdout0_3ck23 = 1.8 time = 480
.meas tran vdout0_3ck23 FIND v(dout0_3) AT=480.1n

* CHECK dout0_4 Vdout0_4ck23 = 1.8 time = 480
.meas tran vdout0_4ck23 FIND v(dout0_4) AT=480.1n

* CHECK dout0_5 Vdout0_5ck23 = 1.8 time = 480
.meas tran vdout0_5ck23 FIND v(dout0_5) AT=480.1n

* CHECK dout0_6 Vdout0_6ck23 = 0 time = 480
.meas tran vdout0_6ck23 FIND v(dout0_6) AT=480.1n

* CHECK dout0_7 Vdout0_7ck23 = 0 time = 480
.meas tran vdout0_7ck23 FIND v(dout0_7) AT=480.1n

* CHECK dout0_8 Vdout0_8ck23 = 1.8 time = 480
.meas tran vdout0_8ck23 FIND v(dout0_8) AT=480.1n

* CHECK dout0_9 Vdout0_9ck23 = 0 time = 480
.meas tran vdout0_9ck23 FIND v(dout0_9) AT=480.1n

* CHECK dout0_10 Vdout0_10ck23 = 1.8 time = 480
.meas tran vdout0_10ck23 FIND v(dout0_10) AT=480.1n

* CHECK dout0_11 Vdout0_11ck23 = 1.8 time = 480
.meas tran vdout0_11ck23 FIND v(dout0_11) AT=480.1n

* CHECK dout0_12 Vdout0_12ck23 = 0 time = 480
.meas tran vdout0_12ck23 FIND v(dout0_12) AT=480.1n

* CHECK dout0_13 Vdout0_13ck23 = 1.8 time = 480
.meas tran vdout0_13ck23 FIND v(dout0_13) AT=480.1n

* CHECK dout0_14 Vdout0_14ck23 = 0 time = 480
.meas tran vdout0_14ck23 FIND v(dout0_14) AT=480.1n

* CHECK dout0_15 Vdout0_15ck23 = 1.8 time = 480
.meas tran vdout0_15ck23 FIND v(dout0_15) AT=480.1n

* CHECK dout0_0 Vdout0_0ck26 = 1.8 time = 540
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=540.1n

* CHECK dout0_1 Vdout0_1ck26 = 1.8 time = 540
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=540.1n

* CHECK dout0_2 Vdout0_2ck26 = 0 time = 540
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=540.1n

* CHECK dout0_3 Vdout0_3ck26 = 1.8 time = 540
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=540.1n

* CHECK dout0_4 Vdout0_4ck26 = 0 time = 540
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=540.1n

* CHECK dout0_5 Vdout0_5ck26 = 1.8 time = 540
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=540.1n

* CHECK dout0_6 Vdout0_6ck26 = 1.8 time = 540
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=540.1n

* CHECK dout0_7 Vdout0_7ck26 = 0 time = 540
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=540.1n

* CHECK dout0_8 Vdout0_8ck26 = 1.8 time = 540
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=540.1n

* CHECK dout0_9 Vdout0_9ck26 = 1.8 time = 540
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=540.1n

* CHECK dout0_10 Vdout0_10ck26 = 1.8 time = 540
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=540.1n

* CHECK dout0_11 Vdout0_11ck26 = 1.8 time = 540
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=540.1n

* CHECK dout0_12 Vdout0_12ck26 = 1.8 time = 540
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=540.1n

* CHECK dout0_13 Vdout0_13ck26 = 1.8 time = 540
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=540.1n

* CHECK dout0_14 Vdout0_14ck26 = 1.8 time = 540
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=540.1n

* CHECK dout0_15 Vdout0_15ck26 = 1.8 time = 540
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=540.1n

* CHECK dout0_0 Vdout0_0ck27 = 0 time = 560
.meas tran vdout0_0ck27 FIND v(dout0_0) AT=560.1n

* CHECK dout0_1 Vdout0_1ck27 = 1.8 time = 560
.meas tran vdout0_1ck27 FIND v(dout0_1) AT=560.1n

* CHECK dout0_2 Vdout0_2ck27 = 1.8 time = 560
.meas tran vdout0_2ck27 FIND v(dout0_2) AT=560.1n

* CHECK dout0_3 Vdout0_3ck27 = 1.8 time = 560
.meas tran vdout0_3ck27 FIND v(dout0_3) AT=560.1n

* CHECK dout0_4 Vdout0_4ck27 = 1.8 time = 560
.meas tran vdout0_4ck27 FIND v(dout0_4) AT=560.1n

* CHECK dout0_5 Vdout0_5ck27 = 0 time = 560
.meas tran vdout0_5ck27 FIND v(dout0_5) AT=560.1n

* CHECK dout0_6 Vdout0_6ck27 = 0 time = 560
.meas tran vdout0_6ck27 FIND v(dout0_6) AT=560.1n

* CHECK dout0_7 Vdout0_7ck27 = 1.8 time = 560
.meas tran vdout0_7ck27 FIND v(dout0_7) AT=560.1n

* CHECK dout0_8 Vdout0_8ck27 = 0 time = 560
.meas tran vdout0_8ck27 FIND v(dout0_8) AT=560.1n

* CHECK dout0_9 Vdout0_9ck27 = 1.8 time = 560
.meas tran vdout0_9ck27 FIND v(dout0_9) AT=560.1n

* CHECK dout0_10 Vdout0_10ck27 = 0 time = 560
.meas tran vdout0_10ck27 FIND v(dout0_10) AT=560.1n

* CHECK dout0_11 Vdout0_11ck27 = 0 time = 560
.meas tran vdout0_11ck27 FIND v(dout0_11) AT=560.1n

* CHECK dout0_12 Vdout0_12ck27 = 1.8 time = 560
.meas tran vdout0_12ck27 FIND v(dout0_12) AT=560.1n

* CHECK dout0_13 Vdout0_13ck27 = 0 time = 560
.meas tran vdout0_13ck27 FIND v(dout0_13) AT=560.1n

* CHECK dout0_14 Vdout0_14ck27 = 0 time = 560
.meas tran vdout0_14ck27 FIND v(dout0_14) AT=560.1n

* CHECK dout0_15 Vdout0_15ck27 = 0 time = 560
.meas tran vdout0_15ck27 FIND v(dout0_15) AT=560.1n

* CHECK dout0_0 Vdout0_0ck29 = 1.8 time = 600
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=600.1n

* CHECK dout0_1 Vdout0_1ck29 = 1.8 time = 600
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=600.1n

* CHECK dout0_2 Vdout0_2ck29 = 0 time = 600
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=600.1n

* CHECK dout0_3 Vdout0_3ck29 = 0 time = 600
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=600.1n

* CHECK dout0_4 Vdout0_4ck29 = 1.8 time = 600
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=600.1n

* CHECK dout0_5 Vdout0_5ck29 = 1.8 time = 600
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=600.1n

* CHECK dout0_6 Vdout0_6ck29 = 0 time = 600
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=600.1n

* CHECK dout0_7 Vdout0_7ck29 = 0 time = 600
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=600.1n

* CHECK dout0_8 Vdout0_8ck29 = 0 time = 600
.meas tran vdout0_8ck29 FIND v(dout0_8) AT=600.1n

* CHECK dout0_9 Vdout0_9ck29 = 1.8 time = 600
.meas tran vdout0_9ck29 FIND v(dout0_9) AT=600.1n

* CHECK dout0_10 Vdout0_10ck29 = 1.8 time = 600
.meas tran vdout0_10ck29 FIND v(dout0_10) AT=600.1n

* CHECK dout0_11 Vdout0_11ck29 = 1.8 time = 600
.meas tran vdout0_11ck29 FIND v(dout0_11) AT=600.1n

* CHECK dout0_12 Vdout0_12ck29 = 0 time = 600
.meas tran vdout0_12ck29 FIND v(dout0_12) AT=600.1n

* CHECK dout0_13 Vdout0_13ck29 = 1.8 time = 600
.meas tran vdout0_13ck29 FIND v(dout0_13) AT=600.1n

* CHECK dout0_14 Vdout0_14ck29 = 1.8 time = 600
.meas tran vdout0_14ck29 FIND v(dout0_14) AT=600.1n

* CHECK dout0_15 Vdout0_15ck29 = 0 time = 600
.meas tran vdout0_15ck29 FIND v(dout0_15) AT=600.1n

* CHECK dout0_0 Vdout0_0ck32 = 1.8 time = 660
.meas tran vdout0_0ck32 FIND v(dout0_0) AT=660.1n

* CHECK dout0_1 Vdout0_1ck32 = 1.8 time = 660
.meas tran vdout0_1ck32 FIND v(dout0_1) AT=660.1n

* CHECK dout0_2 Vdout0_2ck32 = 0 time = 660
.meas tran vdout0_2ck32 FIND v(dout0_2) AT=660.1n

* CHECK dout0_3 Vdout0_3ck32 = 1.8 time = 660
.meas tran vdout0_3ck32 FIND v(dout0_3) AT=660.1n

* CHECK dout0_4 Vdout0_4ck32 = 0 time = 660
.meas tran vdout0_4ck32 FIND v(dout0_4) AT=660.1n

* CHECK dout0_5 Vdout0_5ck32 = 1.8 time = 660
.meas tran vdout0_5ck32 FIND v(dout0_5) AT=660.1n

* CHECK dout0_6 Vdout0_6ck32 = 1.8 time = 660
.meas tran vdout0_6ck32 FIND v(dout0_6) AT=660.1n

* CHECK dout0_7 Vdout0_7ck32 = 0 time = 660
.meas tran vdout0_7ck32 FIND v(dout0_7) AT=660.1n

* CHECK dout0_8 Vdout0_8ck32 = 1.8 time = 660
.meas tran vdout0_8ck32 FIND v(dout0_8) AT=660.1n

* CHECK dout0_9 Vdout0_9ck32 = 1.8 time = 660
.meas tran vdout0_9ck32 FIND v(dout0_9) AT=660.1n

* CHECK dout0_10 Vdout0_10ck32 = 1.8 time = 660
.meas tran vdout0_10ck32 FIND v(dout0_10) AT=660.1n

* CHECK dout0_11 Vdout0_11ck32 = 1.8 time = 660
.meas tran vdout0_11ck32 FIND v(dout0_11) AT=660.1n

* CHECK dout0_12 Vdout0_12ck32 = 1.8 time = 660
.meas tran vdout0_12ck32 FIND v(dout0_12) AT=660.1n

* CHECK dout0_13 Vdout0_13ck32 = 1.8 time = 660
.meas tran vdout0_13ck32 FIND v(dout0_13) AT=660.1n

* CHECK dout0_14 Vdout0_14ck32 = 1.8 time = 660
.meas tran vdout0_14ck32 FIND v(dout0_14) AT=660.1n

* CHECK dout0_15 Vdout0_15ck32 = 1.8 time = 660
.meas tran vdout0_15ck32 FIND v(dout0_15) AT=660.1n

* CHECK dout0_0 Vdout0_0ck34 = 1.8 time = 700
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=700.1n

* CHECK dout0_1 Vdout0_1ck34 = 1.8 time = 700
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=700.1n

* CHECK dout0_2 Vdout0_2ck34 = 0 time = 700
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=700.1n

* CHECK dout0_3 Vdout0_3ck34 = 1.8 time = 700
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=700.1n

* CHECK dout0_4 Vdout0_4ck34 = 0 time = 700
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=700.1n

* CHECK dout0_5 Vdout0_5ck34 = 1.8 time = 700
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=700.1n

* CHECK dout0_6 Vdout0_6ck34 = 1.8 time = 700
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=700.1n

* CHECK dout0_7 Vdout0_7ck34 = 0 time = 700
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=700.1n

* CHECK dout0_8 Vdout0_8ck34 = 1.8 time = 700
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=700.1n

* CHECK dout0_9 Vdout0_9ck34 = 1.8 time = 700
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=700.1n

* CHECK dout0_10 Vdout0_10ck34 = 1.8 time = 700
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=700.1n

* CHECK dout0_11 Vdout0_11ck34 = 1.8 time = 700
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=700.1n

* CHECK dout0_12 Vdout0_12ck34 = 1.8 time = 700
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=700.1n

* CHECK dout0_13 Vdout0_13ck34 = 1.8 time = 700
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=700.1n

* CHECK dout0_14 Vdout0_14ck34 = 1.8 time = 700
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=700.1n

* CHECK dout0_15 Vdout0_15ck34 = 1.8 time = 700
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=700.1n

* CHECK dout0_0 Vdout0_0ck35 = 0 time = 720
.meas tran vdout0_0ck35 FIND v(dout0_0) AT=720.1n

* CHECK dout0_1 Vdout0_1ck35 = 1.8 time = 720
.meas tran vdout0_1ck35 FIND v(dout0_1) AT=720.1n

* CHECK dout0_2 Vdout0_2ck35 = 1.8 time = 720
.meas tran vdout0_2ck35 FIND v(dout0_2) AT=720.1n

* CHECK dout0_3 Vdout0_3ck35 = 1.8 time = 720
.meas tran vdout0_3ck35 FIND v(dout0_3) AT=720.1n

* CHECK dout0_4 Vdout0_4ck35 = 1.8 time = 720
.meas tran vdout0_4ck35 FIND v(dout0_4) AT=720.1n

* CHECK dout0_5 Vdout0_5ck35 = 0 time = 720
.meas tran vdout0_5ck35 FIND v(dout0_5) AT=720.1n

* CHECK dout0_6 Vdout0_6ck35 = 0 time = 720
.meas tran vdout0_6ck35 FIND v(dout0_6) AT=720.1n

* CHECK dout0_7 Vdout0_7ck35 = 1.8 time = 720
.meas tran vdout0_7ck35 FIND v(dout0_7) AT=720.1n

* CHECK dout0_8 Vdout0_8ck35 = 0 time = 720
.meas tran vdout0_8ck35 FIND v(dout0_8) AT=720.1n

* CHECK dout0_9 Vdout0_9ck35 = 1.8 time = 720
.meas tran vdout0_9ck35 FIND v(dout0_9) AT=720.1n

* CHECK dout0_10 Vdout0_10ck35 = 0 time = 720
.meas tran vdout0_10ck35 FIND v(dout0_10) AT=720.1n

* CHECK dout0_11 Vdout0_11ck35 = 0 time = 720
.meas tran vdout0_11ck35 FIND v(dout0_11) AT=720.1n

* CHECK dout0_12 Vdout0_12ck35 = 1.8 time = 720
.meas tran vdout0_12ck35 FIND v(dout0_12) AT=720.1n

* CHECK dout0_13 Vdout0_13ck35 = 0 time = 720
.meas tran vdout0_13ck35 FIND v(dout0_13) AT=720.1n

* CHECK dout0_14 Vdout0_14ck35 = 0 time = 720
.meas tran vdout0_14ck35 FIND v(dout0_14) AT=720.1n

* CHECK dout0_15 Vdout0_15ck35 = 0 time = 720
.meas tran vdout0_15ck35 FIND v(dout0_15) AT=720.1n

* CHECK dout0_0 Vdout0_0ck37 = 1.8 time = 760
.meas tran vdout0_0ck37 FIND v(dout0_0) AT=760.1n

* CHECK dout0_1 Vdout0_1ck37 = 1.8 time = 760
.meas tran vdout0_1ck37 FIND v(dout0_1) AT=760.1n

* CHECK dout0_2 Vdout0_2ck37 = 0 time = 760
.meas tran vdout0_2ck37 FIND v(dout0_2) AT=760.1n

* CHECK dout0_3 Vdout0_3ck37 = 1.8 time = 760
.meas tran vdout0_3ck37 FIND v(dout0_3) AT=760.1n

* CHECK dout0_4 Vdout0_4ck37 = 0 time = 760
.meas tran vdout0_4ck37 FIND v(dout0_4) AT=760.1n

* CHECK dout0_5 Vdout0_5ck37 = 1.8 time = 760
.meas tran vdout0_5ck37 FIND v(dout0_5) AT=760.1n

* CHECK dout0_6 Vdout0_6ck37 = 1.8 time = 760
.meas tran vdout0_6ck37 FIND v(dout0_6) AT=760.1n

* CHECK dout0_7 Vdout0_7ck37 = 0 time = 760
.meas tran vdout0_7ck37 FIND v(dout0_7) AT=760.1n

* CHECK dout0_8 Vdout0_8ck37 = 1.8 time = 760
.meas tran vdout0_8ck37 FIND v(dout0_8) AT=760.1n

* CHECK dout0_9 Vdout0_9ck37 = 1.8 time = 760
.meas tran vdout0_9ck37 FIND v(dout0_9) AT=760.1n

* CHECK dout0_10 Vdout0_10ck37 = 1.8 time = 760
.meas tran vdout0_10ck37 FIND v(dout0_10) AT=760.1n

* CHECK dout0_11 Vdout0_11ck37 = 1.8 time = 760
.meas tran vdout0_11ck37 FIND v(dout0_11) AT=760.1n

* CHECK dout0_12 Vdout0_12ck37 = 1.8 time = 760
.meas tran vdout0_12ck37 FIND v(dout0_12) AT=760.1n

* CHECK dout0_13 Vdout0_13ck37 = 1.8 time = 760
.meas tran vdout0_13ck37 FIND v(dout0_13) AT=760.1n

* CHECK dout0_14 Vdout0_14ck37 = 1.8 time = 760
.meas tran vdout0_14ck37 FIND v(dout0_14) AT=760.1n

* CHECK dout0_15 Vdout0_15ck37 = 1.8 time = 760
.meas tran vdout0_15ck37 FIND v(dout0_15) AT=760.1n

* CHECK dout0_0 Vdout0_0ck41 = 1.8 time = 840
.meas tran vdout0_0ck41 FIND v(dout0_0) AT=840.1n

* CHECK dout0_1 Vdout0_1ck41 = 1.8 time = 840
.meas tran vdout0_1ck41 FIND v(dout0_1) AT=840.1n

* CHECK dout0_2 Vdout0_2ck41 = 0 time = 840
.meas tran vdout0_2ck41 FIND v(dout0_2) AT=840.1n

* CHECK dout0_3 Vdout0_3ck41 = 0 time = 840
.meas tran vdout0_3ck41 FIND v(dout0_3) AT=840.1n

* CHECK dout0_4 Vdout0_4ck41 = 1.8 time = 840
.meas tran vdout0_4ck41 FIND v(dout0_4) AT=840.1n

* CHECK dout0_5 Vdout0_5ck41 = 1.8 time = 840
.meas tran vdout0_5ck41 FIND v(dout0_5) AT=840.1n

* CHECK dout0_6 Vdout0_6ck41 = 0 time = 840
.meas tran vdout0_6ck41 FIND v(dout0_6) AT=840.1n

* CHECK dout0_7 Vdout0_7ck41 = 0 time = 840
.meas tran vdout0_7ck41 FIND v(dout0_7) AT=840.1n

* CHECK dout0_8 Vdout0_8ck41 = 0 time = 840
.meas tran vdout0_8ck41 FIND v(dout0_8) AT=840.1n

* CHECK dout0_9 Vdout0_9ck41 = 1.8 time = 840
.meas tran vdout0_9ck41 FIND v(dout0_9) AT=840.1n

* CHECK dout0_10 Vdout0_10ck41 = 1.8 time = 840
.meas tran vdout0_10ck41 FIND v(dout0_10) AT=840.1n

* CHECK dout0_11 Vdout0_11ck41 = 1.8 time = 840
.meas tran vdout0_11ck41 FIND v(dout0_11) AT=840.1n

* CHECK dout0_12 Vdout0_12ck41 = 0 time = 840
.meas tran vdout0_12ck41 FIND v(dout0_12) AT=840.1n

* CHECK dout0_13 Vdout0_13ck41 = 1.8 time = 840
.meas tran vdout0_13ck41 FIND v(dout0_13) AT=840.1n

* CHECK dout0_14 Vdout0_14ck41 = 1.8 time = 840
.meas tran vdout0_14ck41 FIND v(dout0_14) AT=840.1n

* CHECK dout0_15 Vdout0_15ck41 = 0 time = 840
.meas tran vdout0_15ck41 FIND v(dout0_15) AT=840.1n

* CHECK dout0_0 Vdout0_0ck43 = 1.8 time = 880
.meas tran vdout0_0ck43 FIND v(dout0_0) AT=880.1n

* CHECK dout0_1 Vdout0_1ck43 = 1.8 time = 880
.meas tran vdout0_1ck43 FIND v(dout0_1) AT=880.1n

* CHECK dout0_2 Vdout0_2ck43 = 0 time = 880
.meas tran vdout0_2ck43 FIND v(dout0_2) AT=880.1n

* CHECK dout0_3 Vdout0_3ck43 = 1.8 time = 880
.meas tran vdout0_3ck43 FIND v(dout0_3) AT=880.1n

* CHECK dout0_4 Vdout0_4ck43 = 1.8 time = 880
.meas tran vdout0_4ck43 FIND v(dout0_4) AT=880.1n

* CHECK dout0_5 Vdout0_5ck43 = 1.8 time = 880
.meas tran vdout0_5ck43 FIND v(dout0_5) AT=880.1n

* CHECK dout0_6 Vdout0_6ck43 = 0 time = 880
.meas tran vdout0_6ck43 FIND v(dout0_6) AT=880.1n

* CHECK dout0_7 Vdout0_7ck43 = 0 time = 880
.meas tran vdout0_7ck43 FIND v(dout0_7) AT=880.1n

* CHECK dout0_8 Vdout0_8ck43 = 1.8 time = 880
.meas tran vdout0_8ck43 FIND v(dout0_8) AT=880.1n

* CHECK dout0_9 Vdout0_9ck43 = 0 time = 880
.meas tran vdout0_9ck43 FIND v(dout0_9) AT=880.1n

* CHECK dout0_10 Vdout0_10ck43 = 1.8 time = 880
.meas tran vdout0_10ck43 FIND v(dout0_10) AT=880.1n

* CHECK dout0_11 Vdout0_11ck43 = 1.8 time = 880
.meas tran vdout0_11ck43 FIND v(dout0_11) AT=880.1n

* CHECK dout0_12 Vdout0_12ck43 = 0 time = 880
.meas tran vdout0_12ck43 FIND v(dout0_12) AT=880.1n

* CHECK dout0_13 Vdout0_13ck43 = 1.8 time = 880
.meas tran vdout0_13ck43 FIND v(dout0_13) AT=880.1n

* CHECK dout0_14 Vdout0_14ck43 = 0 time = 880
.meas tran vdout0_14ck43 FIND v(dout0_14) AT=880.1n

* CHECK dout0_15 Vdout0_15ck43 = 1.8 time = 880
.meas tran vdout0_15ck43 FIND v(dout0_15) AT=880.1n

* CHECK dout0_0 Vdout0_0ck44 = 0 time = 900
.meas tran vdout0_0ck44 FIND v(dout0_0) AT=900.1n

* CHECK dout0_1 Vdout0_1ck44 = 0 time = 900
.meas tran vdout0_1ck44 FIND v(dout0_1) AT=900.1n

* CHECK dout0_2 Vdout0_2ck44 = 1.8 time = 900
.meas tran vdout0_2ck44 FIND v(dout0_2) AT=900.1n

* CHECK dout0_3 Vdout0_3ck44 = 1.8 time = 900
.meas tran vdout0_3ck44 FIND v(dout0_3) AT=900.1n

* CHECK dout0_4 Vdout0_4ck44 = 0 time = 900
.meas tran vdout0_4ck44 FIND v(dout0_4) AT=900.1n

* CHECK dout0_5 Vdout0_5ck44 = 1.8 time = 900
.meas tran vdout0_5ck44 FIND v(dout0_5) AT=900.1n

* CHECK dout0_6 Vdout0_6ck44 = 1.8 time = 900
.meas tran vdout0_6ck44 FIND v(dout0_6) AT=900.1n

* CHECK dout0_7 Vdout0_7ck44 = 1.8 time = 900
.meas tran vdout0_7ck44 FIND v(dout0_7) AT=900.1n

* CHECK dout0_8 Vdout0_8ck44 = 0 time = 900
.meas tran vdout0_8ck44 FIND v(dout0_8) AT=900.1n

* CHECK dout0_9 Vdout0_9ck44 = 1.8 time = 900
.meas tran vdout0_9ck44 FIND v(dout0_9) AT=900.1n

* CHECK dout0_10 Vdout0_10ck44 = 0 time = 900
.meas tran vdout0_10ck44 FIND v(dout0_10) AT=900.1n

* CHECK dout0_11 Vdout0_11ck44 = 1.8 time = 900
.meas tran vdout0_11ck44 FIND v(dout0_11) AT=900.1n

* CHECK dout0_12 Vdout0_12ck44 = 0 time = 900
.meas tran vdout0_12ck44 FIND v(dout0_12) AT=900.1n

* CHECK dout0_13 Vdout0_13ck44 = 0 time = 900
.meas tran vdout0_13ck44 FIND v(dout0_13) AT=900.1n

* CHECK dout0_14 Vdout0_14ck44 = 1.8 time = 900
.meas tran vdout0_14ck44 FIND v(dout0_14) AT=900.1n

* CHECK dout0_15 Vdout0_15ck44 = 1.8 time = 900
.meas tran vdout0_15ck44 FIND v(dout0_15) AT=900.1n

* CHECK dout0_0 Vdout0_0ck46 = 0 time = 940
.meas tran vdout0_0ck46 FIND v(dout0_0) AT=940.1n

* CHECK dout0_1 Vdout0_1ck46 = 1.8 time = 940
.meas tran vdout0_1ck46 FIND v(dout0_1) AT=940.1n

* CHECK dout0_2 Vdout0_2ck46 = 1.8 time = 940
.meas tran vdout0_2ck46 FIND v(dout0_2) AT=940.1n

* CHECK dout0_3 Vdout0_3ck46 = 1.8 time = 940
.meas tran vdout0_3ck46 FIND v(dout0_3) AT=940.1n

* CHECK dout0_4 Vdout0_4ck46 = 1.8 time = 940
.meas tran vdout0_4ck46 FIND v(dout0_4) AT=940.1n

* CHECK dout0_5 Vdout0_5ck46 = 0 time = 940
.meas tran vdout0_5ck46 FIND v(dout0_5) AT=940.1n

* CHECK dout0_6 Vdout0_6ck46 = 0 time = 940
.meas tran vdout0_6ck46 FIND v(dout0_6) AT=940.1n

* CHECK dout0_7 Vdout0_7ck46 = 1.8 time = 940
.meas tran vdout0_7ck46 FIND v(dout0_7) AT=940.1n

* CHECK dout0_8 Vdout0_8ck46 = 0 time = 940
.meas tran vdout0_8ck46 FIND v(dout0_8) AT=940.1n

* CHECK dout0_9 Vdout0_9ck46 = 1.8 time = 940
.meas tran vdout0_9ck46 FIND v(dout0_9) AT=940.1n

* CHECK dout0_10 Vdout0_10ck46 = 0 time = 940
.meas tran vdout0_10ck46 FIND v(dout0_10) AT=940.1n

* CHECK dout0_11 Vdout0_11ck46 = 0 time = 940
.meas tran vdout0_11ck46 FIND v(dout0_11) AT=940.1n

* CHECK dout0_12 Vdout0_12ck46 = 1.8 time = 940
.meas tran vdout0_12ck46 FIND v(dout0_12) AT=940.1n

* CHECK dout0_13 Vdout0_13ck46 = 0 time = 940
.meas tran vdout0_13ck46 FIND v(dout0_13) AT=940.1n

* CHECK dout0_14 Vdout0_14ck46 = 0 time = 940
.meas tran vdout0_14ck46 FIND v(dout0_14) AT=940.1n

* CHECK dout0_15 Vdout0_15ck46 = 0 time = 940
.meas tran vdout0_15ck46 FIND v(dout0_15) AT=940.1n

* CHECK dout0_0 Vdout0_0ck47 = 1.8 time = 960
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=960.1n

* CHECK dout0_1 Vdout0_1ck47 = 1.8 time = 960
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=960.1n

* CHECK dout0_2 Vdout0_2ck47 = 0 time = 960
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=960.1n

* CHECK dout0_3 Vdout0_3ck47 = 1.8 time = 960
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=960.1n

* CHECK dout0_4 Vdout0_4ck47 = 1.8 time = 960
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=960.1n

* CHECK dout0_5 Vdout0_5ck47 = 1.8 time = 960
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=960.1n

* CHECK dout0_6 Vdout0_6ck47 = 0 time = 960
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=960.1n

* CHECK dout0_7 Vdout0_7ck47 = 0 time = 960
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=960.1n

* CHECK dout0_8 Vdout0_8ck47 = 1.8 time = 960
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=960.1n

* CHECK dout0_9 Vdout0_9ck47 = 0 time = 960
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=960.1n

* CHECK dout0_10 Vdout0_10ck47 = 1.8 time = 960
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=960.1n

* CHECK dout0_11 Vdout0_11ck47 = 1.8 time = 960
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=960.1n

* CHECK dout0_12 Vdout0_12ck47 = 0 time = 960
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=960.1n

* CHECK dout0_13 Vdout0_13ck47 = 1.8 time = 960
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=960.1n

* CHECK dout0_14 Vdout0_14ck47 = 0 time = 960
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=960.1n

* CHECK dout0_15 Vdout0_15ck47 = 1.8 time = 960
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=960.1n

* CHECK dout0_0 Vdout0_0ck50 = 0 time = 1020
.meas tran vdout0_0ck50 FIND v(dout0_0) AT=1020.1n

* CHECK dout0_1 Vdout0_1ck50 = 0 time = 1020
.meas tran vdout0_1ck50 FIND v(dout0_1) AT=1020.1n

* CHECK dout0_2 Vdout0_2ck50 = 1.8 time = 1020
.meas tran vdout0_2ck50 FIND v(dout0_2) AT=1020.1n

* CHECK dout0_3 Vdout0_3ck50 = 1.8 time = 1020
.meas tran vdout0_3ck50 FIND v(dout0_3) AT=1020.1n

* CHECK dout0_4 Vdout0_4ck50 = 0 time = 1020
.meas tran vdout0_4ck50 FIND v(dout0_4) AT=1020.1n

* CHECK dout0_5 Vdout0_5ck50 = 1.8 time = 1020
.meas tran vdout0_5ck50 FIND v(dout0_5) AT=1020.1n

* CHECK dout0_6 Vdout0_6ck50 = 1.8 time = 1020
.meas tran vdout0_6ck50 FIND v(dout0_6) AT=1020.1n

* CHECK dout0_7 Vdout0_7ck50 = 1.8 time = 1020
.meas tran vdout0_7ck50 FIND v(dout0_7) AT=1020.1n

* CHECK dout0_8 Vdout0_8ck50 = 1.8 time = 1020
.meas tran vdout0_8ck50 FIND v(dout0_8) AT=1020.1n

* CHECK dout0_9 Vdout0_9ck50 = 0 time = 1020
.meas tran vdout0_9ck50 FIND v(dout0_9) AT=1020.1n

* CHECK dout0_10 Vdout0_10ck50 = 0 time = 1020
.meas tran vdout0_10ck50 FIND v(dout0_10) AT=1020.1n

* CHECK dout0_11 Vdout0_11ck50 = 0 time = 1020
.meas tran vdout0_11ck50 FIND v(dout0_11) AT=1020.1n

* CHECK dout0_12 Vdout0_12ck50 = 1.8 time = 1020
.meas tran vdout0_12ck50 FIND v(dout0_12) AT=1020.1n

* CHECK dout0_13 Vdout0_13ck50 = 1.8 time = 1020
.meas tran vdout0_13ck50 FIND v(dout0_13) AT=1020.1n

* CHECK dout0_14 Vdout0_14ck50 = 0 time = 1020
.meas tran vdout0_14ck50 FIND v(dout0_14) AT=1020.1n

* CHECK dout0_15 Vdout0_15ck50 = 0 time = 1020
.meas tran vdout0_15ck50 FIND v(dout0_15) AT=1020.1n

* CHECK dout0_0 Vdout0_0ck51 = 0 time = 1040
.meas tran vdout0_0ck51 FIND v(dout0_0) AT=1040.1n

* CHECK dout0_1 Vdout0_1ck51 = 1.8 time = 1040
.meas tran vdout0_1ck51 FIND v(dout0_1) AT=1040.1n

* CHECK dout0_2 Vdout0_2ck51 = 1.8 time = 1040
.meas tran vdout0_2ck51 FIND v(dout0_2) AT=1040.1n

* CHECK dout0_3 Vdout0_3ck51 = 1.8 time = 1040
.meas tran vdout0_3ck51 FIND v(dout0_3) AT=1040.1n

* CHECK dout0_4 Vdout0_4ck51 = 1.8 time = 1040
.meas tran vdout0_4ck51 FIND v(dout0_4) AT=1040.1n

* CHECK dout0_5 Vdout0_5ck51 = 0 time = 1040
.meas tran vdout0_5ck51 FIND v(dout0_5) AT=1040.1n

* CHECK dout0_6 Vdout0_6ck51 = 0 time = 1040
.meas tran vdout0_6ck51 FIND v(dout0_6) AT=1040.1n

* CHECK dout0_7 Vdout0_7ck51 = 1.8 time = 1040
.meas tran vdout0_7ck51 FIND v(dout0_7) AT=1040.1n

* CHECK dout0_8 Vdout0_8ck51 = 0 time = 1040
.meas tran vdout0_8ck51 FIND v(dout0_8) AT=1040.1n

* CHECK dout0_9 Vdout0_9ck51 = 1.8 time = 1040
.meas tran vdout0_9ck51 FIND v(dout0_9) AT=1040.1n

* CHECK dout0_10 Vdout0_10ck51 = 0 time = 1040
.meas tran vdout0_10ck51 FIND v(dout0_10) AT=1040.1n

* CHECK dout0_11 Vdout0_11ck51 = 0 time = 1040
.meas tran vdout0_11ck51 FIND v(dout0_11) AT=1040.1n

* CHECK dout0_12 Vdout0_12ck51 = 1.8 time = 1040
.meas tran vdout0_12ck51 FIND v(dout0_12) AT=1040.1n

* CHECK dout0_13 Vdout0_13ck51 = 0 time = 1040
.meas tran vdout0_13ck51 FIND v(dout0_13) AT=1040.1n

* CHECK dout0_14 Vdout0_14ck51 = 0 time = 1040
.meas tran vdout0_14ck51 FIND v(dout0_14) AT=1040.1n

* CHECK dout0_15 Vdout0_15ck51 = 0 time = 1040
.meas tran vdout0_15ck51 FIND v(dout0_15) AT=1040.1n

* CHECK dout0_0 Vdout0_0ck52 = 0 time = 1060
.meas tran vdout0_0ck52 FIND v(dout0_0) AT=1060.1n

* CHECK dout0_1 Vdout0_1ck52 = 0 time = 1060
.meas tran vdout0_1ck52 FIND v(dout0_1) AT=1060.1n

* CHECK dout0_2 Vdout0_2ck52 = 1.8 time = 1060
.meas tran vdout0_2ck52 FIND v(dout0_2) AT=1060.1n

* CHECK dout0_3 Vdout0_3ck52 = 1.8 time = 1060
.meas tran vdout0_3ck52 FIND v(dout0_3) AT=1060.1n

* CHECK dout0_4 Vdout0_4ck52 = 1.8 time = 1060
.meas tran vdout0_4ck52 FIND v(dout0_4) AT=1060.1n

* CHECK dout0_5 Vdout0_5ck52 = 1.8 time = 1060
.meas tran vdout0_5ck52 FIND v(dout0_5) AT=1060.1n

* CHECK dout0_6 Vdout0_6ck52 = 1.8 time = 1060
.meas tran vdout0_6ck52 FIND v(dout0_6) AT=1060.1n

* CHECK dout0_7 Vdout0_7ck52 = 0 time = 1060
.meas tran vdout0_7ck52 FIND v(dout0_7) AT=1060.1n

* CHECK dout0_8 Vdout0_8ck52 = 1.8 time = 1060
.meas tran vdout0_8ck52 FIND v(dout0_8) AT=1060.1n

* CHECK dout0_9 Vdout0_9ck52 = 1.8 time = 1060
.meas tran vdout0_9ck52 FIND v(dout0_9) AT=1060.1n

* CHECK dout0_10 Vdout0_10ck52 = 0 time = 1060
.meas tran vdout0_10ck52 FIND v(dout0_10) AT=1060.1n

* CHECK dout0_11 Vdout0_11ck52 = 1.8 time = 1060
.meas tran vdout0_11ck52 FIND v(dout0_11) AT=1060.1n

* CHECK dout0_12 Vdout0_12ck52 = 0 time = 1060
.meas tran vdout0_12ck52 FIND v(dout0_12) AT=1060.1n

* CHECK dout0_13 Vdout0_13ck52 = 0 time = 1060
.meas tran vdout0_13ck52 FIND v(dout0_13) AT=1060.1n

* CHECK dout0_14 Vdout0_14ck52 = 1.8 time = 1060
.meas tran vdout0_14ck52 FIND v(dout0_14) AT=1060.1n

* CHECK dout0_15 Vdout0_15ck52 = 0 time = 1060
.meas tran vdout0_15ck52 FIND v(dout0_15) AT=1060.1n

* CHECK dout0_0 Vdout0_0ck54 = 0 time = 1100
.meas tran vdout0_0ck54 FIND v(dout0_0) AT=1100.1n

* CHECK dout0_1 Vdout0_1ck54 = 0 time = 1100
.meas tran vdout0_1ck54 FIND v(dout0_1) AT=1100.1n

* CHECK dout0_2 Vdout0_2ck54 = 1.8 time = 1100
.meas tran vdout0_2ck54 FIND v(dout0_2) AT=1100.1n

* CHECK dout0_3 Vdout0_3ck54 = 1.8 time = 1100
.meas tran vdout0_3ck54 FIND v(dout0_3) AT=1100.1n

* CHECK dout0_4 Vdout0_4ck54 = 0 time = 1100
.meas tran vdout0_4ck54 FIND v(dout0_4) AT=1100.1n

* CHECK dout0_5 Vdout0_5ck54 = 1.8 time = 1100
.meas tran vdout0_5ck54 FIND v(dout0_5) AT=1100.1n

* CHECK dout0_6 Vdout0_6ck54 = 1.8 time = 1100
.meas tran vdout0_6ck54 FIND v(dout0_6) AT=1100.1n

* CHECK dout0_7 Vdout0_7ck54 = 1.8 time = 1100
.meas tran vdout0_7ck54 FIND v(dout0_7) AT=1100.1n

* CHECK dout0_8 Vdout0_8ck54 = 1.8 time = 1100
.meas tran vdout0_8ck54 FIND v(dout0_8) AT=1100.1n

* CHECK dout0_9 Vdout0_9ck54 = 0 time = 1100
.meas tran vdout0_9ck54 FIND v(dout0_9) AT=1100.1n

* CHECK dout0_10 Vdout0_10ck54 = 0 time = 1100
.meas tran vdout0_10ck54 FIND v(dout0_10) AT=1100.1n

* CHECK dout0_11 Vdout0_11ck54 = 0 time = 1100
.meas tran vdout0_11ck54 FIND v(dout0_11) AT=1100.1n

* CHECK dout0_12 Vdout0_12ck54 = 1.8 time = 1100
.meas tran vdout0_12ck54 FIND v(dout0_12) AT=1100.1n

* CHECK dout0_13 Vdout0_13ck54 = 1.8 time = 1100
.meas tran vdout0_13ck54 FIND v(dout0_13) AT=1100.1n

* CHECK dout0_14 Vdout0_14ck54 = 0 time = 1100
.meas tran vdout0_14ck54 FIND v(dout0_14) AT=1100.1n

* CHECK dout0_15 Vdout0_15ck54 = 0 time = 1100
.meas tran vdout0_15ck54 FIND v(dout0_15) AT=1100.1n

* CHECK dout0_0 Vdout0_0ck56 = 1.8 time = 1140
.meas tran vdout0_0ck56 FIND v(dout0_0) AT=1140.1n

* CHECK dout0_1 Vdout0_1ck56 = 0 time = 1140
.meas tran vdout0_1ck56 FIND v(dout0_1) AT=1140.1n

* CHECK dout0_2 Vdout0_2ck56 = 1.8 time = 1140
.meas tran vdout0_2ck56 FIND v(dout0_2) AT=1140.1n

* CHECK dout0_3 Vdout0_3ck56 = 0 time = 1140
.meas tran vdout0_3ck56 FIND v(dout0_3) AT=1140.1n

* CHECK dout0_4 Vdout0_4ck56 = 0 time = 1140
.meas tran vdout0_4ck56 FIND v(dout0_4) AT=1140.1n

* CHECK dout0_5 Vdout0_5ck56 = 0 time = 1140
.meas tran vdout0_5ck56 FIND v(dout0_5) AT=1140.1n

* CHECK dout0_6 Vdout0_6ck56 = 0 time = 1140
.meas tran vdout0_6ck56 FIND v(dout0_6) AT=1140.1n

* CHECK dout0_7 Vdout0_7ck56 = 1.8 time = 1140
.meas tran vdout0_7ck56 FIND v(dout0_7) AT=1140.1n

* CHECK dout0_8 Vdout0_8ck56 = 1.8 time = 1140
.meas tran vdout0_8ck56 FIND v(dout0_8) AT=1140.1n

* CHECK dout0_9 Vdout0_9ck56 = 1.8 time = 1140
.meas tran vdout0_9ck56 FIND v(dout0_9) AT=1140.1n

* CHECK dout0_10 Vdout0_10ck56 = 0 time = 1140
.meas tran vdout0_10ck56 FIND v(dout0_10) AT=1140.1n

* CHECK dout0_11 Vdout0_11ck56 = 1.8 time = 1140
.meas tran vdout0_11ck56 FIND v(dout0_11) AT=1140.1n

* CHECK dout0_12 Vdout0_12ck56 = 1.8 time = 1140
.meas tran vdout0_12ck56 FIND v(dout0_12) AT=1140.1n

* CHECK dout0_13 Vdout0_13ck56 = 1.8 time = 1140
.meas tran vdout0_13ck56 FIND v(dout0_13) AT=1140.1n

* CHECK dout0_14 Vdout0_14ck56 = 1.8 time = 1140
.meas tran vdout0_14ck56 FIND v(dout0_14) AT=1140.1n

* CHECK dout0_15 Vdout0_15ck56 = 0 time = 1140
.meas tran vdout0_15ck56 FIND v(dout0_15) AT=1140.1n

* CHECK dout0_0 Vdout0_0ck58 = 0 time = 1180
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=1180.1n

* CHECK dout0_1 Vdout0_1ck58 = 0 time = 1180
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=1180.1n

* CHECK dout0_2 Vdout0_2ck58 = 1.8 time = 1180
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=1180.1n

* CHECK dout0_3 Vdout0_3ck58 = 1.8 time = 1180
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=1180.1n

* CHECK dout0_4 Vdout0_4ck58 = 1.8 time = 1180
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=1180.1n

* CHECK dout0_5 Vdout0_5ck58 = 1.8 time = 1180
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=1180.1n

* CHECK dout0_6 Vdout0_6ck58 = 1.8 time = 1180
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=1180.1n

* CHECK dout0_7 Vdout0_7ck58 = 0 time = 1180
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=1180.1n

* CHECK dout0_8 Vdout0_8ck58 = 1.8 time = 1180
.meas tran vdout0_8ck58 FIND v(dout0_8) AT=1180.1n

* CHECK dout0_9 Vdout0_9ck58 = 1.8 time = 1180
.meas tran vdout0_9ck58 FIND v(dout0_9) AT=1180.1n

* CHECK dout0_10 Vdout0_10ck58 = 0 time = 1180
.meas tran vdout0_10ck58 FIND v(dout0_10) AT=1180.1n

* CHECK dout0_11 Vdout0_11ck58 = 1.8 time = 1180
.meas tran vdout0_11ck58 FIND v(dout0_11) AT=1180.1n

* CHECK dout0_12 Vdout0_12ck58 = 0 time = 1180
.meas tran vdout0_12ck58 FIND v(dout0_12) AT=1180.1n

* CHECK dout0_13 Vdout0_13ck58 = 0 time = 1180
.meas tran vdout0_13ck58 FIND v(dout0_13) AT=1180.1n

* CHECK dout0_14 Vdout0_14ck58 = 1.8 time = 1180
.meas tran vdout0_14ck58 FIND v(dout0_14) AT=1180.1n

* CHECK dout0_15 Vdout0_15ck58 = 0 time = 1180
.meas tran vdout0_15ck58 FIND v(dout0_15) AT=1180.1n

* CHECK dout0_0 Vdout0_0ck61 = 1.8 time = 1240
.meas tran vdout0_0ck61 FIND v(dout0_0) AT=1240.1n

* CHECK dout0_1 Vdout0_1ck61 = 1.8 time = 1240
.meas tran vdout0_1ck61 FIND v(dout0_1) AT=1240.1n

* CHECK dout0_2 Vdout0_2ck61 = 0 time = 1240
.meas tran vdout0_2ck61 FIND v(dout0_2) AT=1240.1n

* CHECK dout0_3 Vdout0_3ck61 = 1.8 time = 1240
.meas tran vdout0_3ck61 FIND v(dout0_3) AT=1240.1n

* CHECK dout0_4 Vdout0_4ck61 = 1.8 time = 1240
.meas tran vdout0_4ck61 FIND v(dout0_4) AT=1240.1n

* CHECK dout0_5 Vdout0_5ck61 = 1.8 time = 1240
.meas tran vdout0_5ck61 FIND v(dout0_5) AT=1240.1n

* CHECK dout0_6 Vdout0_6ck61 = 0 time = 1240
.meas tran vdout0_6ck61 FIND v(dout0_6) AT=1240.1n

* CHECK dout0_7 Vdout0_7ck61 = 0 time = 1240
.meas tran vdout0_7ck61 FIND v(dout0_7) AT=1240.1n

* CHECK dout0_8 Vdout0_8ck61 = 1.8 time = 1240
.meas tran vdout0_8ck61 FIND v(dout0_8) AT=1240.1n

* CHECK dout0_9 Vdout0_9ck61 = 0 time = 1240
.meas tran vdout0_9ck61 FIND v(dout0_9) AT=1240.1n

* CHECK dout0_10 Vdout0_10ck61 = 1.8 time = 1240
.meas tran vdout0_10ck61 FIND v(dout0_10) AT=1240.1n

* CHECK dout0_11 Vdout0_11ck61 = 1.8 time = 1240
.meas tran vdout0_11ck61 FIND v(dout0_11) AT=1240.1n

* CHECK dout0_12 Vdout0_12ck61 = 0 time = 1240
.meas tran vdout0_12ck61 FIND v(dout0_12) AT=1240.1n

* CHECK dout0_13 Vdout0_13ck61 = 1.8 time = 1240
.meas tran vdout0_13ck61 FIND v(dout0_13) AT=1240.1n

* CHECK dout0_14 Vdout0_14ck61 = 0 time = 1240
.meas tran vdout0_14ck61 FIND v(dout0_14) AT=1240.1n

* CHECK dout0_15 Vdout0_15ck61 = 1.8 time = 1240
.meas tran vdout0_15ck61 FIND v(dout0_15) AT=1240.1n

* CHECK dout0_0 Vdout0_0ck63 = 1.8 time = 1280
.meas tran vdout0_0ck63 FIND v(dout0_0) AT=1280.1n

* CHECK dout0_1 Vdout0_1ck63 = 0 time = 1280
.meas tran vdout0_1ck63 FIND v(dout0_1) AT=1280.1n

* CHECK dout0_2 Vdout0_2ck63 = 1.8 time = 1280
.meas tran vdout0_2ck63 FIND v(dout0_2) AT=1280.1n

* CHECK dout0_3 Vdout0_3ck63 = 1.8 time = 1280
.meas tran vdout0_3ck63 FIND v(dout0_3) AT=1280.1n

* CHECK dout0_4 Vdout0_4ck63 = 0 time = 1280
.meas tran vdout0_4ck63 FIND v(dout0_4) AT=1280.1n

* CHECK dout0_5 Vdout0_5ck63 = 1.8 time = 1280
.meas tran vdout0_5ck63 FIND v(dout0_5) AT=1280.1n

* CHECK dout0_6 Vdout0_6ck63 = 1.8 time = 1280
.meas tran vdout0_6ck63 FIND v(dout0_6) AT=1280.1n

* CHECK dout0_7 Vdout0_7ck63 = 1.8 time = 1280
.meas tran vdout0_7ck63 FIND v(dout0_7) AT=1280.1n

* CHECK dout0_8 Vdout0_8ck63 = 1.8 time = 1280
.meas tran vdout0_8ck63 FIND v(dout0_8) AT=1280.1n

* CHECK dout0_9 Vdout0_9ck63 = 0 time = 1280
.meas tran vdout0_9ck63 FIND v(dout0_9) AT=1280.1n

* CHECK dout0_10 Vdout0_10ck63 = 1.8 time = 1280
.meas tran vdout0_10ck63 FIND v(dout0_10) AT=1280.1n

* CHECK dout0_11 Vdout0_11ck63 = 0 time = 1280
.meas tran vdout0_11ck63 FIND v(dout0_11) AT=1280.1n

* CHECK dout0_12 Vdout0_12ck63 = 0 time = 1280
.meas tran vdout0_12ck63 FIND v(dout0_12) AT=1280.1n

* CHECK dout0_13 Vdout0_13ck63 = 0 time = 1280
.meas tran vdout0_13ck63 FIND v(dout0_13) AT=1280.1n

* CHECK dout0_14 Vdout0_14ck63 = 1.8 time = 1280
.meas tran vdout0_14ck63 FIND v(dout0_14) AT=1280.1n

* CHECK dout0_15 Vdout0_15ck63 = 0 time = 1280
.meas tran vdout0_15ck63 FIND v(dout0_15) AT=1280.1n

* CHECK dout0_0 Vdout0_0ck65 = 1.8 time = 1320
.meas tran vdout0_0ck65 FIND v(dout0_0) AT=1320.1n

* CHECK dout0_1 Vdout0_1ck65 = 1.8 time = 1320
.meas tran vdout0_1ck65 FIND v(dout0_1) AT=1320.1n

* CHECK dout0_2 Vdout0_2ck65 = 0 time = 1320
.meas tran vdout0_2ck65 FIND v(dout0_2) AT=1320.1n

* CHECK dout0_3 Vdout0_3ck65 = 0 time = 1320
.meas tran vdout0_3ck65 FIND v(dout0_3) AT=1320.1n

* CHECK dout0_4 Vdout0_4ck65 = 1.8 time = 1320
.meas tran vdout0_4ck65 FIND v(dout0_4) AT=1320.1n

* CHECK dout0_5 Vdout0_5ck65 = 0 time = 1320
.meas tran vdout0_5ck65 FIND v(dout0_5) AT=1320.1n

* CHECK dout0_6 Vdout0_6ck65 = 0 time = 1320
.meas tran vdout0_6ck65 FIND v(dout0_6) AT=1320.1n

* CHECK dout0_7 Vdout0_7ck65 = 0 time = 1320
.meas tran vdout0_7ck65 FIND v(dout0_7) AT=1320.1n

* CHECK dout0_8 Vdout0_8ck65 = 0 time = 1320
.meas tran vdout0_8ck65 FIND v(dout0_8) AT=1320.1n

* CHECK dout0_9 Vdout0_9ck65 = 1.8 time = 1320
.meas tran vdout0_9ck65 FIND v(dout0_9) AT=1320.1n

* CHECK dout0_10 Vdout0_10ck65 = 0 time = 1320
.meas tran vdout0_10ck65 FIND v(dout0_10) AT=1320.1n

* CHECK dout0_11 Vdout0_11ck65 = 1.8 time = 1320
.meas tran vdout0_11ck65 FIND v(dout0_11) AT=1320.1n

* CHECK dout0_12 Vdout0_12ck65 = 0 time = 1320
.meas tran vdout0_12ck65 FIND v(dout0_12) AT=1320.1n

* CHECK dout0_13 Vdout0_13ck65 = 0 time = 1320
.meas tran vdout0_13ck65 FIND v(dout0_13) AT=1320.1n

* CHECK dout0_14 Vdout0_14ck65 = 1.8 time = 1320
.meas tran vdout0_14ck65 FIND v(dout0_14) AT=1320.1n

* CHECK dout0_15 Vdout0_15ck65 = 1.8 time = 1320
.meas tran vdout0_15ck65 FIND v(dout0_15) AT=1320.1n

* CHECK dout0_0 Vdout0_0ck66 = 1.8 time = 1340
.meas tran vdout0_0ck66 FIND v(dout0_0) AT=1340.1n

* CHECK dout0_1 Vdout0_1ck66 = 1.8 time = 1340
.meas tran vdout0_1ck66 FIND v(dout0_1) AT=1340.1n

* CHECK dout0_2 Vdout0_2ck66 = 0 time = 1340
.meas tran vdout0_2ck66 FIND v(dout0_2) AT=1340.1n

* CHECK dout0_3 Vdout0_3ck66 = 1.8 time = 1340
.meas tran vdout0_3ck66 FIND v(dout0_3) AT=1340.1n

* CHECK dout0_4 Vdout0_4ck66 = 0 time = 1340
.meas tran vdout0_4ck66 FIND v(dout0_4) AT=1340.1n

* CHECK dout0_5 Vdout0_5ck66 = 1.8 time = 1340
.meas tran vdout0_5ck66 FIND v(dout0_5) AT=1340.1n

* CHECK dout0_6 Vdout0_6ck66 = 1.8 time = 1340
.meas tran vdout0_6ck66 FIND v(dout0_6) AT=1340.1n

* CHECK dout0_7 Vdout0_7ck66 = 0 time = 1340
.meas tran vdout0_7ck66 FIND v(dout0_7) AT=1340.1n

* CHECK dout0_8 Vdout0_8ck66 = 1.8 time = 1340
.meas tran vdout0_8ck66 FIND v(dout0_8) AT=1340.1n

* CHECK dout0_9 Vdout0_9ck66 = 1.8 time = 1340
.meas tran vdout0_9ck66 FIND v(dout0_9) AT=1340.1n

* CHECK dout0_10 Vdout0_10ck66 = 1.8 time = 1340
.meas tran vdout0_10ck66 FIND v(dout0_10) AT=1340.1n

* CHECK dout0_11 Vdout0_11ck66 = 1.8 time = 1340
.meas tran vdout0_11ck66 FIND v(dout0_11) AT=1340.1n

* CHECK dout0_12 Vdout0_12ck66 = 1.8 time = 1340
.meas tran vdout0_12ck66 FIND v(dout0_12) AT=1340.1n

* CHECK dout0_13 Vdout0_13ck66 = 1.8 time = 1340
.meas tran vdout0_13ck66 FIND v(dout0_13) AT=1340.1n

* CHECK dout0_14 Vdout0_14ck66 = 1.8 time = 1340
.meas tran vdout0_14ck66 FIND v(dout0_14) AT=1340.1n

* CHECK dout0_15 Vdout0_15ck66 = 1.8 time = 1340
.meas tran vdout0_15ck66 FIND v(dout0_15) AT=1340.1n

* CHECK dout0_0 Vdout0_0ck68 = 1.8 time = 1380
.meas tran vdout0_0ck68 FIND v(dout0_0) AT=1380.1n

* CHECK dout0_1 Vdout0_1ck68 = 1.8 time = 1380
.meas tran vdout0_1ck68 FIND v(dout0_1) AT=1380.1n

* CHECK dout0_2 Vdout0_2ck68 = 0 time = 1380
.meas tran vdout0_2ck68 FIND v(dout0_2) AT=1380.1n

* CHECK dout0_3 Vdout0_3ck68 = 1.8 time = 1380
.meas tran vdout0_3ck68 FIND v(dout0_3) AT=1380.1n

* CHECK dout0_4 Vdout0_4ck68 = 1.8 time = 1380
.meas tran vdout0_4ck68 FIND v(dout0_4) AT=1380.1n

* CHECK dout0_5 Vdout0_5ck68 = 1.8 time = 1380
.meas tran vdout0_5ck68 FIND v(dout0_5) AT=1380.1n

* CHECK dout0_6 Vdout0_6ck68 = 0 time = 1380
.meas tran vdout0_6ck68 FIND v(dout0_6) AT=1380.1n

* CHECK dout0_7 Vdout0_7ck68 = 0 time = 1380
.meas tran vdout0_7ck68 FIND v(dout0_7) AT=1380.1n

* CHECK dout0_8 Vdout0_8ck68 = 1.8 time = 1380
.meas tran vdout0_8ck68 FIND v(dout0_8) AT=1380.1n

* CHECK dout0_9 Vdout0_9ck68 = 0 time = 1380
.meas tran vdout0_9ck68 FIND v(dout0_9) AT=1380.1n

* CHECK dout0_10 Vdout0_10ck68 = 1.8 time = 1380
.meas tran vdout0_10ck68 FIND v(dout0_10) AT=1380.1n

* CHECK dout0_11 Vdout0_11ck68 = 1.8 time = 1380
.meas tran vdout0_11ck68 FIND v(dout0_11) AT=1380.1n

* CHECK dout0_12 Vdout0_12ck68 = 0 time = 1380
.meas tran vdout0_12ck68 FIND v(dout0_12) AT=1380.1n

* CHECK dout0_13 Vdout0_13ck68 = 1.8 time = 1380
.meas tran vdout0_13ck68 FIND v(dout0_13) AT=1380.1n

* CHECK dout0_14 Vdout0_14ck68 = 0 time = 1380
.meas tran vdout0_14ck68 FIND v(dout0_14) AT=1380.1n

* CHECK dout0_15 Vdout0_15ck68 = 1.8 time = 1380
.meas tran vdout0_15ck68 FIND v(dout0_15) AT=1380.1n

* CHECK dout0_0 Vdout0_0ck69 = 1.8 time = 1400
.meas tran vdout0_0ck69 FIND v(dout0_0) AT=1400.1n

* CHECK dout0_1 Vdout0_1ck69 = 1.8 time = 1400
.meas tran vdout0_1ck69 FIND v(dout0_1) AT=1400.1n

* CHECK dout0_2 Vdout0_2ck69 = 0 time = 1400
.meas tran vdout0_2ck69 FIND v(dout0_2) AT=1400.1n

* CHECK dout0_3 Vdout0_3ck69 = 1.8 time = 1400
.meas tran vdout0_3ck69 FIND v(dout0_3) AT=1400.1n

* CHECK dout0_4 Vdout0_4ck69 = 0 time = 1400
.meas tran vdout0_4ck69 FIND v(dout0_4) AT=1400.1n

* CHECK dout0_5 Vdout0_5ck69 = 1.8 time = 1400
.meas tran vdout0_5ck69 FIND v(dout0_5) AT=1400.1n

* CHECK dout0_6 Vdout0_6ck69 = 1.8 time = 1400
.meas tran vdout0_6ck69 FIND v(dout0_6) AT=1400.1n

* CHECK dout0_7 Vdout0_7ck69 = 0 time = 1400
.meas tran vdout0_7ck69 FIND v(dout0_7) AT=1400.1n

* CHECK dout0_8 Vdout0_8ck69 = 1.8 time = 1400
.meas tran vdout0_8ck69 FIND v(dout0_8) AT=1400.1n

* CHECK dout0_9 Vdout0_9ck69 = 1.8 time = 1400
.meas tran vdout0_9ck69 FIND v(dout0_9) AT=1400.1n

* CHECK dout0_10 Vdout0_10ck69 = 1.8 time = 1400
.meas tran vdout0_10ck69 FIND v(dout0_10) AT=1400.1n

* CHECK dout0_11 Vdout0_11ck69 = 1.8 time = 1400
.meas tran vdout0_11ck69 FIND v(dout0_11) AT=1400.1n

* CHECK dout0_12 Vdout0_12ck69 = 1.8 time = 1400
.meas tran vdout0_12ck69 FIND v(dout0_12) AT=1400.1n

* CHECK dout0_13 Vdout0_13ck69 = 1.8 time = 1400
.meas tran vdout0_13ck69 FIND v(dout0_13) AT=1400.1n

* CHECK dout0_14 Vdout0_14ck69 = 1.8 time = 1400
.meas tran vdout0_14ck69 FIND v(dout0_14) AT=1400.1n

* CHECK dout0_15 Vdout0_15ck69 = 1.8 time = 1400
.meas tran vdout0_15ck69 FIND v(dout0_15) AT=1400.1n

* CHECK dout0_0 Vdout0_0ck70 = 1.8 time = 1420
.meas tran vdout0_0ck70 FIND v(dout0_0) AT=1420.1n

* CHECK dout0_1 Vdout0_1ck70 = 1.8 time = 1420
.meas tran vdout0_1ck70 FIND v(dout0_1) AT=1420.1n

* CHECK dout0_2 Vdout0_2ck70 = 0 time = 1420
.meas tran vdout0_2ck70 FIND v(dout0_2) AT=1420.1n

* CHECK dout0_3 Vdout0_3ck70 = 0 time = 1420
.meas tran vdout0_3ck70 FIND v(dout0_3) AT=1420.1n

* CHECK dout0_4 Vdout0_4ck70 = 1.8 time = 1420
.meas tran vdout0_4ck70 FIND v(dout0_4) AT=1420.1n

* CHECK dout0_5 Vdout0_5ck70 = 1.8 time = 1420
.meas tran vdout0_5ck70 FIND v(dout0_5) AT=1420.1n

* CHECK dout0_6 Vdout0_6ck70 = 1.8 time = 1420
.meas tran vdout0_6ck70 FIND v(dout0_6) AT=1420.1n

* CHECK dout0_7 Vdout0_7ck70 = 1.8 time = 1420
.meas tran vdout0_7ck70 FIND v(dout0_7) AT=1420.1n

* CHECK dout0_8 Vdout0_8ck70 = 0 time = 1420
.meas tran vdout0_8ck70 FIND v(dout0_8) AT=1420.1n

* CHECK dout0_9 Vdout0_9ck70 = 0 time = 1420
.meas tran vdout0_9ck70 FIND v(dout0_9) AT=1420.1n

* CHECK dout0_10 Vdout0_10ck70 = 0 time = 1420
.meas tran vdout0_10ck70 FIND v(dout0_10) AT=1420.1n

* CHECK dout0_11 Vdout0_11ck70 = 1.8 time = 1420
.meas tran vdout0_11ck70 FIND v(dout0_11) AT=1420.1n

* CHECK dout0_12 Vdout0_12ck70 = 1.8 time = 1420
.meas tran vdout0_12ck70 FIND v(dout0_12) AT=1420.1n

* CHECK dout0_13 Vdout0_13ck70 = 1.8 time = 1420
.meas tran vdout0_13ck70 FIND v(dout0_13) AT=1420.1n

* CHECK dout0_14 Vdout0_14ck70 = 0 time = 1420
.meas tran vdout0_14ck70 FIND v(dout0_14) AT=1420.1n

* CHECK dout0_15 Vdout0_15ck70 = 0 time = 1420
.meas tran vdout0_15ck70 FIND v(dout0_15) AT=1420.1n

* CHECK dout0_0 Vdout0_0ck72 = 1.8 time = 1460
.meas tran vdout0_0ck72 FIND v(dout0_0) AT=1460.1n

* CHECK dout0_1 Vdout0_1ck72 = 0 time = 1460
.meas tran vdout0_1ck72 FIND v(dout0_1) AT=1460.1n

* CHECK dout0_2 Vdout0_2ck72 = 0 time = 1460
.meas tran vdout0_2ck72 FIND v(dout0_2) AT=1460.1n

* CHECK dout0_3 Vdout0_3ck72 = 0 time = 1460
.meas tran vdout0_3ck72 FIND v(dout0_3) AT=1460.1n

* CHECK dout0_4 Vdout0_4ck72 = 0 time = 1460
.meas tran vdout0_4ck72 FIND v(dout0_4) AT=1460.1n

* CHECK dout0_5 Vdout0_5ck72 = 1.8 time = 1460
.meas tran vdout0_5ck72 FIND v(dout0_5) AT=1460.1n

* CHECK dout0_6 Vdout0_6ck72 = 0 time = 1460
.meas tran vdout0_6ck72 FIND v(dout0_6) AT=1460.1n

* CHECK dout0_7 Vdout0_7ck72 = 1.8 time = 1460
.meas tran vdout0_7ck72 FIND v(dout0_7) AT=1460.1n

* CHECK dout0_8 Vdout0_8ck72 = 0 time = 1460
.meas tran vdout0_8ck72 FIND v(dout0_8) AT=1460.1n

* CHECK dout0_9 Vdout0_9ck72 = 0 time = 1460
.meas tran vdout0_9ck72 FIND v(dout0_9) AT=1460.1n

* CHECK dout0_10 Vdout0_10ck72 = 0 time = 1460
.meas tran vdout0_10ck72 FIND v(dout0_10) AT=1460.1n

* CHECK dout0_11 Vdout0_11ck72 = 1.8 time = 1460
.meas tran vdout0_11ck72 FIND v(dout0_11) AT=1460.1n

* CHECK dout0_12 Vdout0_12ck72 = 0 time = 1460
.meas tran vdout0_12ck72 FIND v(dout0_12) AT=1460.1n

* CHECK dout0_13 Vdout0_13ck72 = 1.8 time = 1460
.meas tran vdout0_13ck72 FIND v(dout0_13) AT=1460.1n

* CHECK dout0_14 Vdout0_14ck72 = 1.8 time = 1460
.meas tran vdout0_14ck72 FIND v(dout0_14) AT=1460.1n

* CHECK dout0_15 Vdout0_15ck72 = 0 time = 1460
.meas tran vdout0_15ck72 FIND v(dout0_15) AT=1460.1n

* CHECK dout0_0 Vdout0_0ck73 = 1.8 time = 1480
.meas tran vdout0_0ck73 FIND v(dout0_0) AT=1480.1n

* CHECK dout0_1 Vdout0_1ck73 = 1.8 time = 1480
.meas tran vdout0_1ck73 FIND v(dout0_1) AT=1480.1n

* CHECK dout0_2 Vdout0_2ck73 = 0 time = 1480
.meas tran vdout0_2ck73 FIND v(dout0_2) AT=1480.1n

* CHECK dout0_3 Vdout0_3ck73 = 0 time = 1480
.meas tran vdout0_3ck73 FIND v(dout0_3) AT=1480.1n

* CHECK dout0_4 Vdout0_4ck73 = 1.8 time = 1480
.meas tran vdout0_4ck73 FIND v(dout0_4) AT=1480.1n

* CHECK dout0_5 Vdout0_5ck73 = 1.8 time = 1480
.meas tran vdout0_5ck73 FIND v(dout0_5) AT=1480.1n

* CHECK dout0_6 Vdout0_6ck73 = 0 time = 1480
.meas tran vdout0_6ck73 FIND v(dout0_6) AT=1480.1n

* CHECK dout0_7 Vdout0_7ck73 = 0 time = 1480
.meas tran vdout0_7ck73 FIND v(dout0_7) AT=1480.1n

* CHECK dout0_8 Vdout0_8ck73 = 0 time = 1480
.meas tran vdout0_8ck73 FIND v(dout0_8) AT=1480.1n

* CHECK dout0_9 Vdout0_9ck73 = 1.8 time = 1480
.meas tran vdout0_9ck73 FIND v(dout0_9) AT=1480.1n

* CHECK dout0_10 Vdout0_10ck73 = 1.8 time = 1480
.meas tran vdout0_10ck73 FIND v(dout0_10) AT=1480.1n

* CHECK dout0_11 Vdout0_11ck73 = 1.8 time = 1480
.meas tran vdout0_11ck73 FIND v(dout0_11) AT=1480.1n

* CHECK dout0_12 Vdout0_12ck73 = 0 time = 1480
.meas tran vdout0_12ck73 FIND v(dout0_12) AT=1480.1n

* CHECK dout0_13 Vdout0_13ck73 = 1.8 time = 1480
.meas tran vdout0_13ck73 FIND v(dout0_13) AT=1480.1n

* CHECK dout0_14 Vdout0_14ck73 = 1.8 time = 1480
.meas tran vdout0_14ck73 FIND v(dout0_14) AT=1480.1n

* CHECK dout0_15 Vdout0_15ck73 = 0 time = 1480
.meas tran vdout0_15ck73 FIND v(dout0_15) AT=1480.1n

* CHECK dout0_0 Vdout0_0ck74 = 1.8 time = 1500
.meas tran vdout0_0ck74 FIND v(dout0_0) AT=1500.1n

* CHECK dout0_1 Vdout0_1ck74 = 1.8 time = 1500
.meas tran vdout0_1ck74 FIND v(dout0_1) AT=1500.1n

* CHECK dout0_2 Vdout0_2ck74 = 0 time = 1500
.meas tran vdout0_2ck74 FIND v(dout0_2) AT=1500.1n

* CHECK dout0_3 Vdout0_3ck74 = 1.8 time = 1500
.meas tran vdout0_3ck74 FIND v(dout0_3) AT=1500.1n

* CHECK dout0_4 Vdout0_4ck74 = 0 time = 1500
.meas tran vdout0_4ck74 FIND v(dout0_4) AT=1500.1n

* CHECK dout0_5 Vdout0_5ck74 = 1.8 time = 1500
.meas tran vdout0_5ck74 FIND v(dout0_5) AT=1500.1n

* CHECK dout0_6 Vdout0_6ck74 = 1.8 time = 1500
.meas tran vdout0_6ck74 FIND v(dout0_6) AT=1500.1n

* CHECK dout0_7 Vdout0_7ck74 = 0 time = 1500
.meas tran vdout0_7ck74 FIND v(dout0_7) AT=1500.1n

* CHECK dout0_8 Vdout0_8ck74 = 1.8 time = 1500
.meas tran vdout0_8ck74 FIND v(dout0_8) AT=1500.1n

* CHECK dout0_9 Vdout0_9ck74 = 1.8 time = 1500
.meas tran vdout0_9ck74 FIND v(dout0_9) AT=1500.1n

* CHECK dout0_10 Vdout0_10ck74 = 1.8 time = 1500
.meas tran vdout0_10ck74 FIND v(dout0_10) AT=1500.1n

* CHECK dout0_11 Vdout0_11ck74 = 1.8 time = 1500
.meas tran vdout0_11ck74 FIND v(dout0_11) AT=1500.1n

* CHECK dout0_12 Vdout0_12ck74 = 1.8 time = 1500
.meas tran vdout0_12ck74 FIND v(dout0_12) AT=1500.1n

* CHECK dout0_13 Vdout0_13ck74 = 1.8 time = 1500
.meas tran vdout0_13ck74 FIND v(dout0_13) AT=1500.1n

* CHECK dout0_14 Vdout0_14ck74 = 1.8 time = 1500
.meas tran vdout0_14ck74 FIND v(dout0_14) AT=1500.1n

* CHECK dout0_15 Vdout0_15ck74 = 1.8 time = 1500
.meas tran vdout0_15ck74 FIND v(dout0_15) AT=1500.1n

* CHECK dout0_0 Vdout0_0ck75 = 1.8 time = 1520
.meas tran vdout0_0ck75 FIND v(dout0_0) AT=1520.1n

* CHECK dout0_1 Vdout0_1ck75 = 1.8 time = 1520
.meas tran vdout0_1ck75 FIND v(dout0_1) AT=1520.1n

* CHECK dout0_2 Vdout0_2ck75 = 0 time = 1520
.meas tran vdout0_2ck75 FIND v(dout0_2) AT=1520.1n

* CHECK dout0_3 Vdout0_3ck75 = 0 time = 1520
.meas tran vdout0_3ck75 FIND v(dout0_3) AT=1520.1n

* CHECK dout0_4 Vdout0_4ck75 = 1.8 time = 1520
.meas tran vdout0_4ck75 FIND v(dout0_4) AT=1520.1n

* CHECK dout0_5 Vdout0_5ck75 = 1.8 time = 1520
.meas tran vdout0_5ck75 FIND v(dout0_5) AT=1520.1n

* CHECK dout0_6 Vdout0_6ck75 = 0 time = 1520
.meas tran vdout0_6ck75 FIND v(dout0_6) AT=1520.1n

* CHECK dout0_7 Vdout0_7ck75 = 0 time = 1520
.meas tran vdout0_7ck75 FIND v(dout0_7) AT=1520.1n

* CHECK dout0_8 Vdout0_8ck75 = 0 time = 1520
.meas tran vdout0_8ck75 FIND v(dout0_8) AT=1520.1n

* CHECK dout0_9 Vdout0_9ck75 = 1.8 time = 1520
.meas tran vdout0_9ck75 FIND v(dout0_9) AT=1520.1n

* CHECK dout0_10 Vdout0_10ck75 = 1.8 time = 1520
.meas tran vdout0_10ck75 FIND v(dout0_10) AT=1520.1n

* CHECK dout0_11 Vdout0_11ck75 = 1.8 time = 1520
.meas tran vdout0_11ck75 FIND v(dout0_11) AT=1520.1n

* CHECK dout0_12 Vdout0_12ck75 = 0 time = 1520
.meas tran vdout0_12ck75 FIND v(dout0_12) AT=1520.1n

* CHECK dout0_13 Vdout0_13ck75 = 1.8 time = 1520
.meas tran vdout0_13ck75 FIND v(dout0_13) AT=1520.1n

* CHECK dout0_14 Vdout0_14ck75 = 1.8 time = 1520
.meas tran vdout0_14ck75 FIND v(dout0_14) AT=1520.1n

* CHECK dout0_15 Vdout0_15ck75 = 0 time = 1520
.meas tran vdout0_15ck75 FIND v(dout0_15) AT=1520.1n

* CHECK dout0_0 Vdout0_0ck78 = 1.8 time = 1580
.meas tran vdout0_0ck78 FIND v(dout0_0) AT=1580.1n

* CHECK dout0_1 Vdout0_1ck78 = 0 time = 1580
.meas tran vdout0_1ck78 FIND v(dout0_1) AT=1580.1n

* CHECK dout0_2 Vdout0_2ck78 = 0 time = 1580
.meas tran vdout0_2ck78 FIND v(dout0_2) AT=1580.1n

* CHECK dout0_3 Vdout0_3ck78 = 0 time = 1580
.meas tran vdout0_3ck78 FIND v(dout0_3) AT=1580.1n

* CHECK dout0_4 Vdout0_4ck78 = 0 time = 1580
.meas tran vdout0_4ck78 FIND v(dout0_4) AT=1580.1n

* CHECK dout0_5 Vdout0_5ck78 = 1.8 time = 1580
.meas tran vdout0_5ck78 FIND v(dout0_5) AT=1580.1n

* CHECK dout0_6 Vdout0_6ck78 = 0 time = 1580
.meas tran vdout0_6ck78 FIND v(dout0_6) AT=1580.1n

* CHECK dout0_7 Vdout0_7ck78 = 1.8 time = 1580
.meas tran vdout0_7ck78 FIND v(dout0_7) AT=1580.1n

* CHECK dout0_8 Vdout0_8ck78 = 0 time = 1580
.meas tran vdout0_8ck78 FIND v(dout0_8) AT=1580.1n

* CHECK dout0_9 Vdout0_9ck78 = 0 time = 1580
.meas tran vdout0_9ck78 FIND v(dout0_9) AT=1580.1n

* CHECK dout0_10 Vdout0_10ck78 = 0 time = 1580
.meas tran vdout0_10ck78 FIND v(dout0_10) AT=1580.1n

* CHECK dout0_11 Vdout0_11ck78 = 1.8 time = 1580
.meas tran vdout0_11ck78 FIND v(dout0_11) AT=1580.1n

* CHECK dout0_12 Vdout0_12ck78 = 0 time = 1580
.meas tran vdout0_12ck78 FIND v(dout0_12) AT=1580.1n

* CHECK dout0_13 Vdout0_13ck78 = 1.8 time = 1580
.meas tran vdout0_13ck78 FIND v(dout0_13) AT=1580.1n

* CHECK dout0_14 Vdout0_14ck78 = 1.8 time = 1580
.meas tran vdout0_14ck78 FIND v(dout0_14) AT=1580.1n

* CHECK dout0_15 Vdout0_15ck78 = 0 time = 1580
.meas tran vdout0_15ck78 FIND v(dout0_15) AT=1580.1n

* CHECK dout0_0 Vdout0_0ck80 = 1.8 time = 1620
.meas tran vdout0_0ck80 FIND v(dout0_0) AT=1620.1n

* CHECK dout0_1 Vdout0_1ck80 = 1.8 time = 1620
.meas tran vdout0_1ck80 FIND v(dout0_1) AT=1620.1n

* CHECK dout0_2 Vdout0_2ck80 = 0 time = 1620
.meas tran vdout0_2ck80 FIND v(dout0_2) AT=1620.1n

* CHECK dout0_3 Vdout0_3ck80 = 0 time = 1620
.meas tran vdout0_3ck80 FIND v(dout0_3) AT=1620.1n

* CHECK dout0_4 Vdout0_4ck80 = 1.8 time = 1620
.meas tran vdout0_4ck80 FIND v(dout0_4) AT=1620.1n

* CHECK dout0_5 Vdout0_5ck80 = 0 time = 1620
.meas tran vdout0_5ck80 FIND v(dout0_5) AT=1620.1n

* CHECK dout0_6 Vdout0_6ck80 = 0 time = 1620
.meas tran vdout0_6ck80 FIND v(dout0_6) AT=1620.1n

* CHECK dout0_7 Vdout0_7ck80 = 0 time = 1620
.meas tran vdout0_7ck80 FIND v(dout0_7) AT=1620.1n

* CHECK dout0_8 Vdout0_8ck80 = 0 time = 1620
.meas tran vdout0_8ck80 FIND v(dout0_8) AT=1620.1n

* CHECK dout0_9 Vdout0_9ck80 = 1.8 time = 1620
.meas tran vdout0_9ck80 FIND v(dout0_9) AT=1620.1n

* CHECK dout0_10 Vdout0_10ck80 = 0 time = 1620
.meas tran vdout0_10ck80 FIND v(dout0_10) AT=1620.1n

* CHECK dout0_11 Vdout0_11ck80 = 1.8 time = 1620
.meas tran vdout0_11ck80 FIND v(dout0_11) AT=1620.1n

* CHECK dout0_12 Vdout0_12ck80 = 0 time = 1620
.meas tran vdout0_12ck80 FIND v(dout0_12) AT=1620.1n

* CHECK dout0_13 Vdout0_13ck80 = 0 time = 1620
.meas tran vdout0_13ck80 FIND v(dout0_13) AT=1620.1n

* CHECK dout0_14 Vdout0_14ck80 = 1.8 time = 1620
.meas tran vdout0_14ck80 FIND v(dout0_14) AT=1620.1n

* CHECK dout0_15 Vdout0_15ck80 = 1.8 time = 1620
.meas tran vdout0_15ck80 FIND v(dout0_15) AT=1620.1n

* CHECK dout0_0 Vdout0_0ck82 = 1.8 time = 1660
.meas tran vdout0_0ck82 FIND v(dout0_0) AT=1660.1n

* CHECK dout0_1 Vdout0_1ck82 = 1.8 time = 1660
.meas tran vdout0_1ck82 FIND v(dout0_1) AT=1660.1n

* CHECK dout0_2 Vdout0_2ck82 = 0 time = 1660
.meas tran vdout0_2ck82 FIND v(dout0_2) AT=1660.1n

* CHECK dout0_3 Vdout0_3ck82 = 0 time = 1660
.meas tran vdout0_3ck82 FIND v(dout0_3) AT=1660.1n

* CHECK dout0_4 Vdout0_4ck82 = 1.8 time = 1660
.meas tran vdout0_4ck82 FIND v(dout0_4) AT=1660.1n

* CHECK dout0_5 Vdout0_5ck82 = 1.8 time = 1660
.meas tran vdout0_5ck82 FIND v(dout0_5) AT=1660.1n

* CHECK dout0_6 Vdout0_6ck82 = 0 time = 1660
.meas tran vdout0_6ck82 FIND v(dout0_6) AT=1660.1n

* CHECK dout0_7 Vdout0_7ck82 = 0 time = 1660
.meas tran vdout0_7ck82 FIND v(dout0_7) AT=1660.1n

* CHECK dout0_8 Vdout0_8ck82 = 0 time = 1660
.meas tran vdout0_8ck82 FIND v(dout0_8) AT=1660.1n

* CHECK dout0_9 Vdout0_9ck82 = 1.8 time = 1660
.meas tran vdout0_9ck82 FIND v(dout0_9) AT=1660.1n

* CHECK dout0_10 Vdout0_10ck82 = 1.8 time = 1660
.meas tran vdout0_10ck82 FIND v(dout0_10) AT=1660.1n

* CHECK dout0_11 Vdout0_11ck82 = 1.8 time = 1660
.meas tran vdout0_11ck82 FIND v(dout0_11) AT=1660.1n

* CHECK dout0_12 Vdout0_12ck82 = 0 time = 1660
.meas tran vdout0_12ck82 FIND v(dout0_12) AT=1660.1n

* CHECK dout0_13 Vdout0_13ck82 = 1.8 time = 1660
.meas tran vdout0_13ck82 FIND v(dout0_13) AT=1660.1n

* CHECK dout0_14 Vdout0_14ck82 = 1.8 time = 1660
.meas tran vdout0_14ck82 FIND v(dout0_14) AT=1660.1n

* CHECK dout0_15 Vdout0_15ck82 = 0 time = 1660
.meas tran vdout0_15ck82 FIND v(dout0_15) AT=1660.1n

* CHECK dout0_0 Vdout0_0ck83 = 1.8 time = 1680
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=1680.1n

* CHECK dout0_1 Vdout0_1ck83 = 0 time = 1680
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=1680.1n

* CHECK dout0_2 Vdout0_2ck83 = 0 time = 1680
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=1680.1n

* CHECK dout0_3 Vdout0_3ck83 = 0 time = 1680
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=1680.1n

* CHECK dout0_4 Vdout0_4ck83 = 0 time = 1680
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=1680.1n

* CHECK dout0_5 Vdout0_5ck83 = 1.8 time = 1680
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=1680.1n

* CHECK dout0_6 Vdout0_6ck83 = 0 time = 1680
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=1680.1n

* CHECK dout0_7 Vdout0_7ck83 = 1.8 time = 1680
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=1680.1n

* CHECK dout0_8 Vdout0_8ck83 = 0 time = 1680
.meas tran vdout0_8ck83 FIND v(dout0_8) AT=1680.1n

* CHECK dout0_9 Vdout0_9ck83 = 0 time = 1680
.meas tran vdout0_9ck83 FIND v(dout0_9) AT=1680.1n

* CHECK dout0_10 Vdout0_10ck83 = 0 time = 1680
.meas tran vdout0_10ck83 FIND v(dout0_10) AT=1680.1n

* CHECK dout0_11 Vdout0_11ck83 = 1.8 time = 1680
.meas tran vdout0_11ck83 FIND v(dout0_11) AT=1680.1n

* CHECK dout0_12 Vdout0_12ck83 = 0 time = 1680
.meas tran vdout0_12ck83 FIND v(dout0_12) AT=1680.1n

* CHECK dout0_13 Vdout0_13ck83 = 1.8 time = 1680
.meas tran vdout0_13ck83 FIND v(dout0_13) AT=1680.1n

* CHECK dout0_14 Vdout0_14ck83 = 1.8 time = 1680
.meas tran vdout0_14ck83 FIND v(dout0_14) AT=1680.1n

* CHECK dout0_15 Vdout0_15ck83 = 0 time = 1680
.meas tran vdout0_15ck83 FIND v(dout0_15) AT=1680.1n

* CHECK dout0_0 Vdout0_0ck84 = 1.8 time = 1700
.meas tran vdout0_0ck84 FIND v(dout0_0) AT=1700.1n

* CHECK dout0_1 Vdout0_1ck84 = 1.8 time = 1700
.meas tran vdout0_1ck84 FIND v(dout0_1) AT=1700.1n

* CHECK dout0_2 Vdout0_2ck84 = 0 time = 1700
.meas tran vdout0_2ck84 FIND v(dout0_2) AT=1700.1n

* CHECK dout0_3 Vdout0_3ck84 = 0 time = 1700
.meas tran vdout0_3ck84 FIND v(dout0_3) AT=1700.1n

* CHECK dout0_4 Vdout0_4ck84 = 1.8 time = 1700
.meas tran vdout0_4ck84 FIND v(dout0_4) AT=1700.1n

* CHECK dout0_5 Vdout0_5ck84 = 0 time = 1700
.meas tran vdout0_5ck84 FIND v(dout0_5) AT=1700.1n

* CHECK dout0_6 Vdout0_6ck84 = 0 time = 1700
.meas tran vdout0_6ck84 FIND v(dout0_6) AT=1700.1n

* CHECK dout0_7 Vdout0_7ck84 = 0 time = 1700
.meas tran vdout0_7ck84 FIND v(dout0_7) AT=1700.1n

* CHECK dout0_8 Vdout0_8ck84 = 0 time = 1700
.meas tran vdout0_8ck84 FIND v(dout0_8) AT=1700.1n

* CHECK dout0_9 Vdout0_9ck84 = 1.8 time = 1700
.meas tran vdout0_9ck84 FIND v(dout0_9) AT=1700.1n

* CHECK dout0_10 Vdout0_10ck84 = 0 time = 1700
.meas tran vdout0_10ck84 FIND v(dout0_10) AT=1700.1n

* CHECK dout0_11 Vdout0_11ck84 = 1.8 time = 1700
.meas tran vdout0_11ck84 FIND v(dout0_11) AT=1700.1n

* CHECK dout0_12 Vdout0_12ck84 = 0 time = 1700
.meas tran vdout0_12ck84 FIND v(dout0_12) AT=1700.1n

* CHECK dout0_13 Vdout0_13ck84 = 0 time = 1700
.meas tran vdout0_13ck84 FIND v(dout0_13) AT=1700.1n

* CHECK dout0_14 Vdout0_14ck84 = 1.8 time = 1700
.meas tran vdout0_14ck84 FIND v(dout0_14) AT=1700.1n

* CHECK dout0_15 Vdout0_15ck84 = 1.8 time = 1700
.meas tran vdout0_15ck84 FIND v(dout0_15) AT=1700.1n

* CHECK dout0_0 Vdout0_0ck86 = 1.8 time = 1740
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=1740.1n

* CHECK dout0_1 Vdout0_1ck86 = 0 time = 1740
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=1740.1n

* CHECK dout0_2 Vdout0_2ck86 = 0 time = 1740
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=1740.1n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 1740
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=1740.1n

* CHECK dout0_4 Vdout0_4ck86 = 0 time = 1740
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=1740.1n

* CHECK dout0_5 Vdout0_5ck86 = 1.8 time = 1740
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=1740.1n

* CHECK dout0_6 Vdout0_6ck86 = 0 time = 1740
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=1740.1n

* CHECK dout0_7 Vdout0_7ck86 = 1.8 time = 1740
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=1740.1n

* CHECK dout0_8 Vdout0_8ck86 = 0 time = 1740
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=1740.1n

* CHECK dout0_9 Vdout0_9ck86 = 0 time = 1740
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=1740.1n

* CHECK dout0_10 Vdout0_10ck86 = 0 time = 1740
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=1740.1n

* CHECK dout0_11 Vdout0_11ck86 = 1.8 time = 1740
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=1740.1n

* CHECK dout0_12 Vdout0_12ck86 = 0 time = 1740
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=1740.1n

* CHECK dout0_13 Vdout0_13ck86 = 1.8 time = 1740
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=1740.1n

* CHECK dout0_14 Vdout0_14ck86 = 1.8 time = 1740
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=1740.1n

* CHECK dout0_15 Vdout0_15ck86 = 0 time = 1740
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=1740.1n

* CHECK dout0_0 Vdout0_0ck87 = 1.8 time = 1760
.meas tran vdout0_0ck87 FIND v(dout0_0) AT=1760.1n

* CHECK dout0_1 Vdout0_1ck87 = 1.8 time = 1760
.meas tran vdout0_1ck87 FIND v(dout0_1) AT=1760.1n

* CHECK dout0_2 Vdout0_2ck87 = 0 time = 1760
.meas tran vdout0_2ck87 FIND v(dout0_2) AT=1760.1n

* CHECK dout0_3 Vdout0_3ck87 = 0 time = 1760
.meas tran vdout0_3ck87 FIND v(dout0_3) AT=1760.1n

* CHECK dout0_4 Vdout0_4ck87 = 1.8 time = 1760
.meas tran vdout0_4ck87 FIND v(dout0_4) AT=1760.1n

* CHECK dout0_5 Vdout0_5ck87 = 0 time = 1760
.meas tran vdout0_5ck87 FIND v(dout0_5) AT=1760.1n

* CHECK dout0_6 Vdout0_6ck87 = 0 time = 1760
.meas tran vdout0_6ck87 FIND v(dout0_6) AT=1760.1n

* CHECK dout0_7 Vdout0_7ck87 = 0 time = 1760
.meas tran vdout0_7ck87 FIND v(dout0_7) AT=1760.1n

* CHECK dout0_8 Vdout0_8ck87 = 0 time = 1760
.meas tran vdout0_8ck87 FIND v(dout0_8) AT=1760.1n

* CHECK dout0_9 Vdout0_9ck87 = 1.8 time = 1760
.meas tran vdout0_9ck87 FIND v(dout0_9) AT=1760.1n

* CHECK dout0_10 Vdout0_10ck87 = 0 time = 1760
.meas tran vdout0_10ck87 FIND v(dout0_10) AT=1760.1n

* CHECK dout0_11 Vdout0_11ck87 = 1.8 time = 1760
.meas tran vdout0_11ck87 FIND v(dout0_11) AT=1760.1n

* CHECK dout0_12 Vdout0_12ck87 = 0 time = 1760
.meas tran vdout0_12ck87 FIND v(dout0_12) AT=1760.1n

* CHECK dout0_13 Vdout0_13ck87 = 0 time = 1760
.meas tran vdout0_13ck87 FIND v(dout0_13) AT=1760.1n

* CHECK dout0_14 Vdout0_14ck87 = 1.8 time = 1760
.meas tran vdout0_14ck87 FIND v(dout0_14) AT=1760.1n

* CHECK dout0_15 Vdout0_15ck87 = 1.8 time = 1760
.meas tran vdout0_15ck87 FIND v(dout0_15) AT=1760.1n

* CHECK dout0_0 Vdout0_0ck91 = 1.8 time = 1840
.meas tran vdout0_0ck91 FIND v(dout0_0) AT=1840.1n

* CHECK dout0_1 Vdout0_1ck91 = 1.8 time = 1840
.meas tran vdout0_1ck91 FIND v(dout0_1) AT=1840.1n

* CHECK dout0_2 Vdout0_2ck91 = 0 time = 1840
.meas tran vdout0_2ck91 FIND v(dout0_2) AT=1840.1n

* CHECK dout0_3 Vdout0_3ck91 = 0 time = 1840
.meas tran vdout0_3ck91 FIND v(dout0_3) AT=1840.1n

* CHECK dout0_4 Vdout0_4ck91 = 0 time = 1840
.meas tran vdout0_4ck91 FIND v(dout0_4) AT=1840.1n

* CHECK dout0_5 Vdout0_5ck91 = 1.8 time = 1840
.meas tran vdout0_5ck91 FIND v(dout0_5) AT=1840.1n

* CHECK dout0_6 Vdout0_6ck91 = 0 time = 1840
.meas tran vdout0_6ck91 FIND v(dout0_6) AT=1840.1n

* CHECK dout0_7 Vdout0_7ck91 = 0 time = 1840
.meas tran vdout0_7ck91 FIND v(dout0_7) AT=1840.1n

* CHECK dout0_8 Vdout0_8ck91 = 1.8 time = 1840
.meas tran vdout0_8ck91 FIND v(dout0_8) AT=1840.1n

* CHECK dout0_9 Vdout0_9ck91 = 0 time = 1840
.meas tran vdout0_9ck91 FIND v(dout0_9) AT=1840.1n

* CHECK dout0_10 Vdout0_10ck91 = 1.8 time = 1840
.meas tran vdout0_10ck91 FIND v(dout0_10) AT=1840.1n

* CHECK dout0_11 Vdout0_11ck91 = 1.8 time = 1840
.meas tran vdout0_11ck91 FIND v(dout0_11) AT=1840.1n

* CHECK dout0_12 Vdout0_12ck91 = 1.8 time = 1840
.meas tran vdout0_12ck91 FIND v(dout0_12) AT=1840.1n

* CHECK dout0_13 Vdout0_13ck91 = 1.8 time = 1840
.meas tran vdout0_13ck91 FIND v(dout0_13) AT=1840.1n

* CHECK dout0_14 Vdout0_14ck91 = 1.8 time = 1840
.meas tran vdout0_14ck91 FIND v(dout0_14) AT=1840.1n

* CHECK dout0_15 Vdout0_15ck91 = 0 time = 1840
.meas tran vdout0_15ck91 FIND v(dout0_15) AT=1840.1n

* CHECK dout0_0 Vdout0_0ck92 = 1.8 time = 1860
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=1860.1n

* CHECK dout0_1 Vdout0_1ck92 = 0 time = 1860
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=1860.1n

* CHECK dout0_2 Vdout0_2ck92 = 0 time = 1860
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=1860.1n

* CHECK dout0_3 Vdout0_3ck92 = 0 time = 1860
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=1860.1n

* CHECK dout0_4 Vdout0_4ck92 = 1.8 time = 1860
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=1860.1n

* CHECK dout0_5 Vdout0_5ck92 = 1.8 time = 1860
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=1860.1n

* CHECK dout0_6 Vdout0_6ck92 = 1.8 time = 1860
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=1860.1n

* CHECK dout0_7 Vdout0_7ck92 = 1.8 time = 1860
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=1860.1n

* CHECK dout0_8 Vdout0_8ck92 = 0 time = 1860
.meas tran vdout0_8ck92 FIND v(dout0_8) AT=1860.1n

* CHECK dout0_9 Vdout0_9ck92 = 1.8 time = 1860
.meas tran vdout0_9ck92 FIND v(dout0_9) AT=1860.1n

* CHECK dout0_10 Vdout0_10ck92 = 0 time = 1860
.meas tran vdout0_10ck92 FIND v(dout0_10) AT=1860.1n

* CHECK dout0_11 Vdout0_11ck92 = 0 time = 1860
.meas tran vdout0_11ck92 FIND v(dout0_11) AT=1860.1n

* CHECK dout0_12 Vdout0_12ck92 = 0 time = 1860
.meas tran vdout0_12ck92 FIND v(dout0_12) AT=1860.1n

* CHECK dout0_13 Vdout0_13ck92 = 1.8 time = 1860
.meas tran vdout0_13ck92 FIND v(dout0_13) AT=1860.1n

* CHECK dout0_14 Vdout0_14ck92 = 1.8 time = 1860
.meas tran vdout0_14ck92 FIND v(dout0_14) AT=1860.1n

* CHECK dout0_15 Vdout0_15ck92 = 1.8 time = 1860
.meas tran vdout0_15ck92 FIND v(dout0_15) AT=1860.1n

* CHECK dout0_0 Vdout0_0ck93 = 1.8 time = 1880
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=1880.1n

* CHECK dout0_1 Vdout0_1ck93 = 0 time = 1880
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=1880.1n

* CHECK dout0_2 Vdout0_2ck93 = 0 time = 1880
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=1880.1n

* CHECK dout0_3 Vdout0_3ck93 = 0 time = 1880
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=1880.1n

* CHECK dout0_4 Vdout0_4ck93 = 1.8 time = 1880
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=1880.1n

* CHECK dout0_5 Vdout0_5ck93 = 1.8 time = 1880
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=1880.1n

* CHECK dout0_6 Vdout0_6ck93 = 1.8 time = 1880
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=1880.1n

* CHECK dout0_7 Vdout0_7ck93 = 1.8 time = 1880
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=1880.1n

* CHECK dout0_8 Vdout0_8ck93 = 0 time = 1880
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=1880.1n

* CHECK dout0_9 Vdout0_9ck93 = 1.8 time = 1880
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=1880.1n

* CHECK dout0_10 Vdout0_10ck93 = 0 time = 1880
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=1880.1n

* CHECK dout0_11 Vdout0_11ck93 = 0 time = 1880
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=1880.1n

* CHECK dout0_12 Vdout0_12ck93 = 0 time = 1880
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=1880.1n

* CHECK dout0_13 Vdout0_13ck93 = 1.8 time = 1880
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=1880.1n

* CHECK dout0_14 Vdout0_14ck93 = 1.8 time = 1880
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=1880.1n

* CHECK dout0_15 Vdout0_15ck93 = 1.8 time = 1880
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=1880.1n

* CHECK dout0_0 Vdout0_0ck96 = 1.8 time = 1940
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=1940.1n

* CHECK dout0_1 Vdout0_1ck96 = 0 time = 1940
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=1940.1n

* CHECK dout0_2 Vdout0_2ck96 = 0 time = 1940
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=1940.1n

* CHECK dout0_3 Vdout0_3ck96 = 0 time = 1940
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=1940.1n

* CHECK dout0_4 Vdout0_4ck96 = 1.8 time = 1940
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=1940.1n

* CHECK dout0_5 Vdout0_5ck96 = 1.8 time = 1940
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=1940.1n

* CHECK dout0_6 Vdout0_6ck96 = 1.8 time = 1940
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=1940.1n

* CHECK dout0_7 Vdout0_7ck96 = 1.8 time = 1940
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=1940.1n

* CHECK dout0_8 Vdout0_8ck96 = 0 time = 1940
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=1940.1n

* CHECK dout0_9 Vdout0_9ck96 = 1.8 time = 1940
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=1940.1n

* CHECK dout0_10 Vdout0_10ck96 = 0 time = 1940
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=1940.1n

* CHECK dout0_11 Vdout0_11ck96 = 0 time = 1940
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=1940.1n

* CHECK dout0_12 Vdout0_12ck96 = 0 time = 1940
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=1940.1n

* CHECK dout0_13 Vdout0_13ck96 = 1.8 time = 1940
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=1940.1n

* CHECK dout0_14 Vdout0_14ck96 = 1.8 time = 1940
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=1940.1n

* CHECK dout0_15 Vdout0_15ck96 = 1.8 time = 1940
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=1940.1n

* CHECK dout0_0 Vdout0_0ck98 = 1.8 time = 1980
.meas tran vdout0_0ck98 FIND v(dout0_0) AT=1980.1n

* CHECK dout0_1 Vdout0_1ck98 = 1.8 time = 1980
.meas tran vdout0_1ck98 FIND v(dout0_1) AT=1980.1n

* CHECK dout0_2 Vdout0_2ck98 = 0 time = 1980
.meas tran vdout0_2ck98 FIND v(dout0_2) AT=1980.1n

* CHECK dout0_3 Vdout0_3ck98 = 0 time = 1980
.meas tran vdout0_3ck98 FIND v(dout0_3) AT=1980.1n

* CHECK dout0_4 Vdout0_4ck98 = 0 time = 1980
.meas tran vdout0_4ck98 FIND v(dout0_4) AT=1980.1n

* CHECK dout0_5 Vdout0_5ck98 = 1.8 time = 1980
.meas tran vdout0_5ck98 FIND v(dout0_5) AT=1980.1n

* CHECK dout0_6 Vdout0_6ck98 = 0 time = 1980
.meas tran vdout0_6ck98 FIND v(dout0_6) AT=1980.1n

* CHECK dout0_7 Vdout0_7ck98 = 0 time = 1980
.meas tran vdout0_7ck98 FIND v(dout0_7) AT=1980.1n

* CHECK dout0_8 Vdout0_8ck98 = 1.8 time = 1980
.meas tran vdout0_8ck98 FIND v(dout0_8) AT=1980.1n

* CHECK dout0_9 Vdout0_9ck98 = 0 time = 1980
.meas tran vdout0_9ck98 FIND v(dout0_9) AT=1980.1n

* CHECK dout0_10 Vdout0_10ck98 = 1.8 time = 1980
.meas tran vdout0_10ck98 FIND v(dout0_10) AT=1980.1n

* CHECK dout0_11 Vdout0_11ck98 = 1.8 time = 1980
.meas tran vdout0_11ck98 FIND v(dout0_11) AT=1980.1n

* CHECK dout0_12 Vdout0_12ck98 = 1.8 time = 1980
.meas tran vdout0_12ck98 FIND v(dout0_12) AT=1980.1n

* CHECK dout0_13 Vdout0_13ck98 = 1.8 time = 1980
.meas tran vdout0_13ck98 FIND v(dout0_13) AT=1980.1n

* CHECK dout0_14 Vdout0_14ck98 = 1.8 time = 1980
.meas tran vdout0_14ck98 FIND v(dout0_14) AT=1980.1n

* CHECK dout0_15 Vdout0_15ck98 = 0 time = 1980
.meas tran vdout0_15ck98 FIND v(dout0_15) AT=1980.1n

* CHECK dout0_0 Vdout0_0ck99 = 1.8 time = 2000
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=2000.1n

* CHECK dout0_1 Vdout0_1ck99 = 0 time = 2000
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=2000.1n

* CHECK dout0_2 Vdout0_2ck99 = 1.8 time = 2000
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=2000.1n

* CHECK dout0_3 Vdout0_3ck99 = 0 time = 2000
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=2000.1n

* CHECK dout0_4 Vdout0_4ck99 = 1.8 time = 2000
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=2000.1n

* CHECK dout0_5 Vdout0_5ck99 = 0 time = 2000
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=2000.1n

* CHECK dout0_6 Vdout0_6ck99 = 0 time = 2000
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=2000.1n

* CHECK dout0_7 Vdout0_7ck99 = 0 time = 2000
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=2000.1n

* CHECK dout0_8 Vdout0_8ck99 = 1.8 time = 2000
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=2000.1n

* CHECK dout0_9 Vdout0_9ck99 = 0 time = 2000
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=2000.1n

* CHECK dout0_10 Vdout0_10ck99 = 1.8 time = 2000
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=2000.1n

* CHECK dout0_11 Vdout0_11ck99 = 0 time = 2000
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=2000.1n

* CHECK dout0_12 Vdout0_12ck99 = 1.8 time = 2000
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=2000.1n

* CHECK dout0_13 Vdout0_13ck99 = 1.8 time = 2000
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=2000.1n

* CHECK dout0_14 Vdout0_14ck99 = 0 time = 2000
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=2000.1n

* CHECK dout0_15 Vdout0_15ck99 = 1.8 time = 2000
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=2000.1n

* CHECK dout0_0 Vdout0_0ck101 = 1.8 time = 2040
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=2040.1n

* CHECK dout0_1 Vdout0_1ck101 = 0 time = 2040
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=2040.1n

* CHECK dout0_2 Vdout0_2ck101 = 0 time = 2040
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=2040.1n

* CHECK dout0_3 Vdout0_3ck101 = 0 time = 2040
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=2040.1n

* CHECK dout0_4 Vdout0_4ck101 = 1.8 time = 2040
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=2040.1n

* CHECK dout0_5 Vdout0_5ck101 = 1.8 time = 2040
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=2040.1n

* CHECK dout0_6 Vdout0_6ck101 = 1.8 time = 2040
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=2040.1n

* CHECK dout0_7 Vdout0_7ck101 = 1.8 time = 2040
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=2040.1n

* CHECK dout0_8 Vdout0_8ck101 = 0 time = 2040
.meas tran vdout0_8ck101 FIND v(dout0_8) AT=2040.1n

* CHECK dout0_9 Vdout0_9ck101 = 1.8 time = 2040
.meas tran vdout0_9ck101 FIND v(dout0_9) AT=2040.1n

* CHECK dout0_10 Vdout0_10ck101 = 0 time = 2040
.meas tran vdout0_10ck101 FIND v(dout0_10) AT=2040.1n

* CHECK dout0_11 Vdout0_11ck101 = 0 time = 2040
.meas tran vdout0_11ck101 FIND v(dout0_11) AT=2040.1n

* CHECK dout0_12 Vdout0_12ck101 = 0 time = 2040
.meas tran vdout0_12ck101 FIND v(dout0_12) AT=2040.1n

* CHECK dout0_13 Vdout0_13ck101 = 1.8 time = 2040
.meas tran vdout0_13ck101 FIND v(dout0_13) AT=2040.1n

* CHECK dout0_14 Vdout0_14ck101 = 1.8 time = 2040
.meas tran vdout0_14ck101 FIND v(dout0_14) AT=2040.1n

* CHECK dout0_15 Vdout0_15ck101 = 1.8 time = 2040
.meas tran vdout0_15ck101 FIND v(dout0_15) AT=2040.1n

* CHECK dout0_0 Vdout0_0ck102 = 1.8 time = 2060
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=2060.1n

* CHECK dout0_1 Vdout0_1ck102 = 1.8 time = 2060
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=2060.1n

* CHECK dout0_2 Vdout0_2ck102 = 0 time = 2060
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=2060.1n

* CHECK dout0_3 Vdout0_3ck102 = 0 time = 2060
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=2060.1n

* CHECK dout0_4 Vdout0_4ck102 = 1.8 time = 2060
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=2060.1n

* CHECK dout0_5 Vdout0_5ck102 = 0 time = 2060
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=2060.1n

* CHECK dout0_6 Vdout0_6ck102 = 0 time = 2060
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=2060.1n

* CHECK dout0_7 Vdout0_7ck102 = 0 time = 2060
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=2060.1n

* CHECK dout0_8 Vdout0_8ck102 = 0 time = 2060
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=2060.1n

* CHECK dout0_9 Vdout0_9ck102 = 1.8 time = 2060
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=2060.1n

* CHECK dout0_10 Vdout0_10ck102 = 0 time = 2060
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=2060.1n

* CHECK dout0_11 Vdout0_11ck102 = 1.8 time = 2060
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=2060.1n

* CHECK dout0_12 Vdout0_12ck102 = 0 time = 2060
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=2060.1n

* CHECK dout0_13 Vdout0_13ck102 = 0 time = 2060
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=2060.1n

* CHECK dout0_14 Vdout0_14ck102 = 1.8 time = 2060
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=2060.1n

* CHECK dout0_15 Vdout0_15ck102 = 1.8 time = 2060
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=2060.1n

* CHECK dout0_0 Vdout0_0ck105 = 1.8 time = 2120
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=2120.1n

* CHECK dout0_1 Vdout0_1ck105 = 0 time = 2120
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=2120.1n

* CHECK dout0_2 Vdout0_2ck105 = 0 time = 2120
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=2120.1n

* CHECK dout0_3 Vdout0_3ck105 = 0 time = 2120
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=2120.1n

* CHECK dout0_4 Vdout0_4ck105 = 1.8 time = 2120
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=2120.1n

* CHECK dout0_5 Vdout0_5ck105 = 1.8 time = 2120
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=2120.1n

* CHECK dout0_6 Vdout0_6ck105 = 1.8 time = 2120
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=2120.1n

* CHECK dout0_7 Vdout0_7ck105 = 1.8 time = 2120
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=2120.1n

* CHECK dout0_8 Vdout0_8ck105 = 0 time = 2120
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=2120.1n

* CHECK dout0_9 Vdout0_9ck105 = 1.8 time = 2120
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=2120.1n

* CHECK dout0_10 Vdout0_10ck105 = 0 time = 2120
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=2120.1n

* CHECK dout0_11 Vdout0_11ck105 = 0 time = 2120
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=2120.1n

* CHECK dout0_12 Vdout0_12ck105 = 0 time = 2120
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=2120.1n

* CHECK dout0_13 Vdout0_13ck105 = 1.8 time = 2120
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=2120.1n

* CHECK dout0_14 Vdout0_14ck105 = 1.8 time = 2120
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=2120.1n

* CHECK dout0_15 Vdout0_15ck105 = 1.8 time = 2120
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=2120.1n

* CHECK dout0_0 Vdout0_0ck106 = 1.8 time = 2140
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=2140.1n

* CHECK dout0_1 Vdout0_1ck106 = 1.8 time = 2140
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=2140.1n

* CHECK dout0_2 Vdout0_2ck106 = 0 time = 2140
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=2140.1n

* CHECK dout0_3 Vdout0_3ck106 = 0 time = 2140
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=2140.1n

* CHECK dout0_4 Vdout0_4ck106 = 1.8 time = 2140
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=2140.1n

* CHECK dout0_5 Vdout0_5ck106 = 1.8 time = 2140
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=2140.1n

* CHECK dout0_6 Vdout0_6ck106 = 0 time = 2140
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=2140.1n

* CHECK dout0_7 Vdout0_7ck106 = 0 time = 2140
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=2140.1n

* CHECK dout0_8 Vdout0_8ck106 = 0 time = 2140
.meas tran vdout0_8ck106 FIND v(dout0_8) AT=2140.1n

* CHECK dout0_9 Vdout0_9ck106 = 1.8 time = 2140
.meas tran vdout0_9ck106 FIND v(dout0_9) AT=2140.1n

* CHECK dout0_10 Vdout0_10ck106 = 1.8 time = 2140
.meas tran vdout0_10ck106 FIND v(dout0_10) AT=2140.1n

* CHECK dout0_11 Vdout0_11ck106 = 1.8 time = 2140
.meas tran vdout0_11ck106 FIND v(dout0_11) AT=2140.1n

* CHECK dout0_12 Vdout0_12ck106 = 0 time = 2140
.meas tran vdout0_12ck106 FIND v(dout0_12) AT=2140.1n

* CHECK dout0_13 Vdout0_13ck106 = 1.8 time = 2140
.meas tran vdout0_13ck106 FIND v(dout0_13) AT=2140.1n

* CHECK dout0_14 Vdout0_14ck106 = 1.8 time = 2140
.meas tran vdout0_14ck106 FIND v(dout0_14) AT=2140.1n

* CHECK dout0_15 Vdout0_15ck106 = 0 time = 2140
.meas tran vdout0_15ck106 FIND v(dout0_15) AT=2140.1n

* CHECK dout0_0 Vdout0_0ck107 = 1.8 time = 2160
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=2160.1n

* CHECK dout0_1 Vdout0_1ck107 = 1.8 time = 2160
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=2160.1n

* CHECK dout0_2 Vdout0_2ck107 = 0 time = 2160
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=2160.1n

* CHECK dout0_3 Vdout0_3ck107 = 0 time = 2160
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=2160.1n

* CHECK dout0_4 Vdout0_4ck107 = 1.8 time = 2160
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=2160.1n

* CHECK dout0_5 Vdout0_5ck107 = 1.8 time = 2160
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=2160.1n

* CHECK dout0_6 Vdout0_6ck107 = 0 time = 2160
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=2160.1n

* CHECK dout0_7 Vdout0_7ck107 = 0 time = 2160
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=2160.1n

* CHECK dout0_8 Vdout0_8ck107 = 0 time = 2160
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=2160.1n

* CHECK dout0_9 Vdout0_9ck107 = 1.8 time = 2160
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=2160.1n

* CHECK dout0_10 Vdout0_10ck107 = 1.8 time = 2160
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=2160.1n

* CHECK dout0_11 Vdout0_11ck107 = 1.8 time = 2160
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=2160.1n

* CHECK dout0_12 Vdout0_12ck107 = 0 time = 2160
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=2160.1n

* CHECK dout0_13 Vdout0_13ck107 = 1.8 time = 2160
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=2160.1n

* CHECK dout0_14 Vdout0_14ck107 = 1.8 time = 2160
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=2160.1n

* CHECK dout0_15 Vdout0_15ck107 = 0 time = 2160
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=2160.1n

* CHECK dout0_0 Vdout0_0ck109 = 1.8 time = 2200
.meas tran vdout0_0ck109 FIND v(dout0_0) AT=2200.1n

* CHECK dout0_1 Vdout0_1ck109 = 1.8 time = 2200
.meas tran vdout0_1ck109 FIND v(dout0_1) AT=2200.1n

* CHECK dout0_2 Vdout0_2ck109 = 0 time = 2200
.meas tran vdout0_2ck109 FIND v(dout0_2) AT=2200.1n

* CHECK dout0_3 Vdout0_3ck109 = 0 time = 2200
.meas tran vdout0_3ck109 FIND v(dout0_3) AT=2200.1n

* CHECK dout0_4 Vdout0_4ck109 = 1.8 time = 2200
.meas tran vdout0_4ck109 FIND v(dout0_4) AT=2200.1n

* CHECK dout0_5 Vdout0_5ck109 = 0 time = 2200
.meas tran vdout0_5ck109 FIND v(dout0_5) AT=2200.1n

* CHECK dout0_6 Vdout0_6ck109 = 0 time = 2200
.meas tran vdout0_6ck109 FIND v(dout0_6) AT=2200.1n

* CHECK dout0_7 Vdout0_7ck109 = 0 time = 2200
.meas tran vdout0_7ck109 FIND v(dout0_7) AT=2200.1n

* CHECK dout0_8 Vdout0_8ck109 = 0 time = 2200
.meas tran vdout0_8ck109 FIND v(dout0_8) AT=2200.1n

* CHECK dout0_9 Vdout0_9ck109 = 1.8 time = 2200
.meas tran vdout0_9ck109 FIND v(dout0_9) AT=2200.1n

* CHECK dout0_10 Vdout0_10ck109 = 0 time = 2200
.meas tran vdout0_10ck109 FIND v(dout0_10) AT=2200.1n

* CHECK dout0_11 Vdout0_11ck109 = 1.8 time = 2200
.meas tran vdout0_11ck109 FIND v(dout0_11) AT=2200.1n

* CHECK dout0_12 Vdout0_12ck109 = 0 time = 2200
.meas tran vdout0_12ck109 FIND v(dout0_12) AT=2200.1n

* CHECK dout0_13 Vdout0_13ck109 = 0 time = 2200
.meas tran vdout0_13ck109 FIND v(dout0_13) AT=2200.1n

* CHECK dout0_14 Vdout0_14ck109 = 1.8 time = 2200
.meas tran vdout0_14ck109 FIND v(dout0_14) AT=2200.1n

* CHECK dout0_15 Vdout0_15ck109 = 1.8 time = 2200
.meas tran vdout0_15ck109 FIND v(dout0_15) AT=2200.1n

* CHECK dout0_0 Vdout0_0ck111 = 1.8 time = 2240
.meas tran vdout0_0ck111 FIND v(dout0_0) AT=2240.1n

* CHECK dout0_1 Vdout0_1ck111 = 0 time = 2240
.meas tran vdout0_1ck111 FIND v(dout0_1) AT=2240.1n

* CHECK dout0_2 Vdout0_2ck111 = 1.8 time = 2240
.meas tran vdout0_2ck111 FIND v(dout0_2) AT=2240.1n

* CHECK dout0_3 Vdout0_3ck111 = 0 time = 2240
.meas tran vdout0_3ck111 FIND v(dout0_3) AT=2240.1n

* CHECK dout0_4 Vdout0_4ck111 = 1.8 time = 2240
.meas tran vdout0_4ck111 FIND v(dout0_4) AT=2240.1n

* CHECK dout0_5 Vdout0_5ck111 = 0 time = 2240
.meas tran vdout0_5ck111 FIND v(dout0_5) AT=2240.1n

* CHECK dout0_6 Vdout0_6ck111 = 0 time = 2240
.meas tran vdout0_6ck111 FIND v(dout0_6) AT=2240.1n

* CHECK dout0_7 Vdout0_7ck111 = 0 time = 2240
.meas tran vdout0_7ck111 FIND v(dout0_7) AT=2240.1n

* CHECK dout0_8 Vdout0_8ck111 = 1.8 time = 2240
.meas tran vdout0_8ck111 FIND v(dout0_8) AT=2240.1n

* CHECK dout0_9 Vdout0_9ck111 = 0 time = 2240
.meas tran vdout0_9ck111 FIND v(dout0_9) AT=2240.1n

* CHECK dout0_10 Vdout0_10ck111 = 1.8 time = 2240
.meas tran vdout0_10ck111 FIND v(dout0_10) AT=2240.1n

* CHECK dout0_11 Vdout0_11ck111 = 0 time = 2240
.meas tran vdout0_11ck111 FIND v(dout0_11) AT=2240.1n

* CHECK dout0_12 Vdout0_12ck111 = 1.8 time = 2240
.meas tran vdout0_12ck111 FIND v(dout0_12) AT=2240.1n

* CHECK dout0_13 Vdout0_13ck111 = 1.8 time = 2240
.meas tran vdout0_13ck111 FIND v(dout0_13) AT=2240.1n

* CHECK dout0_14 Vdout0_14ck111 = 0 time = 2240
.meas tran vdout0_14ck111 FIND v(dout0_14) AT=2240.1n

* CHECK dout0_15 Vdout0_15ck111 = 1.8 time = 2240
.meas tran vdout0_15ck111 FIND v(dout0_15) AT=2240.1n

* CHECK dout0_0 Vdout0_0ck112 = 1.8 time = 2260
.meas tran vdout0_0ck112 FIND v(dout0_0) AT=2260.1n

* CHECK dout0_1 Vdout0_1ck112 = 0 time = 2260
.meas tran vdout0_1ck112 FIND v(dout0_1) AT=2260.1n

* CHECK dout0_2 Vdout0_2ck112 = 1.8 time = 2260
.meas tran vdout0_2ck112 FIND v(dout0_2) AT=2260.1n

* CHECK dout0_3 Vdout0_3ck112 = 0 time = 2260
.meas tran vdout0_3ck112 FIND v(dout0_3) AT=2260.1n

* CHECK dout0_4 Vdout0_4ck112 = 1.8 time = 2260
.meas tran vdout0_4ck112 FIND v(dout0_4) AT=2260.1n

* CHECK dout0_5 Vdout0_5ck112 = 0 time = 2260
.meas tran vdout0_5ck112 FIND v(dout0_5) AT=2260.1n

* CHECK dout0_6 Vdout0_6ck112 = 0 time = 2260
.meas tran vdout0_6ck112 FIND v(dout0_6) AT=2260.1n

* CHECK dout0_7 Vdout0_7ck112 = 0 time = 2260
.meas tran vdout0_7ck112 FIND v(dout0_7) AT=2260.1n

* CHECK dout0_8 Vdout0_8ck112 = 1.8 time = 2260
.meas tran vdout0_8ck112 FIND v(dout0_8) AT=2260.1n

* CHECK dout0_9 Vdout0_9ck112 = 0 time = 2260
.meas tran vdout0_9ck112 FIND v(dout0_9) AT=2260.1n

* CHECK dout0_10 Vdout0_10ck112 = 1.8 time = 2260
.meas tran vdout0_10ck112 FIND v(dout0_10) AT=2260.1n

* CHECK dout0_11 Vdout0_11ck112 = 0 time = 2260
.meas tran vdout0_11ck112 FIND v(dout0_11) AT=2260.1n

* CHECK dout0_12 Vdout0_12ck112 = 1.8 time = 2260
.meas tran vdout0_12ck112 FIND v(dout0_12) AT=2260.1n

* CHECK dout0_13 Vdout0_13ck112 = 1.8 time = 2260
.meas tran vdout0_13ck112 FIND v(dout0_13) AT=2260.1n

* CHECK dout0_14 Vdout0_14ck112 = 0 time = 2260
.meas tran vdout0_14ck112 FIND v(dout0_14) AT=2260.1n

* CHECK dout0_15 Vdout0_15ck112 = 1.8 time = 2260
.meas tran vdout0_15ck112 FIND v(dout0_15) AT=2260.1n

* CHECK dout0_0 Vdout0_0ck113 = 1.8 time = 2280
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=2280.1n

* CHECK dout0_1 Vdout0_1ck113 = 1.8 time = 2280
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=2280.1n

* CHECK dout0_2 Vdout0_2ck113 = 0 time = 2280
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=2280.1n

* CHECK dout0_3 Vdout0_3ck113 = 0 time = 2280
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=2280.1n

* CHECK dout0_4 Vdout0_4ck113 = 1.8 time = 2280
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=2280.1n

* CHECK dout0_5 Vdout0_5ck113 = 1.8 time = 2280
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=2280.1n

* CHECK dout0_6 Vdout0_6ck113 = 0 time = 2280
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=2280.1n

* CHECK dout0_7 Vdout0_7ck113 = 0 time = 2280
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=2280.1n

* CHECK dout0_8 Vdout0_8ck113 = 0 time = 2280
.meas tran vdout0_8ck113 FIND v(dout0_8) AT=2280.1n

* CHECK dout0_9 Vdout0_9ck113 = 1.8 time = 2280
.meas tran vdout0_9ck113 FIND v(dout0_9) AT=2280.1n

* CHECK dout0_10 Vdout0_10ck113 = 1.8 time = 2280
.meas tran vdout0_10ck113 FIND v(dout0_10) AT=2280.1n

* CHECK dout0_11 Vdout0_11ck113 = 1.8 time = 2280
.meas tran vdout0_11ck113 FIND v(dout0_11) AT=2280.1n

* CHECK dout0_12 Vdout0_12ck113 = 0 time = 2280
.meas tran vdout0_12ck113 FIND v(dout0_12) AT=2280.1n

* CHECK dout0_13 Vdout0_13ck113 = 1.8 time = 2280
.meas tran vdout0_13ck113 FIND v(dout0_13) AT=2280.1n

* CHECK dout0_14 Vdout0_14ck113 = 1.8 time = 2280
.meas tran vdout0_14ck113 FIND v(dout0_14) AT=2280.1n

* CHECK dout0_15 Vdout0_15ck113 = 0 time = 2280
.meas tran vdout0_15ck113 FIND v(dout0_15) AT=2280.1n

* CHECK dout0_0 Vdout0_0ck115 = 1.8 time = 2320
.meas tran vdout0_0ck115 FIND v(dout0_0) AT=2320.1n

* CHECK dout0_1 Vdout0_1ck115 = 1.8 time = 2320
.meas tran vdout0_1ck115 FIND v(dout0_1) AT=2320.1n

* CHECK dout0_2 Vdout0_2ck115 = 1.8 time = 2320
.meas tran vdout0_2ck115 FIND v(dout0_2) AT=2320.1n

* CHECK dout0_3 Vdout0_3ck115 = 1.8 time = 2320
.meas tran vdout0_3ck115 FIND v(dout0_3) AT=2320.1n

* CHECK dout0_4 Vdout0_4ck115 = 0 time = 2320
.meas tran vdout0_4ck115 FIND v(dout0_4) AT=2320.1n

* CHECK dout0_5 Vdout0_5ck115 = 0 time = 2320
.meas tran vdout0_5ck115 FIND v(dout0_5) AT=2320.1n

* CHECK dout0_6 Vdout0_6ck115 = 0 time = 2320
.meas tran vdout0_6ck115 FIND v(dout0_6) AT=2320.1n

* CHECK dout0_7 Vdout0_7ck115 = 0 time = 2320
.meas tran vdout0_7ck115 FIND v(dout0_7) AT=2320.1n

* CHECK dout0_8 Vdout0_8ck115 = 0 time = 2320
.meas tran vdout0_8ck115 FIND v(dout0_8) AT=2320.1n

* CHECK dout0_9 Vdout0_9ck115 = 1.8 time = 2320
.meas tran vdout0_9ck115 FIND v(dout0_9) AT=2320.1n

* CHECK dout0_10 Vdout0_10ck115 = 1.8 time = 2320
.meas tran vdout0_10ck115 FIND v(dout0_10) AT=2320.1n

* CHECK dout0_11 Vdout0_11ck115 = 1.8 time = 2320
.meas tran vdout0_11ck115 FIND v(dout0_11) AT=2320.1n

* CHECK dout0_12 Vdout0_12ck115 = 1.8 time = 2320
.meas tran vdout0_12ck115 FIND v(dout0_12) AT=2320.1n

* CHECK dout0_13 Vdout0_13ck115 = 1.8 time = 2320
.meas tran vdout0_13ck115 FIND v(dout0_13) AT=2320.1n

* CHECK dout0_14 Vdout0_14ck115 = 0 time = 2320
.meas tran vdout0_14ck115 FIND v(dout0_14) AT=2320.1n

* CHECK dout0_15 Vdout0_15ck115 = 0 time = 2320
.meas tran vdout0_15ck115 FIND v(dout0_15) AT=2320.1n

* CHECK dout0_0 Vdout0_0ck116 = 1.8 time = 2340
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=2340.1n

* CHECK dout0_1 Vdout0_1ck116 = 1.8 time = 2340
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=2340.1n

* CHECK dout0_2 Vdout0_2ck116 = 1.8 time = 2340
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=2340.1n

* CHECK dout0_3 Vdout0_3ck116 = 1.8 time = 2340
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=2340.1n

* CHECK dout0_4 Vdout0_4ck116 = 1.8 time = 2340
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=2340.1n

* CHECK dout0_5 Vdout0_5ck116 = 0 time = 2340
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=2340.1n

* CHECK dout0_6 Vdout0_6ck116 = 0 time = 2340
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=2340.1n

* CHECK dout0_7 Vdout0_7ck116 = 0 time = 2340
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=2340.1n

* CHECK dout0_8 Vdout0_8ck116 = 1.8 time = 2340
.meas tran vdout0_8ck116 FIND v(dout0_8) AT=2340.1n

* CHECK dout0_9 Vdout0_9ck116 = 0 time = 2340
.meas tran vdout0_9ck116 FIND v(dout0_9) AT=2340.1n

* CHECK dout0_10 Vdout0_10ck116 = 1.8 time = 2340
.meas tran vdout0_10ck116 FIND v(dout0_10) AT=2340.1n

* CHECK dout0_11 Vdout0_11ck116 = 1.8 time = 2340
.meas tran vdout0_11ck116 FIND v(dout0_11) AT=2340.1n

* CHECK dout0_12 Vdout0_12ck116 = 1.8 time = 2340
.meas tran vdout0_12ck116 FIND v(dout0_12) AT=2340.1n

* CHECK dout0_13 Vdout0_13ck116 = 1.8 time = 2340
.meas tran vdout0_13ck116 FIND v(dout0_13) AT=2340.1n

* CHECK dout0_14 Vdout0_14ck116 = 0 time = 2340
.meas tran vdout0_14ck116 FIND v(dout0_14) AT=2340.1n

* CHECK dout0_15 Vdout0_15ck116 = 1.8 time = 2340
.meas tran vdout0_15ck116 FIND v(dout0_15) AT=2340.1n

* CHECK dout0_0 Vdout0_0ck118 = 1.8 time = 2380
.meas tran vdout0_0ck118 FIND v(dout0_0) AT=2380.1n

* CHECK dout0_1 Vdout0_1ck118 = 1.8 time = 2380
.meas tran vdout0_1ck118 FIND v(dout0_1) AT=2380.1n

* CHECK dout0_2 Vdout0_2ck118 = 0 time = 2380
.meas tran vdout0_2ck118 FIND v(dout0_2) AT=2380.1n

* CHECK dout0_3 Vdout0_3ck118 = 0 time = 2380
.meas tran vdout0_3ck118 FIND v(dout0_3) AT=2380.1n

* CHECK dout0_4 Vdout0_4ck118 = 1.8 time = 2380
.meas tran vdout0_4ck118 FIND v(dout0_4) AT=2380.1n

* CHECK dout0_5 Vdout0_5ck118 = 0 time = 2380
.meas tran vdout0_5ck118 FIND v(dout0_5) AT=2380.1n

* CHECK dout0_6 Vdout0_6ck118 = 0 time = 2380
.meas tran vdout0_6ck118 FIND v(dout0_6) AT=2380.1n

* CHECK dout0_7 Vdout0_7ck118 = 0 time = 2380
.meas tran vdout0_7ck118 FIND v(dout0_7) AT=2380.1n

* CHECK dout0_8 Vdout0_8ck118 = 0 time = 2380
.meas tran vdout0_8ck118 FIND v(dout0_8) AT=2380.1n

* CHECK dout0_9 Vdout0_9ck118 = 1.8 time = 2380
.meas tran vdout0_9ck118 FIND v(dout0_9) AT=2380.1n

* CHECK dout0_10 Vdout0_10ck118 = 0 time = 2380
.meas tran vdout0_10ck118 FIND v(dout0_10) AT=2380.1n

* CHECK dout0_11 Vdout0_11ck118 = 1.8 time = 2380
.meas tran vdout0_11ck118 FIND v(dout0_11) AT=2380.1n

* CHECK dout0_12 Vdout0_12ck118 = 0 time = 2380
.meas tran vdout0_12ck118 FIND v(dout0_12) AT=2380.1n

* CHECK dout0_13 Vdout0_13ck118 = 0 time = 2380
.meas tran vdout0_13ck118 FIND v(dout0_13) AT=2380.1n

* CHECK dout0_14 Vdout0_14ck118 = 1.8 time = 2380
.meas tran vdout0_14ck118 FIND v(dout0_14) AT=2380.1n

* CHECK dout0_15 Vdout0_15ck118 = 1.8 time = 2380
.meas tran vdout0_15ck118 FIND v(dout0_15) AT=2380.1n

* CHECK dout0_0 Vdout0_0ck119 = 1.8 time = 2400
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=2400.1n

* CHECK dout0_1 Vdout0_1ck119 = 1.8 time = 2400
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=2400.1n

* CHECK dout0_2 Vdout0_2ck119 = 0 time = 2400
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=2400.1n

* CHECK dout0_3 Vdout0_3ck119 = 0 time = 2400
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=2400.1n

* CHECK dout0_4 Vdout0_4ck119 = 0 time = 2400
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=2400.1n

* CHECK dout0_5 Vdout0_5ck119 = 1.8 time = 2400
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=2400.1n

* CHECK dout0_6 Vdout0_6ck119 = 0 time = 2400
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=2400.1n

* CHECK dout0_7 Vdout0_7ck119 = 0 time = 2400
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=2400.1n

* CHECK dout0_8 Vdout0_8ck119 = 1.8 time = 2400
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=2400.1n

* CHECK dout0_9 Vdout0_9ck119 = 0 time = 2400
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=2400.1n

* CHECK dout0_10 Vdout0_10ck119 = 1.8 time = 2400
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=2400.1n

* CHECK dout0_11 Vdout0_11ck119 = 1.8 time = 2400
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=2400.1n

* CHECK dout0_12 Vdout0_12ck119 = 1.8 time = 2400
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=2400.1n

* CHECK dout0_13 Vdout0_13ck119 = 1.8 time = 2400
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=2400.1n

* CHECK dout0_14 Vdout0_14ck119 = 1.8 time = 2400
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=2400.1n

* CHECK dout0_15 Vdout0_15ck119 = 0 time = 2400
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=2400.1n

* CHECK dout0_0 Vdout0_0ck122 = 1.8 time = 2460
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=2460.1n

* CHECK dout0_1 Vdout0_1ck122 = 1.8 time = 2460
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=2460.1n

* CHECK dout0_2 Vdout0_2ck122 = 0 time = 2460
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=2460.1n

* CHECK dout0_3 Vdout0_3ck122 = 0 time = 2460
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=2460.1n

* CHECK dout0_4 Vdout0_4ck122 = 1.8 time = 2460
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=2460.1n

* CHECK dout0_5 Vdout0_5ck122 = 1.8 time = 2460
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=2460.1n

* CHECK dout0_6 Vdout0_6ck122 = 1.8 time = 2460
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=2460.1n

* CHECK dout0_7 Vdout0_7ck122 = 1.8 time = 2460
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=2460.1n

* CHECK dout0_8 Vdout0_8ck122 = 0 time = 2460
.meas tran vdout0_8ck122 FIND v(dout0_8) AT=2460.1n

* CHECK dout0_9 Vdout0_9ck122 = 0 time = 2460
.meas tran vdout0_9ck122 FIND v(dout0_9) AT=2460.1n

* CHECK dout0_10 Vdout0_10ck122 = 0 time = 2460
.meas tran vdout0_10ck122 FIND v(dout0_10) AT=2460.1n

* CHECK dout0_11 Vdout0_11ck122 = 1.8 time = 2460
.meas tran vdout0_11ck122 FIND v(dout0_11) AT=2460.1n

* CHECK dout0_12 Vdout0_12ck122 = 1.8 time = 2460
.meas tran vdout0_12ck122 FIND v(dout0_12) AT=2460.1n

* CHECK dout0_13 Vdout0_13ck122 = 1.8 time = 2460
.meas tran vdout0_13ck122 FIND v(dout0_13) AT=2460.1n

* CHECK dout0_14 Vdout0_14ck122 = 0 time = 2460
.meas tran vdout0_14ck122 FIND v(dout0_14) AT=2460.1n

* CHECK dout0_15 Vdout0_15ck122 = 0 time = 2460
.meas tran vdout0_15ck122 FIND v(dout0_15) AT=2460.1n

* CHECK dout0_0 Vdout0_0ck123 = 0 time = 2480
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=2480.1n

* CHECK dout0_1 Vdout0_1ck123 = 0 time = 2480
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=2480.1n

* CHECK dout0_2 Vdout0_2ck123 = 1.8 time = 2480
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=2480.1n

* CHECK dout0_3 Vdout0_3ck123 = 0 time = 2480
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=2480.1n

* CHECK dout0_4 Vdout0_4ck123 = 0 time = 2480
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=2480.1n

* CHECK dout0_5 Vdout0_5ck123 = 1.8 time = 2480
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=2480.1n

* CHECK dout0_6 Vdout0_6ck123 = 1.8 time = 2480
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=2480.1n

* CHECK dout0_7 Vdout0_7ck123 = 1.8 time = 2480
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=2480.1n

* CHECK dout0_8 Vdout0_8ck123 = 1.8 time = 2480
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=2480.1n

* CHECK dout0_9 Vdout0_9ck123 = 0 time = 2480
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=2480.1n

* CHECK dout0_10 Vdout0_10ck123 = 0 time = 2480
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=2480.1n

* CHECK dout0_11 Vdout0_11ck123 = 0 time = 2480
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=2480.1n

* CHECK dout0_12 Vdout0_12ck123 = 0 time = 2480
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=2480.1n

* CHECK dout0_13 Vdout0_13ck123 = 1.8 time = 2480
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=2480.1n

* CHECK dout0_14 Vdout0_14ck123 = 0 time = 2480
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=2480.1n

* CHECK dout0_15 Vdout0_15ck123 = 1.8 time = 2480
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=2480.1n

* CHECK dout0_0 Vdout0_0ck124 = 1.8 time = 2500
.meas tran vdout0_0ck124 FIND v(dout0_0) AT=2500.1n

* CHECK dout0_1 Vdout0_1ck124 = 0 time = 2500
.meas tran vdout0_1ck124 FIND v(dout0_1) AT=2500.1n

* CHECK dout0_2 Vdout0_2ck124 = 1.8 time = 2500
.meas tran vdout0_2ck124 FIND v(dout0_2) AT=2500.1n

* CHECK dout0_3 Vdout0_3ck124 = 0 time = 2500
.meas tran vdout0_3ck124 FIND v(dout0_3) AT=2500.1n

* CHECK dout0_4 Vdout0_4ck124 = 0 time = 2500
.meas tran vdout0_4ck124 FIND v(dout0_4) AT=2500.1n

* CHECK dout0_5 Vdout0_5ck124 = 1.8 time = 2500
.meas tran vdout0_5ck124 FIND v(dout0_5) AT=2500.1n

* CHECK dout0_6 Vdout0_6ck124 = 1.8 time = 2500
.meas tran vdout0_6ck124 FIND v(dout0_6) AT=2500.1n

* CHECK dout0_7 Vdout0_7ck124 = 1.8 time = 2500
.meas tran vdout0_7ck124 FIND v(dout0_7) AT=2500.1n

* CHECK dout0_8 Vdout0_8ck124 = 1.8 time = 2500
.meas tran vdout0_8ck124 FIND v(dout0_8) AT=2500.1n

* CHECK dout0_9 Vdout0_9ck124 = 1.8 time = 2500
.meas tran vdout0_9ck124 FIND v(dout0_9) AT=2500.1n

* CHECK dout0_10 Vdout0_10ck124 = 1.8 time = 2500
.meas tran vdout0_10ck124 FIND v(dout0_10) AT=2500.1n

* CHECK dout0_11 Vdout0_11ck124 = 0 time = 2500
.meas tran vdout0_11ck124 FIND v(dout0_11) AT=2500.1n

* CHECK dout0_12 Vdout0_12ck124 = 1.8 time = 2500
.meas tran vdout0_12ck124 FIND v(dout0_12) AT=2500.1n

* CHECK dout0_13 Vdout0_13ck124 = 1.8 time = 2500
.meas tran vdout0_13ck124 FIND v(dout0_13) AT=2500.1n

* CHECK dout0_14 Vdout0_14ck124 = 1.8 time = 2500
.meas tran vdout0_14ck124 FIND v(dout0_14) AT=2500.1n

* CHECK dout0_15 Vdout0_15ck124 = 0 time = 2500
.meas tran vdout0_15ck124 FIND v(dout0_15) AT=2500.1n

* CHECK dout0_0 Vdout0_0ck126 = 0 time = 2540
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=2540.1n

* CHECK dout0_1 Vdout0_1ck126 = 0 time = 2540
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=2540.1n

* CHECK dout0_2 Vdout0_2ck126 = 1.8 time = 2540
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=2540.1n

* CHECK dout0_3 Vdout0_3ck126 = 1.8 time = 2540
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=2540.1n

* CHECK dout0_4 Vdout0_4ck126 = 0 time = 2540
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=2540.1n

* CHECK dout0_5 Vdout0_5ck126 = 0 time = 2540
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=2540.1n

* CHECK dout0_6 Vdout0_6ck126 = 0 time = 2540
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=2540.1n

* CHECK dout0_7 Vdout0_7ck126 = 0 time = 2540
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=2540.1n

* CHECK dout0_8 Vdout0_8ck126 = 1.8 time = 2540
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=2540.1n

* CHECK dout0_9 Vdout0_9ck126 = 1.8 time = 2540
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=2540.1n

* CHECK dout0_10 Vdout0_10ck126 = 1.8 time = 2540
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=2540.1n

* CHECK dout0_11 Vdout0_11ck126 = 0 time = 2540
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=2540.1n

* CHECK dout0_12 Vdout0_12ck126 = 1.8 time = 2540
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=2540.1n

* CHECK dout0_13 Vdout0_13ck126 = 1.8 time = 2540
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=2540.1n

* CHECK dout0_14 Vdout0_14ck126 = 1.8 time = 2540
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=2540.1n

* CHECK dout0_15 Vdout0_15ck126 = 0 time = 2540
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=2540.1n

* CHECK dout0_0 Vdout0_0ck127 = 1.8 time = 2560
.meas tran vdout0_0ck127 FIND v(dout0_0) AT=2560.1n

* CHECK dout0_1 Vdout0_1ck127 = 1.8 time = 2560
.meas tran vdout0_1ck127 FIND v(dout0_1) AT=2560.1n

* CHECK dout0_2 Vdout0_2ck127 = 0 time = 2560
.meas tran vdout0_2ck127 FIND v(dout0_2) AT=2560.1n

* CHECK dout0_3 Vdout0_3ck127 = 0 time = 2560
.meas tran vdout0_3ck127 FIND v(dout0_3) AT=2560.1n

* CHECK dout0_4 Vdout0_4ck127 = 0 time = 2560
.meas tran vdout0_4ck127 FIND v(dout0_4) AT=2560.1n

* CHECK dout0_5 Vdout0_5ck127 = 1.8 time = 2560
.meas tran vdout0_5ck127 FIND v(dout0_5) AT=2560.1n

* CHECK dout0_6 Vdout0_6ck127 = 0 time = 2560
.meas tran vdout0_6ck127 FIND v(dout0_6) AT=2560.1n

* CHECK dout0_7 Vdout0_7ck127 = 0 time = 2560
.meas tran vdout0_7ck127 FIND v(dout0_7) AT=2560.1n

* CHECK dout0_8 Vdout0_8ck127 = 1.8 time = 2560
.meas tran vdout0_8ck127 FIND v(dout0_8) AT=2560.1n

* CHECK dout0_9 Vdout0_9ck127 = 0 time = 2560
.meas tran vdout0_9ck127 FIND v(dout0_9) AT=2560.1n

* CHECK dout0_10 Vdout0_10ck127 = 1.8 time = 2560
.meas tran vdout0_10ck127 FIND v(dout0_10) AT=2560.1n

* CHECK dout0_11 Vdout0_11ck127 = 1.8 time = 2560
.meas tran vdout0_11ck127 FIND v(dout0_11) AT=2560.1n

* CHECK dout0_12 Vdout0_12ck127 = 1.8 time = 2560
.meas tran vdout0_12ck127 FIND v(dout0_12) AT=2560.1n

* CHECK dout0_13 Vdout0_13ck127 = 1.8 time = 2560
.meas tran vdout0_13ck127 FIND v(dout0_13) AT=2560.1n

* CHECK dout0_14 Vdout0_14ck127 = 1.8 time = 2560
.meas tran vdout0_14ck127 FIND v(dout0_14) AT=2560.1n

* CHECK dout0_15 Vdout0_15ck127 = 0 time = 2560
.meas tran vdout0_15ck127 FIND v(dout0_15) AT=2560.1n

* CHECK dout0_0 Vdout0_0ck129 = 0 time = 2600
.meas tran vdout0_0ck129 FIND v(dout0_0) AT=2600.1n

* CHECK dout0_1 Vdout0_1ck129 = 0 time = 2600
.meas tran vdout0_1ck129 FIND v(dout0_1) AT=2600.1n

* CHECK dout0_2 Vdout0_2ck129 = 1.8 time = 2600
.meas tran vdout0_2ck129 FIND v(dout0_2) AT=2600.1n

* CHECK dout0_3 Vdout0_3ck129 = 1.8 time = 2600
.meas tran vdout0_3ck129 FIND v(dout0_3) AT=2600.1n

* CHECK dout0_4 Vdout0_4ck129 = 0 time = 2600
.meas tran vdout0_4ck129 FIND v(dout0_4) AT=2600.1n

* CHECK dout0_5 Vdout0_5ck129 = 0 time = 2600
.meas tran vdout0_5ck129 FIND v(dout0_5) AT=2600.1n

* CHECK dout0_6 Vdout0_6ck129 = 0 time = 2600
.meas tran vdout0_6ck129 FIND v(dout0_6) AT=2600.1n

* CHECK dout0_7 Vdout0_7ck129 = 0 time = 2600
.meas tran vdout0_7ck129 FIND v(dout0_7) AT=2600.1n

* CHECK dout0_8 Vdout0_8ck129 = 1.8 time = 2600
.meas tran vdout0_8ck129 FIND v(dout0_8) AT=2600.1n

* CHECK dout0_9 Vdout0_9ck129 = 1.8 time = 2600
.meas tran vdout0_9ck129 FIND v(dout0_9) AT=2600.1n

* CHECK dout0_10 Vdout0_10ck129 = 1.8 time = 2600
.meas tran vdout0_10ck129 FIND v(dout0_10) AT=2600.1n

* CHECK dout0_11 Vdout0_11ck129 = 0 time = 2600
.meas tran vdout0_11ck129 FIND v(dout0_11) AT=2600.1n

* CHECK dout0_12 Vdout0_12ck129 = 1.8 time = 2600
.meas tran vdout0_12ck129 FIND v(dout0_12) AT=2600.1n

* CHECK dout0_13 Vdout0_13ck129 = 1.8 time = 2600
.meas tran vdout0_13ck129 FIND v(dout0_13) AT=2600.1n

* CHECK dout0_14 Vdout0_14ck129 = 1.8 time = 2600
.meas tran vdout0_14ck129 FIND v(dout0_14) AT=2600.1n

* CHECK dout0_15 Vdout0_15ck129 = 0 time = 2600
.meas tran vdout0_15ck129 FIND v(dout0_15) AT=2600.1n

* CHECK dout0_0 Vdout0_0ck130 = 1.8 time = 2620
.meas tran vdout0_0ck130 FIND v(dout0_0) AT=2620.1n

* CHECK dout0_1 Vdout0_1ck130 = 1.8 time = 2620
.meas tran vdout0_1ck130 FIND v(dout0_1) AT=2620.1n

* CHECK dout0_2 Vdout0_2ck130 = 0 time = 2620
.meas tran vdout0_2ck130 FIND v(dout0_2) AT=2620.1n

* CHECK dout0_3 Vdout0_3ck130 = 0 time = 2620
.meas tran vdout0_3ck130 FIND v(dout0_3) AT=2620.1n

* CHECK dout0_4 Vdout0_4ck130 = 0 time = 2620
.meas tran vdout0_4ck130 FIND v(dout0_4) AT=2620.1n

* CHECK dout0_5 Vdout0_5ck130 = 1.8 time = 2620
.meas tran vdout0_5ck130 FIND v(dout0_5) AT=2620.1n

* CHECK dout0_6 Vdout0_6ck130 = 0 time = 2620
.meas tran vdout0_6ck130 FIND v(dout0_6) AT=2620.1n

* CHECK dout0_7 Vdout0_7ck130 = 0 time = 2620
.meas tran vdout0_7ck130 FIND v(dout0_7) AT=2620.1n

* CHECK dout0_8 Vdout0_8ck130 = 1.8 time = 2620
.meas tran vdout0_8ck130 FIND v(dout0_8) AT=2620.1n

* CHECK dout0_9 Vdout0_9ck130 = 0 time = 2620
.meas tran vdout0_9ck130 FIND v(dout0_9) AT=2620.1n

* CHECK dout0_10 Vdout0_10ck130 = 1.8 time = 2620
.meas tran vdout0_10ck130 FIND v(dout0_10) AT=2620.1n

* CHECK dout0_11 Vdout0_11ck130 = 1.8 time = 2620
.meas tran vdout0_11ck130 FIND v(dout0_11) AT=2620.1n

* CHECK dout0_12 Vdout0_12ck130 = 1.8 time = 2620
.meas tran vdout0_12ck130 FIND v(dout0_12) AT=2620.1n

* CHECK dout0_13 Vdout0_13ck130 = 1.8 time = 2620
.meas tran vdout0_13ck130 FIND v(dout0_13) AT=2620.1n

* CHECK dout0_14 Vdout0_14ck130 = 1.8 time = 2620
.meas tran vdout0_14ck130 FIND v(dout0_14) AT=2620.1n

* CHECK dout0_15 Vdout0_15ck130 = 0 time = 2620
.meas tran vdout0_15ck130 FIND v(dout0_15) AT=2620.1n

* CHECK dout0_0 Vdout0_0ck131 = 1.8 time = 2640
.meas tran vdout0_0ck131 FIND v(dout0_0) AT=2640.1n

* CHECK dout0_1 Vdout0_1ck131 = 1.8 time = 2640
.meas tran vdout0_1ck131 FIND v(dout0_1) AT=2640.1n

* CHECK dout0_2 Vdout0_2ck131 = 1.8 time = 2640
.meas tran vdout0_2ck131 FIND v(dout0_2) AT=2640.1n

* CHECK dout0_3 Vdout0_3ck131 = 1.8 time = 2640
.meas tran vdout0_3ck131 FIND v(dout0_3) AT=2640.1n

* CHECK dout0_4 Vdout0_4ck131 = 1.8 time = 2640
.meas tran vdout0_4ck131 FIND v(dout0_4) AT=2640.1n

* CHECK dout0_5 Vdout0_5ck131 = 0 time = 2640
.meas tran vdout0_5ck131 FIND v(dout0_5) AT=2640.1n

* CHECK dout0_6 Vdout0_6ck131 = 0 time = 2640
.meas tran vdout0_6ck131 FIND v(dout0_6) AT=2640.1n

* CHECK dout0_7 Vdout0_7ck131 = 0 time = 2640
.meas tran vdout0_7ck131 FIND v(dout0_7) AT=2640.1n

* CHECK dout0_8 Vdout0_8ck131 = 1.8 time = 2640
.meas tran vdout0_8ck131 FIND v(dout0_8) AT=2640.1n

* CHECK dout0_9 Vdout0_9ck131 = 0 time = 2640
.meas tran vdout0_9ck131 FIND v(dout0_9) AT=2640.1n

* CHECK dout0_10 Vdout0_10ck131 = 1.8 time = 2640
.meas tran vdout0_10ck131 FIND v(dout0_10) AT=2640.1n

* CHECK dout0_11 Vdout0_11ck131 = 1.8 time = 2640
.meas tran vdout0_11ck131 FIND v(dout0_11) AT=2640.1n

* CHECK dout0_12 Vdout0_12ck131 = 1.8 time = 2640
.meas tran vdout0_12ck131 FIND v(dout0_12) AT=2640.1n

* CHECK dout0_13 Vdout0_13ck131 = 1.8 time = 2640
.meas tran vdout0_13ck131 FIND v(dout0_13) AT=2640.1n

* CHECK dout0_14 Vdout0_14ck131 = 0 time = 2640
.meas tran vdout0_14ck131 FIND v(dout0_14) AT=2640.1n

* CHECK dout0_15 Vdout0_15ck131 = 1.8 time = 2640
.meas tran vdout0_15ck131 FIND v(dout0_15) AT=2640.1n

* CHECK dout0_0 Vdout0_0ck133 = 0 time = 2680
.meas tran vdout0_0ck133 FIND v(dout0_0) AT=2680.1n

* CHECK dout0_1 Vdout0_1ck133 = 0 time = 2680
.meas tran vdout0_1ck133 FIND v(dout0_1) AT=2680.1n

* CHECK dout0_2 Vdout0_2ck133 = 1.8 time = 2680
.meas tran vdout0_2ck133 FIND v(dout0_2) AT=2680.1n

* CHECK dout0_3 Vdout0_3ck133 = 0 time = 2680
.meas tran vdout0_3ck133 FIND v(dout0_3) AT=2680.1n

* CHECK dout0_4 Vdout0_4ck133 = 0 time = 2680
.meas tran vdout0_4ck133 FIND v(dout0_4) AT=2680.1n

* CHECK dout0_5 Vdout0_5ck133 = 1.8 time = 2680
.meas tran vdout0_5ck133 FIND v(dout0_5) AT=2680.1n

* CHECK dout0_6 Vdout0_6ck133 = 1.8 time = 2680
.meas tran vdout0_6ck133 FIND v(dout0_6) AT=2680.1n

* CHECK dout0_7 Vdout0_7ck133 = 1.8 time = 2680
.meas tran vdout0_7ck133 FIND v(dout0_7) AT=2680.1n

* CHECK dout0_8 Vdout0_8ck133 = 1.8 time = 2680
.meas tran vdout0_8ck133 FIND v(dout0_8) AT=2680.1n

* CHECK dout0_9 Vdout0_9ck133 = 0 time = 2680
.meas tran vdout0_9ck133 FIND v(dout0_9) AT=2680.1n

* CHECK dout0_10 Vdout0_10ck133 = 0 time = 2680
.meas tran vdout0_10ck133 FIND v(dout0_10) AT=2680.1n

* CHECK dout0_11 Vdout0_11ck133 = 0 time = 2680
.meas tran vdout0_11ck133 FIND v(dout0_11) AT=2680.1n

* CHECK dout0_12 Vdout0_12ck133 = 0 time = 2680
.meas tran vdout0_12ck133 FIND v(dout0_12) AT=2680.1n

* CHECK dout0_13 Vdout0_13ck133 = 1.8 time = 2680
.meas tran vdout0_13ck133 FIND v(dout0_13) AT=2680.1n

* CHECK dout0_14 Vdout0_14ck133 = 0 time = 2680
.meas tran vdout0_14ck133 FIND v(dout0_14) AT=2680.1n

* CHECK dout0_15 Vdout0_15ck133 = 1.8 time = 2680
.meas tran vdout0_15ck133 FIND v(dout0_15) AT=2680.1n

* CHECK dout0_0 Vdout0_0ck138 = 1.8 time = 2780
.meas tran vdout0_0ck138 FIND v(dout0_0) AT=2780.1n

* CHECK dout0_1 Vdout0_1ck138 = 1.8 time = 2780
.meas tran vdout0_1ck138 FIND v(dout0_1) AT=2780.1n

* CHECK dout0_2 Vdout0_2ck138 = 0 time = 2780
.meas tran vdout0_2ck138 FIND v(dout0_2) AT=2780.1n

* CHECK dout0_3 Vdout0_3ck138 = 0 time = 2780
.meas tran vdout0_3ck138 FIND v(dout0_3) AT=2780.1n

* CHECK dout0_4 Vdout0_4ck138 = 0 time = 2780
.meas tran vdout0_4ck138 FIND v(dout0_4) AT=2780.1n

* CHECK dout0_5 Vdout0_5ck138 = 1.8 time = 2780
.meas tran vdout0_5ck138 FIND v(dout0_5) AT=2780.1n

* CHECK dout0_6 Vdout0_6ck138 = 0 time = 2780
.meas tran vdout0_6ck138 FIND v(dout0_6) AT=2780.1n

* CHECK dout0_7 Vdout0_7ck138 = 0 time = 2780
.meas tran vdout0_7ck138 FIND v(dout0_7) AT=2780.1n

* CHECK dout0_8 Vdout0_8ck138 = 1.8 time = 2780
.meas tran vdout0_8ck138 FIND v(dout0_8) AT=2780.1n

* CHECK dout0_9 Vdout0_9ck138 = 0 time = 2780
.meas tran vdout0_9ck138 FIND v(dout0_9) AT=2780.1n

* CHECK dout0_10 Vdout0_10ck138 = 1.8 time = 2780
.meas tran vdout0_10ck138 FIND v(dout0_10) AT=2780.1n

* CHECK dout0_11 Vdout0_11ck138 = 1.8 time = 2780
.meas tran vdout0_11ck138 FIND v(dout0_11) AT=2780.1n

* CHECK dout0_12 Vdout0_12ck138 = 1.8 time = 2780
.meas tran vdout0_12ck138 FIND v(dout0_12) AT=2780.1n

* CHECK dout0_13 Vdout0_13ck138 = 1.8 time = 2780
.meas tran vdout0_13ck138 FIND v(dout0_13) AT=2780.1n

* CHECK dout0_14 Vdout0_14ck138 = 1.8 time = 2780
.meas tran vdout0_14ck138 FIND v(dout0_14) AT=2780.1n

* CHECK dout0_15 Vdout0_15ck138 = 0 time = 2780
.meas tran vdout0_15ck138 FIND v(dout0_15) AT=2780.1n

* CHECK dout0_0 Vdout0_0ck141 = 1.8 time = 2840
.meas tran vdout0_0ck141 FIND v(dout0_0) AT=2840.1n

* CHECK dout0_1 Vdout0_1ck141 = 0 time = 2840
.meas tran vdout0_1ck141 FIND v(dout0_1) AT=2840.1n

* CHECK dout0_2 Vdout0_2ck141 = 1.8 time = 2840
.meas tran vdout0_2ck141 FIND v(dout0_2) AT=2840.1n

* CHECK dout0_3 Vdout0_3ck141 = 0 time = 2840
.meas tran vdout0_3ck141 FIND v(dout0_3) AT=2840.1n

* CHECK dout0_4 Vdout0_4ck141 = 1.8 time = 2840
.meas tran vdout0_4ck141 FIND v(dout0_4) AT=2840.1n

* CHECK dout0_5 Vdout0_5ck141 = 0 time = 2840
.meas tran vdout0_5ck141 FIND v(dout0_5) AT=2840.1n

* CHECK dout0_6 Vdout0_6ck141 = 0 time = 2840
.meas tran vdout0_6ck141 FIND v(dout0_6) AT=2840.1n

* CHECK dout0_7 Vdout0_7ck141 = 0 time = 2840
.meas tran vdout0_7ck141 FIND v(dout0_7) AT=2840.1n

* CHECK dout0_8 Vdout0_8ck141 = 1.8 time = 2840
.meas tran vdout0_8ck141 FIND v(dout0_8) AT=2840.1n

* CHECK dout0_9 Vdout0_9ck141 = 0 time = 2840
.meas tran vdout0_9ck141 FIND v(dout0_9) AT=2840.1n

* CHECK dout0_10 Vdout0_10ck141 = 1.8 time = 2840
.meas tran vdout0_10ck141 FIND v(dout0_10) AT=2840.1n

* CHECK dout0_11 Vdout0_11ck141 = 0 time = 2840
.meas tran vdout0_11ck141 FIND v(dout0_11) AT=2840.1n

* CHECK dout0_12 Vdout0_12ck141 = 1.8 time = 2840
.meas tran vdout0_12ck141 FIND v(dout0_12) AT=2840.1n

* CHECK dout0_13 Vdout0_13ck141 = 1.8 time = 2840
.meas tran vdout0_13ck141 FIND v(dout0_13) AT=2840.1n

* CHECK dout0_14 Vdout0_14ck141 = 0 time = 2840
.meas tran vdout0_14ck141 FIND v(dout0_14) AT=2840.1n

* CHECK dout0_15 Vdout0_15ck141 = 1.8 time = 2840
.meas tran vdout0_15ck141 FIND v(dout0_15) AT=2840.1n

* CHECK dout0_0 Vdout0_0ck143 = 0 time = 2880
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=2880.1n

* CHECK dout0_1 Vdout0_1ck143 = 1.8 time = 2880
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=2880.1n

* CHECK dout0_2 Vdout0_2ck143 = 1.8 time = 2880
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=2880.1n

* CHECK dout0_3 Vdout0_3ck143 = 0 time = 2880
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=2880.1n

* CHECK dout0_4 Vdout0_4ck143 = 1.8 time = 2880
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=2880.1n

* CHECK dout0_5 Vdout0_5ck143 = 0 time = 2880
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=2880.1n

* CHECK dout0_6 Vdout0_6ck143 = 0 time = 2880
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=2880.1n

* CHECK dout0_7 Vdout0_7ck143 = 1.8 time = 2880
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=2880.1n

* CHECK dout0_8 Vdout0_8ck143 = 1.8 time = 2880
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=2880.1n

* CHECK dout0_9 Vdout0_9ck143 = 1.8 time = 2880
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=2880.1n

* CHECK dout0_10 Vdout0_10ck143 = 1.8 time = 2880
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=2880.1n

* CHECK dout0_11 Vdout0_11ck143 = 0 time = 2880
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=2880.1n

* CHECK dout0_12 Vdout0_12ck143 = 0 time = 2880
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=2880.1n

* CHECK dout0_13 Vdout0_13ck143 = 0 time = 2880
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=2880.1n

* CHECK dout0_14 Vdout0_14ck143 = 1.8 time = 2880
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=2880.1n

* CHECK dout0_15 Vdout0_15ck143 = 0 time = 2880
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=2880.1n

* CHECK dout0_0 Vdout0_0ck145 = 0 time = 2920
.meas tran vdout0_0ck145 FIND v(dout0_0) AT=2920.1n

* CHECK dout0_1 Vdout0_1ck145 = 1.8 time = 2920
.meas tran vdout0_1ck145 FIND v(dout0_1) AT=2920.1n

* CHECK dout0_2 Vdout0_2ck145 = 1.8 time = 2920
.meas tran vdout0_2ck145 FIND v(dout0_2) AT=2920.1n

* CHECK dout0_3 Vdout0_3ck145 = 0 time = 2920
.meas tran vdout0_3ck145 FIND v(dout0_3) AT=2920.1n

* CHECK dout0_4 Vdout0_4ck145 = 1.8 time = 2920
.meas tran vdout0_4ck145 FIND v(dout0_4) AT=2920.1n

* CHECK dout0_5 Vdout0_5ck145 = 0 time = 2920
.meas tran vdout0_5ck145 FIND v(dout0_5) AT=2920.1n

* CHECK dout0_6 Vdout0_6ck145 = 0 time = 2920
.meas tran vdout0_6ck145 FIND v(dout0_6) AT=2920.1n

* CHECK dout0_7 Vdout0_7ck145 = 1.8 time = 2920
.meas tran vdout0_7ck145 FIND v(dout0_7) AT=2920.1n

* CHECK dout0_8 Vdout0_8ck145 = 1.8 time = 2920
.meas tran vdout0_8ck145 FIND v(dout0_8) AT=2920.1n

* CHECK dout0_9 Vdout0_9ck145 = 1.8 time = 2920
.meas tran vdout0_9ck145 FIND v(dout0_9) AT=2920.1n

* CHECK dout0_10 Vdout0_10ck145 = 1.8 time = 2920
.meas tran vdout0_10ck145 FIND v(dout0_10) AT=2920.1n

* CHECK dout0_11 Vdout0_11ck145 = 0 time = 2920
.meas tran vdout0_11ck145 FIND v(dout0_11) AT=2920.1n

* CHECK dout0_12 Vdout0_12ck145 = 0 time = 2920
.meas tran vdout0_12ck145 FIND v(dout0_12) AT=2920.1n

* CHECK dout0_13 Vdout0_13ck145 = 0 time = 2920
.meas tran vdout0_13ck145 FIND v(dout0_13) AT=2920.1n

* CHECK dout0_14 Vdout0_14ck145 = 1.8 time = 2920
.meas tran vdout0_14ck145 FIND v(dout0_14) AT=2920.1n

* CHECK dout0_15 Vdout0_15ck145 = 0 time = 2920
.meas tran vdout0_15ck145 FIND v(dout0_15) AT=2920.1n

* CHECK dout0_0 Vdout0_0ck146 = 0 time = 2940
.meas tran vdout0_0ck146 FIND v(dout0_0) AT=2940.1n

* CHECK dout0_1 Vdout0_1ck146 = 0 time = 2940
.meas tran vdout0_1ck146 FIND v(dout0_1) AT=2940.1n

* CHECK dout0_2 Vdout0_2ck146 = 1.8 time = 2940
.meas tran vdout0_2ck146 FIND v(dout0_2) AT=2940.1n

* CHECK dout0_3 Vdout0_3ck146 = 0 time = 2940
.meas tran vdout0_3ck146 FIND v(dout0_3) AT=2940.1n

* CHECK dout0_4 Vdout0_4ck146 = 0 time = 2940
.meas tran vdout0_4ck146 FIND v(dout0_4) AT=2940.1n

* CHECK dout0_5 Vdout0_5ck146 = 1.8 time = 2940
.meas tran vdout0_5ck146 FIND v(dout0_5) AT=2940.1n

* CHECK dout0_6 Vdout0_6ck146 = 1.8 time = 2940
.meas tran vdout0_6ck146 FIND v(dout0_6) AT=2940.1n

* CHECK dout0_7 Vdout0_7ck146 = 1.8 time = 2940
.meas tran vdout0_7ck146 FIND v(dout0_7) AT=2940.1n

* CHECK dout0_8 Vdout0_8ck146 = 1.8 time = 2940
.meas tran vdout0_8ck146 FIND v(dout0_8) AT=2940.1n

* CHECK dout0_9 Vdout0_9ck146 = 0 time = 2940
.meas tran vdout0_9ck146 FIND v(dout0_9) AT=2940.1n

* CHECK dout0_10 Vdout0_10ck146 = 0 time = 2940
.meas tran vdout0_10ck146 FIND v(dout0_10) AT=2940.1n

* CHECK dout0_11 Vdout0_11ck146 = 0 time = 2940
.meas tran vdout0_11ck146 FIND v(dout0_11) AT=2940.1n

* CHECK dout0_12 Vdout0_12ck146 = 0 time = 2940
.meas tran vdout0_12ck146 FIND v(dout0_12) AT=2940.1n

* CHECK dout0_13 Vdout0_13ck146 = 1.8 time = 2940
.meas tran vdout0_13ck146 FIND v(dout0_13) AT=2940.1n

* CHECK dout0_14 Vdout0_14ck146 = 0 time = 2940
.meas tran vdout0_14ck146 FIND v(dout0_14) AT=2940.1n

* CHECK dout0_15 Vdout0_15ck146 = 1.8 time = 2940
.meas tran vdout0_15ck146 FIND v(dout0_15) AT=2940.1n

* CHECK dout0_0 Vdout0_0ck148 = 0 time = 2980
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=2980.1n

* CHECK dout0_1 Vdout0_1ck148 = 1.8 time = 2980
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=2980.1n

* CHECK dout0_2 Vdout0_2ck148 = 1.8 time = 2980
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=2980.1n

* CHECK dout0_3 Vdout0_3ck148 = 0 time = 2980
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=2980.1n

* CHECK dout0_4 Vdout0_4ck148 = 1.8 time = 2980
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=2980.1n

* CHECK dout0_5 Vdout0_5ck148 = 0 time = 2980
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=2980.1n

* CHECK dout0_6 Vdout0_6ck148 = 0 time = 2980
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=2980.1n

* CHECK dout0_7 Vdout0_7ck148 = 1.8 time = 2980
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=2980.1n

* CHECK dout0_8 Vdout0_8ck148 = 1.8 time = 2980
.meas tran vdout0_8ck148 FIND v(dout0_8) AT=2980.1n

* CHECK dout0_9 Vdout0_9ck148 = 1.8 time = 2980
.meas tran vdout0_9ck148 FIND v(dout0_9) AT=2980.1n

* CHECK dout0_10 Vdout0_10ck148 = 1.8 time = 2980
.meas tran vdout0_10ck148 FIND v(dout0_10) AT=2980.1n

* CHECK dout0_11 Vdout0_11ck148 = 0 time = 2980
.meas tran vdout0_11ck148 FIND v(dout0_11) AT=2980.1n

* CHECK dout0_12 Vdout0_12ck148 = 0 time = 2980
.meas tran vdout0_12ck148 FIND v(dout0_12) AT=2980.1n

* CHECK dout0_13 Vdout0_13ck148 = 0 time = 2980
.meas tran vdout0_13ck148 FIND v(dout0_13) AT=2980.1n

* CHECK dout0_14 Vdout0_14ck148 = 1.8 time = 2980
.meas tran vdout0_14ck148 FIND v(dout0_14) AT=2980.1n

* CHECK dout0_15 Vdout0_15ck148 = 0 time = 2980
.meas tran vdout0_15ck148 FIND v(dout0_15) AT=2980.1n

* CHECK dout0_0 Vdout0_0ck149 = 0 time = 3000
.meas tran vdout0_0ck149 FIND v(dout0_0) AT=3000.1n

* CHECK dout0_1 Vdout0_1ck149 = 0 time = 3000
.meas tran vdout0_1ck149 FIND v(dout0_1) AT=3000.1n

* CHECK dout0_2 Vdout0_2ck149 = 0 time = 3000
.meas tran vdout0_2ck149 FIND v(dout0_2) AT=3000.1n

* CHECK dout0_3 Vdout0_3ck149 = 1.8 time = 3000
.meas tran vdout0_3ck149 FIND v(dout0_3) AT=3000.1n

* CHECK dout0_4 Vdout0_4ck149 = 1.8 time = 3000
.meas tran vdout0_4ck149 FIND v(dout0_4) AT=3000.1n

* CHECK dout0_5 Vdout0_5ck149 = 1.8 time = 3000
.meas tran vdout0_5ck149 FIND v(dout0_5) AT=3000.1n

* CHECK dout0_6 Vdout0_6ck149 = 1.8 time = 3000
.meas tran vdout0_6ck149 FIND v(dout0_6) AT=3000.1n

* CHECK dout0_7 Vdout0_7ck149 = 1.8 time = 3000
.meas tran vdout0_7ck149 FIND v(dout0_7) AT=3000.1n

* CHECK dout0_8 Vdout0_8ck149 = 1.8 time = 3000
.meas tran vdout0_8ck149 FIND v(dout0_8) AT=3000.1n

* CHECK dout0_9 Vdout0_9ck149 = 0 time = 3000
.meas tran vdout0_9ck149 FIND v(dout0_9) AT=3000.1n

* CHECK dout0_10 Vdout0_10ck149 = 1.8 time = 3000
.meas tran vdout0_10ck149 FIND v(dout0_10) AT=3000.1n

* CHECK dout0_11 Vdout0_11ck149 = 0 time = 3000
.meas tran vdout0_11ck149 FIND v(dout0_11) AT=3000.1n

* CHECK dout0_12 Vdout0_12ck149 = 1.8 time = 3000
.meas tran vdout0_12ck149 FIND v(dout0_12) AT=3000.1n

* CHECK dout0_13 Vdout0_13ck149 = 1.8 time = 3000
.meas tran vdout0_13ck149 FIND v(dout0_13) AT=3000.1n

* CHECK dout0_14 Vdout0_14ck149 = 1.8 time = 3000
.meas tran vdout0_14ck149 FIND v(dout0_14) AT=3000.1n

* CHECK dout0_15 Vdout0_15ck149 = 1.8 time = 3000
.meas tran vdout0_15ck149 FIND v(dout0_15) AT=3000.1n

* CHECK dout0_0 Vdout0_0ck151 = 1.8 time = 3040
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=3040.1n

* CHECK dout0_1 Vdout0_1ck151 = 0 time = 3040
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=3040.1n

* CHECK dout0_2 Vdout0_2ck151 = 1.8 time = 3040
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=3040.1n

* CHECK dout0_3 Vdout0_3ck151 = 1.8 time = 3040
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=3040.1n

* CHECK dout0_4 Vdout0_4ck151 = 0 time = 3040
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=3040.1n

* CHECK dout0_5 Vdout0_5ck151 = 0 time = 3040
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=3040.1n

* CHECK dout0_6 Vdout0_6ck151 = 0 time = 3040
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=3040.1n

* CHECK dout0_7 Vdout0_7ck151 = 1.8 time = 3040
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=3040.1n

* CHECK dout0_8 Vdout0_8ck151 = 1.8 time = 3040
.meas tran vdout0_8ck151 FIND v(dout0_8) AT=3040.1n

* CHECK dout0_9 Vdout0_9ck151 = 0 time = 3040
.meas tran vdout0_9ck151 FIND v(dout0_9) AT=3040.1n

* CHECK dout0_10 Vdout0_10ck151 = 1.8 time = 3040
.meas tran vdout0_10ck151 FIND v(dout0_10) AT=3040.1n

* CHECK dout0_11 Vdout0_11ck151 = 1.8 time = 3040
.meas tran vdout0_11ck151 FIND v(dout0_11) AT=3040.1n

* CHECK dout0_12 Vdout0_12ck151 = 0 time = 3040
.meas tran vdout0_12ck151 FIND v(dout0_12) AT=3040.1n

* CHECK dout0_13 Vdout0_13ck151 = 1.8 time = 3040
.meas tran vdout0_13ck151 FIND v(dout0_13) AT=3040.1n

* CHECK dout0_14 Vdout0_14ck151 = 1.8 time = 3040
.meas tran vdout0_14ck151 FIND v(dout0_14) AT=3040.1n

* CHECK dout0_15 Vdout0_15ck151 = 1.8 time = 3040
.meas tran vdout0_15ck151 FIND v(dout0_15) AT=3040.1n

* CHECK dout0_0 Vdout0_0ck153 = 0 time = 3080
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=3080.1n

* CHECK dout0_1 Vdout0_1ck153 = 1.8 time = 3080
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=3080.1n

* CHECK dout0_2 Vdout0_2ck153 = 1.8 time = 3080
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=3080.1n

* CHECK dout0_3 Vdout0_3ck153 = 0 time = 3080
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=3080.1n

* CHECK dout0_4 Vdout0_4ck153 = 1.8 time = 3080
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=3080.1n

* CHECK dout0_5 Vdout0_5ck153 = 0 time = 3080
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=3080.1n

* CHECK dout0_6 Vdout0_6ck153 = 0 time = 3080
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=3080.1n

* CHECK dout0_7 Vdout0_7ck153 = 1.8 time = 3080
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=3080.1n

* CHECK dout0_8 Vdout0_8ck153 = 1.8 time = 3080
.meas tran vdout0_8ck153 FIND v(dout0_8) AT=3080.1n

* CHECK dout0_9 Vdout0_9ck153 = 1.8 time = 3080
.meas tran vdout0_9ck153 FIND v(dout0_9) AT=3080.1n

* CHECK dout0_10 Vdout0_10ck153 = 1.8 time = 3080
.meas tran vdout0_10ck153 FIND v(dout0_10) AT=3080.1n

* CHECK dout0_11 Vdout0_11ck153 = 0 time = 3080
.meas tran vdout0_11ck153 FIND v(dout0_11) AT=3080.1n

* CHECK dout0_12 Vdout0_12ck153 = 0 time = 3080
.meas tran vdout0_12ck153 FIND v(dout0_12) AT=3080.1n

* CHECK dout0_13 Vdout0_13ck153 = 0 time = 3080
.meas tran vdout0_13ck153 FIND v(dout0_13) AT=3080.1n

* CHECK dout0_14 Vdout0_14ck153 = 1.8 time = 3080
.meas tran vdout0_14ck153 FIND v(dout0_14) AT=3080.1n

* CHECK dout0_15 Vdout0_15ck153 = 0 time = 3080
.meas tran vdout0_15ck153 FIND v(dout0_15) AT=3080.1n

* CHECK dout0_0 Vdout0_0ck157 = 1.8 time = 3160
.meas tran vdout0_0ck157 FIND v(dout0_0) AT=3160.1n

* CHECK dout0_1 Vdout0_1ck157 = 0 time = 3160
.meas tran vdout0_1ck157 FIND v(dout0_1) AT=3160.1n

* CHECK dout0_2 Vdout0_2ck157 = 1.8 time = 3160
.meas tran vdout0_2ck157 FIND v(dout0_2) AT=3160.1n

* CHECK dout0_3 Vdout0_3ck157 = 1.8 time = 3160
.meas tran vdout0_3ck157 FIND v(dout0_3) AT=3160.1n

* CHECK dout0_4 Vdout0_4ck157 = 0 time = 3160
.meas tran vdout0_4ck157 FIND v(dout0_4) AT=3160.1n

* CHECK dout0_5 Vdout0_5ck157 = 0 time = 3160
.meas tran vdout0_5ck157 FIND v(dout0_5) AT=3160.1n

* CHECK dout0_6 Vdout0_6ck157 = 0 time = 3160
.meas tran vdout0_6ck157 FIND v(dout0_6) AT=3160.1n

* CHECK dout0_7 Vdout0_7ck157 = 1.8 time = 3160
.meas tran vdout0_7ck157 FIND v(dout0_7) AT=3160.1n

* CHECK dout0_8 Vdout0_8ck157 = 1.8 time = 3160
.meas tran vdout0_8ck157 FIND v(dout0_8) AT=3160.1n

* CHECK dout0_9 Vdout0_9ck157 = 0 time = 3160
.meas tran vdout0_9ck157 FIND v(dout0_9) AT=3160.1n

* CHECK dout0_10 Vdout0_10ck157 = 1.8 time = 3160
.meas tran vdout0_10ck157 FIND v(dout0_10) AT=3160.1n

* CHECK dout0_11 Vdout0_11ck157 = 1.8 time = 3160
.meas tran vdout0_11ck157 FIND v(dout0_11) AT=3160.1n

* CHECK dout0_12 Vdout0_12ck157 = 0 time = 3160
.meas tran vdout0_12ck157 FIND v(dout0_12) AT=3160.1n

* CHECK dout0_13 Vdout0_13ck157 = 1.8 time = 3160
.meas tran vdout0_13ck157 FIND v(dout0_13) AT=3160.1n

* CHECK dout0_14 Vdout0_14ck157 = 1.8 time = 3160
.meas tran vdout0_14ck157 FIND v(dout0_14) AT=3160.1n

* CHECK dout0_15 Vdout0_15ck157 = 1.8 time = 3160
.meas tran vdout0_15ck157 FIND v(dout0_15) AT=3160.1n

* CHECK dout0_0 Vdout0_0ck158 = 1.8 time = 3180
.meas tran vdout0_0ck158 FIND v(dout0_0) AT=3180.1n

* CHECK dout0_1 Vdout0_1ck158 = 1.8 time = 3180
.meas tran vdout0_1ck158 FIND v(dout0_1) AT=3180.1n

* CHECK dout0_2 Vdout0_2ck158 = 1.8 time = 3180
.meas tran vdout0_2ck158 FIND v(dout0_2) AT=3180.1n

* CHECK dout0_3 Vdout0_3ck158 = 0 time = 3180
.meas tran vdout0_3ck158 FIND v(dout0_3) AT=3180.1n

* CHECK dout0_4 Vdout0_4ck158 = 0 time = 3180
.meas tran vdout0_4ck158 FIND v(dout0_4) AT=3180.1n

* CHECK dout0_5 Vdout0_5ck158 = 1.8 time = 3180
.meas tran vdout0_5ck158 FIND v(dout0_5) AT=3180.1n

* CHECK dout0_6 Vdout0_6ck158 = 1.8 time = 3180
.meas tran vdout0_6ck158 FIND v(dout0_6) AT=3180.1n

* CHECK dout0_7 Vdout0_7ck158 = 0 time = 3180
.meas tran vdout0_7ck158 FIND v(dout0_7) AT=3180.1n

* CHECK dout0_8 Vdout0_8ck158 = 0 time = 3180
.meas tran vdout0_8ck158 FIND v(dout0_8) AT=3180.1n

* CHECK dout0_9 Vdout0_9ck158 = 1.8 time = 3180
.meas tran vdout0_9ck158 FIND v(dout0_9) AT=3180.1n

* CHECK dout0_10 Vdout0_10ck158 = 0 time = 3180
.meas tran vdout0_10ck158 FIND v(dout0_10) AT=3180.1n

* CHECK dout0_11 Vdout0_11ck158 = 0 time = 3180
.meas tran vdout0_11ck158 FIND v(dout0_11) AT=3180.1n

* CHECK dout0_12 Vdout0_12ck158 = 1.8 time = 3180
.meas tran vdout0_12ck158 FIND v(dout0_12) AT=3180.1n

* CHECK dout0_13 Vdout0_13ck158 = 1.8 time = 3180
.meas tran vdout0_13ck158 FIND v(dout0_13) AT=3180.1n

* CHECK dout0_14 Vdout0_14ck158 = 1.8 time = 3180
.meas tran vdout0_14ck158 FIND v(dout0_14) AT=3180.1n

* CHECK dout0_15 Vdout0_15ck158 = 1.8 time = 3180
.meas tran vdout0_15ck158 FIND v(dout0_15) AT=3180.1n

* CHECK dout0_0 Vdout0_0ck159 = 1.8 time = 3200
.meas tran vdout0_0ck159 FIND v(dout0_0) AT=3200.1n

* CHECK dout0_1 Vdout0_1ck159 = 0 time = 3200
.meas tran vdout0_1ck159 FIND v(dout0_1) AT=3200.1n

* CHECK dout0_2 Vdout0_2ck159 = 1.8 time = 3200
.meas tran vdout0_2ck159 FIND v(dout0_2) AT=3200.1n

* CHECK dout0_3 Vdout0_3ck159 = 1.8 time = 3200
.meas tran vdout0_3ck159 FIND v(dout0_3) AT=3200.1n

* CHECK dout0_4 Vdout0_4ck159 = 0 time = 3200
.meas tran vdout0_4ck159 FIND v(dout0_4) AT=3200.1n

* CHECK dout0_5 Vdout0_5ck159 = 0 time = 3200
.meas tran vdout0_5ck159 FIND v(dout0_5) AT=3200.1n

* CHECK dout0_6 Vdout0_6ck159 = 0 time = 3200
.meas tran vdout0_6ck159 FIND v(dout0_6) AT=3200.1n

* CHECK dout0_7 Vdout0_7ck159 = 1.8 time = 3200
.meas tran vdout0_7ck159 FIND v(dout0_7) AT=3200.1n

* CHECK dout0_8 Vdout0_8ck159 = 1.8 time = 3200
.meas tran vdout0_8ck159 FIND v(dout0_8) AT=3200.1n

* CHECK dout0_9 Vdout0_9ck159 = 0 time = 3200
.meas tran vdout0_9ck159 FIND v(dout0_9) AT=3200.1n

* CHECK dout0_10 Vdout0_10ck159 = 1.8 time = 3200
.meas tran vdout0_10ck159 FIND v(dout0_10) AT=3200.1n

* CHECK dout0_11 Vdout0_11ck159 = 1.8 time = 3200
.meas tran vdout0_11ck159 FIND v(dout0_11) AT=3200.1n

* CHECK dout0_12 Vdout0_12ck159 = 0 time = 3200
.meas tran vdout0_12ck159 FIND v(dout0_12) AT=3200.1n

* CHECK dout0_13 Vdout0_13ck159 = 1.8 time = 3200
.meas tran vdout0_13ck159 FIND v(dout0_13) AT=3200.1n

* CHECK dout0_14 Vdout0_14ck159 = 1.8 time = 3200
.meas tran vdout0_14ck159 FIND v(dout0_14) AT=3200.1n

* CHECK dout0_15 Vdout0_15ck159 = 1.8 time = 3200
.meas tran vdout0_15ck159 FIND v(dout0_15) AT=3200.1n

* CHECK dout0_0 Vdout0_0ck161 = 1.8 time = 3240
.meas tran vdout0_0ck161 FIND v(dout0_0) AT=3240.1n

* CHECK dout0_1 Vdout0_1ck161 = 1.8 time = 3240
.meas tran vdout0_1ck161 FIND v(dout0_1) AT=3240.1n

* CHECK dout0_2 Vdout0_2ck161 = 1.8 time = 3240
.meas tran vdout0_2ck161 FIND v(dout0_2) AT=3240.1n

* CHECK dout0_3 Vdout0_3ck161 = 0 time = 3240
.meas tran vdout0_3ck161 FIND v(dout0_3) AT=3240.1n

* CHECK dout0_4 Vdout0_4ck161 = 0 time = 3240
.meas tran vdout0_4ck161 FIND v(dout0_4) AT=3240.1n

* CHECK dout0_5 Vdout0_5ck161 = 1.8 time = 3240
.meas tran vdout0_5ck161 FIND v(dout0_5) AT=3240.1n

* CHECK dout0_6 Vdout0_6ck161 = 1.8 time = 3240
.meas tran vdout0_6ck161 FIND v(dout0_6) AT=3240.1n

* CHECK dout0_7 Vdout0_7ck161 = 0 time = 3240
.meas tran vdout0_7ck161 FIND v(dout0_7) AT=3240.1n

* CHECK dout0_8 Vdout0_8ck161 = 0 time = 3240
.meas tran vdout0_8ck161 FIND v(dout0_8) AT=3240.1n

* CHECK dout0_9 Vdout0_9ck161 = 1.8 time = 3240
.meas tran vdout0_9ck161 FIND v(dout0_9) AT=3240.1n

* CHECK dout0_10 Vdout0_10ck161 = 0 time = 3240
.meas tran vdout0_10ck161 FIND v(dout0_10) AT=3240.1n

* CHECK dout0_11 Vdout0_11ck161 = 0 time = 3240
.meas tran vdout0_11ck161 FIND v(dout0_11) AT=3240.1n

* CHECK dout0_12 Vdout0_12ck161 = 1.8 time = 3240
.meas tran vdout0_12ck161 FIND v(dout0_12) AT=3240.1n

* CHECK dout0_13 Vdout0_13ck161 = 1.8 time = 3240
.meas tran vdout0_13ck161 FIND v(dout0_13) AT=3240.1n

* CHECK dout0_14 Vdout0_14ck161 = 1.8 time = 3240
.meas tran vdout0_14ck161 FIND v(dout0_14) AT=3240.1n

* CHECK dout0_15 Vdout0_15ck161 = 1.8 time = 3240
.meas tran vdout0_15ck161 FIND v(dout0_15) AT=3240.1n

* CHECK dout0_0 Vdout0_0ck163 = 0 time = 3280
.meas tran vdout0_0ck163 FIND v(dout0_0) AT=3280.1n

* CHECK dout0_1 Vdout0_1ck163 = 1.8 time = 3280
.meas tran vdout0_1ck163 FIND v(dout0_1) AT=3280.1n

* CHECK dout0_2 Vdout0_2ck163 = 1.8 time = 3280
.meas tran vdout0_2ck163 FIND v(dout0_2) AT=3280.1n

* CHECK dout0_3 Vdout0_3ck163 = 1.8 time = 3280
.meas tran vdout0_3ck163 FIND v(dout0_3) AT=3280.1n

* CHECK dout0_4 Vdout0_4ck163 = 1.8 time = 3280
.meas tran vdout0_4ck163 FIND v(dout0_4) AT=3280.1n

* CHECK dout0_5 Vdout0_5ck163 = 0 time = 3280
.meas tran vdout0_5ck163 FIND v(dout0_5) AT=3280.1n

* CHECK dout0_6 Vdout0_6ck163 = 0 time = 3280
.meas tran vdout0_6ck163 FIND v(dout0_6) AT=3280.1n

* CHECK dout0_7 Vdout0_7ck163 = 1.8 time = 3280
.meas tran vdout0_7ck163 FIND v(dout0_7) AT=3280.1n

* CHECK dout0_8 Vdout0_8ck163 = 0 time = 3280
.meas tran vdout0_8ck163 FIND v(dout0_8) AT=3280.1n

* CHECK dout0_9 Vdout0_9ck163 = 1.8 time = 3280
.meas tran vdout0_9ck163 FIND v(dout0_9) AT=3280.1n

* CHECK dout0_10 Vdout0_10ck163 = 0 time = 3280
.meas tran vdout0_10ck163 FIND v(dout0_10) AT=3280.1n

* CHECK dout0_11 Vdout0_11ck163 = 0 time = 3280
.meas tran vdout0_11ck163 FIND v(dout0_11) AT=3280.1n

* CHECK dout0_12 Vdout0_12ck163 = 0 time = 3280
.meas tran vdout0_12ck163 FIND v(dout0_12) AT=3280.1n

* CHECK dout0_13 Vdout0_13ck163 = 0 time = 3280
.meas tran vdout0_13ck163 FIND v(dout0_13) AT=3280.1n

* CHECK dout0_14 Vdout0_14ck163 = 0 time = 3280
.meas tran vdout0_14ck163 FIND v(dout0_14) AT=3280.1n

* CHECK dout0_15 Vdout0_15ck163 = 0 time = 3280
.meas tran vdout0_15ck163 FIND v(dout0_15) AT=3280.1n

* CHECK dout0_0 Vdout0_0ck165 = 1.8 time = 3320
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=3320.1n

* CHECK dout0_1 Vdout0_1ck165 = 0 time = 3320
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=3320.1n

* CHECK dout0_2 Vdout0_2ck165 = 1.8 time = 3320
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=3320.1n

* CHECK dout0_3 Vdout0_3ck165 = 1.8 time = 3320
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=3320.1n

* CHECK dout0_4 Vdout0_4ck165 = 1.8 time = 3320
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=3320.1n

* CHECK dout0_5 Vdout0_5ck165 = 0 time = 3320
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=3320.1n

* CHECK dout0_6 Vdout0_6ck165 = 0 time = 3320
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=3320.1n

* CHECK dout0_7 Vdout0_7ck165 = 1.8 time = 3320
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=3320.1n

* CHECK dout0_8 Vdout0_8ck165 = 1.8 time = 3320
.meas tran vdout0_8ck165 FIND v(dout0_8) AT=3320.1n

* CHECK dout0_9 Vdout0_9ck165 = 1.8 time = 3320
.meas tran vdout0_9ck165 FIND v(dout0_9) AT=3320.1n

* CHECK dout0_10 Vdout0_10ck165 = 0 time = 3320
.meas tran vdout0_10ck165 FIND v(dout0_10) AT=3320.1n

* CHECK dout0_11 Vdout0_11ck165 = 0 time = 3320
.meas tran vdout0_11ck165 FIND v(dout0_11) AT=3320.1n

* CHECK dout0_12 Vdout0_12ck165 = 1.8 time = 3320
.meas tran vdout0_12ck165 FIND v(dout0_12) AT=3320.1n

* CHECK dout0_13 Vdout0_13ck165 = 0 time = 3320
.meas tran vdout0_13ck165 FIND v(dout0_13) AT=3320.1n

* CHECK dout0_14 Vdout0_14ck165 = 0 time = 3320
.meas tran vdout0_14ck165 FIND v(dout0_14) AT=3320.1n

* CHECK dout0_15 Vdout0_15ck165 = 0 time = 3320
.meas tran vdout0_15ck165 FIND v(dout0_15) AT=3320.1n

* CHECK dout0_0 Vdout0_0ck167 = 0 time = 3360
.meas tran vdout0_0ck167 FIND v(dout0_0) AT=3360.1n

* CHECK dout0_1 Vdout0_1ck167 = 1.8 time = 3360
.meas tran vdout0_1ck167 FIND v(dout0_1) AT=3360.1n

* CHECK dout0_2 Vdout0_2ck167 = 1.8 time = 3360
.meas tran vdout0_2ck167 FIND v(dout0_2) AT=3360.1n

* CHECK dout0_3 Vdout0_3ck167 = 0 time = 3360
.meas tran vdout0_3ck167 FIND v(dout0_3) AT=3360.1n

* CHECK dout0_4 Vdout0_4ck167 = 1.8 time = 3360
.meas tran vdout0_4ck167 FIND v(dout0_4) AT=3360.1n

* CHECK dout0_5 Vdout0_5ck167 = 0 time = 3360
.meas tran vdout0_5ck167 FIND v(dout0_5) AT=3360.1n

* CHECK dout0_6 Vdout0_6ck167 = 0 time = 3360
.meas tran vdout0_6ck167 FIND v(dout0_6) AT=3360.1n

* CHECK dout0_7 Vdout0_7ck167 = 1.8 time = 3360
.meas tran vdout0_7ck167 FIND v(dout0_7) AT=3360.1n

* CHECK dout0_8 Vdout0_8ck167 = 1.8 time = 3360
.meas tran vdout0_8ck167 FIND v(dout0_8) AT=3360.1n

* CHECK dout0_9 Vdout0_9ck167 = 1.8 time = 3360
.meas tran vdout0_9ck167 FIND v(dout0_9) AT=3360.1n

* CHECK dout0_10 Vdout0_10ck167 = 1.8 time = 3360
.meas tran vdout0_10ck167 FIND v(dout0_10) AT=3360.1n

* CHECK dout0_11 Vdout0_11ck167 = 0 time = 3360
.meas tran vdout0_11ck167 FIND v(dout0_11) AT=3360.1n

* CHECK dout0_12 Vdout0_12ck167 = 0 time = 3360
.meas tran vdout0_12ck167 FIND v(dout0_12) AT=3360.1n

* CHECK dout0_13 Vdout0_13ck167 = 0 time = 3360
.meas tran vdout0_13ck167 FIND v(dout0_13) AT=3360.1n

* CHECK dout0_14 Vdout0_14ck167 = 1.8 time = 3360
.meas tran vdout0_14ck167 FIND v(dout0_14) AT=3360.1n

* CHECK dout0_15 Vdout0_15ck167 = 0 time = 3360
.meas tran vdout0_15ck167 FIND v(dout0_15) AT=3360.1n

* CHECK dout0_0 Vdout0_0ck168 = 0 time = 3380
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=3380.1n

* CHECK dout0_1 Vdout0_1ck168 = 1.8 time = 3380
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=3380.1n

* CHECK dout0_2 Vdout0_2ck168 = 0 time = 3380
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=3380.1n

* CHECK dout0_3 Vdout0_3ck168 = 1.8 time = 3380
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=3380.1n

* CHECK dout0_4 Vdout0_4ck168 = 0 time = 3380
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=3380.1n

* CHECK dout0_5 Vdout0_5ck168 = 1.8 time = 3380
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=3380.1n

* CHECK dout0_6 Vdout0_6ck168 = 1.8 time = 3380
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=3380.1n

* CHECK dout0_7 Vdout0_7ck168 = 0 time = 3380
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=3380.1n

* CHECK dout0_8 Vdout0_8ck168 = 1.8 time = 3380
.meas tran vdout0_8ck168 FIND v(dout0_8) AT=3380.1n

* CHECK dout0_9 Vdout0_9ck168 = 1.8 time = 3380
.meas tran vdout0_9ck168 FIND v(dout0_9) AT=3380.1n

* CHECK dout0_10 Vdout0_10ck168 = 1.8 time = 3380
.meas tran vdout0_10ck168 FIND v(dout0_10) AT=3380.1n

* CHECK dout0_11 Vdout0_11ck168 = 1.8 time = 3380
.meas tran vdout0_11ck168 FIND v(dout0_11) AT=3380.1n

* CHECK dout0_12 Vdout0_12ck168 = 0 time = 3380
.meas tran vdout0_12ck168 FIND v(dout0_12) AT=3380.1n

* CHECK dout0_13 Vdout0_13ck168 = 1.8 time = 3380
.meas tran vdout0_13ck168 FIND v(dout0_13) AT=3380.1n

* CHECK dout0_14 Vdout0_14ck168 = 0 time = 3380
.meas tran vdout0_14ck168 FIND v(dout0_14) AT=3380.1n

* CHECK dout0_15 Vdout0_15ck168 = 1.8 time = 3380
.meas tran vdout0_15ck168 FIND v(dout0_15) AT=3380.1n

* CHECK dout0_0 Vdout0_0ck170 = 1.8 time = 3420
.meas tran vdout0_0ck170 FIND v(dout0_0) AT=3420.1n

* CHECK dout0_1 Vdout0_1ck170 = 1.8 time = 3420
.meas tran vdout0_1ck170 FIND v(dout0_1) AT=3420.1n

* CHECK dout0_2 Vdout0_2ck170 = 1.8 time = 3420
.meas tran vdout0_2ck170 FIND v(dout0_2) AT=3420.1n

* CHECK dout0_3 Vdout0_3ck170 = 0 time = 3420
.meas tran vdout0_3ck170 FIND v(dout0_3) AT=3420.1n

* CHECK dout0_4 Vdout0_4ck170 = 0 time = 3420
.meas tran vdout0_4ck170 FIND v(dout0_4) AT=3420.1n

* CHECK dout0_5 Vdout0_5ck170 = 1.8 time = 3420
.meas tran vdout0_5ck170 FIND v(dout0_5) AT=3420.1n

* CHECK dout0_6 Vdout0_6ck170 = 1.8 time = 3420
.meas tran vdout0_6ck170 FIND v(dout0_6) AT=3420.1n

* CHECK dout0_7 Vdout0_7ck170 = 0 time = 3420
.meas tran vdout0_7ck170 FIND v(dout0_7) AT=3420.1n

* CHECK dout0_8 Vdout0_8ck170 = 0 time = 3420
.meas tran vdout0_8ck170 FIND v(dout0_8) AT=3420.1n

* CHECK dout0_9 Vdout0_9ck170 = 1.8 time = 3420
.meas tran vdout0_9ck170 FIND v(dout0_9) AT=3420.1n

* CHECK dout0_10 Vdout0_10ck170 = 0 time = 3420
.meas tran vdout0_10ck170 FIND v(dout0_10) AT=3420.1n

* CHECK dout0_11 Vdout0_11ck170 = 0 time = 3420
.meas tran vdout0_11ck170 FIND v(dout0_11) AT=3420.1n

* CHECK dout0_12 Vdout0_12ck170 = 0 time = 3420
.meas tran vdout0_12ck170 FIND v(dout0_12) AT=3420.1n

* CHECK dout0_13 Vdout0_13ck170 = 1.8 time = 3420
.meas tran vdout0_13ck170 FIND v(dout0_13) AT=3420.1n

* CHECK dout0_14 Vdout0_14ck170 = 0 time = 3420
.meas tran vdout0_14ck170 FIND v(dout0_14) AT=3420.1n

* CHECK dout0_15 Vdout0_15ck170 = 1.8 time = 3420
.meas tran vdout0_15ck170 FIND v(dout0_15) AT=3420.1n

* CHECK dout0_0 Vdout0_0ck171 = 0 time = 3440
.meas tran vdout0_0ck171 FIND v(dout0_0) AT=3440.1n

* CHECK dout0_1 Vdout0_1ck171 = 0 time = 3440
.meas tran vdout0_1ck171 FIND v(dout0_1) AT=3440.1n

* CHECK dout0_2 Vdout0_2ck171 = 0 time = 3440
.meas tran vdout0_2ck171 FIND v(dout0_2) AT=3440.1n

* CHECK dout0_3 Vdout0_3ck171 = 1.8 time = 3440
.meas tran vdout0_3ck171 FIND v(dout0_3) AT=3440.1n

* CHECK dout0_4 Vdout0_4ck171 = 1.8 time = 3440
.meas tran vdout0_4ck171 FIND v(dout0_4) AT=3440.1n

* CHECK dout0_5 Vdout0_5ck171 = 0 time = 3440
.meas tran vdout0_5ck171 FIND v(dout0_5) AT=3440.1n

* CHECK dout0_6 Vdout0_6ck171 = 1.8 time = 3440
.meas tran vdout0_6ck171 FIND v(dout0_6) AT=3440.1n

* CHECK dout0_7 Vdout0_7ck171 = 1.8 time = 3440
.meas tran vdout0_7ck171 FIND v(dout0_7) AT=3440.1n

* CHECK dout0_8 Vdout0_8ck171 = 0 time = 3440
.meas tran vdout0_8ck171 FIND v(dout0_8) AT=3440.1n

* CHECK dout0_9 Vdout0_9ck171 = 1.8 time = 3440
.meas tran vdout0_9ck171 FIND v(dout0_9) AT=3440.1n

* CHECK dout0_10 Vdout0_10ck171 = 0 time = 3440
.meas tran vdout0_10ck171 FIND v(dout0_10) AT=3440.1n

* CHECK dout0_11 Vdout0_11ck171 = 0 time = 3440
.meas tran vdout0_11ck171 FIND v(dout0_11) AT=3440.1n

* CHECK dout0_12 Vdout0_12ck171 = 1.8 time = 3440
.meas tran vdout0_12ck171 FIND v(dout0_12) AT=3440.1n

* CHECK dout0_13 Vdout0_13ck171 = 0 time = 3440
.meas tran vdout0_13ck171 FIND v(dout0_13) AT=3440.1n

* CHECK dout0_14 Vdout0_14ck171 = 0 time = 3440
.meas tran vdout0_14ck171 FIND v(dout0_14) AT=3440.1n

* CHECK dout0_15 Vdout0_15ck171 = 1.8 time = 3440
.meas tran vdout0_15ck171 FIND v(dout0_15) AT=3440.1n

* CHECK dout0_0 Vdout0_0ck175 = 0 time = 3520
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=3520.1n

* CHECK dout0_1 Vdout0_1ck175 = 1.8 time = 3520
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=3520.1n

* CHECK dout0_2 Vdout0_2ck175 = 1.8 time = 3520
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=3520.1n

* CHECK dout0_3 Vdout0_3ck175 = 1.8 time = 3520
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=3520.1n

* CHECK dout0_4 Vdout0_4ck175 = 1.8 time = 3520
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=3520.1n

* CHECK dout0_5 Vdout0_5ck175 = 1.8 time = 3520
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=3520.1n

* CHECK dout0_6 Vdout0_6ck175 = 0 time = 3520
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=3520.1n

* CHECK dout0_7 Vdout0_7ck175 = 1.8 time = 3520
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=3520.1n

* CHECK dout0_8 Vdout0_8ck175 = 1.8 time = 3520
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=3520.1n

* CHECK dout0_9 Vdout0_9ck175 = 1.8 time = 3520
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=3520.1n

* CHECK dout0_10 Vdout0_10ck175 = 1.8 time = 3520
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=3520.1n

* CHECK dout0_11 Vdout0_11ck175 = 1.8 time = 3520
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=3520.1n

* CHECK dout0_12 Vdout0_12ck175 = 1.8 time = 3520
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=3520.1n

* CHECK dout0_13 Vdout0_13ck175 = 1.8 time = 3520
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=3520.1n

* CHECK dout0_14 Vdout0_14ck175 = 1.8 time = 3520
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=3520.1n

* CHECK dout0_15 Vdout0_15ck175 = 0 time = 3520
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=3520.1n

* CHECK dout0_0 Vdout0_0ck176 = 1.8 time = 3540
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=3540.1n

* CHECK dout0_1 Vdout0_1ck176 = 0 time = 3540
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=3540.1n

* CHECK dout0_2 Vdout0_2ck176 = 1.8 time = 3540
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=3540.1n

* CHECK dout0_3 Vdout0_3ck176 = 1.8 time = 3540
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=3540.1n

* CHECK dout0_4 Vdout0_4ck176 = 0 time = 3540
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=3540.1n

* CHECK dout0_5 Vdout0_5ck176 = 0 time = 3540
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=3540.1n

* CHECK dout0_6 Vdout0_6ck176 = 0 time = 3540
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=3540.1n

* CHECK dout0_7 Vdout0_7ck176 = 1.8 time = 3540
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=3540.1n

* CHECK dout0_8 Vdout0_8ck176 = 1.8 time = 3540
.meas tran vdout0_8ck176 FIND v(dout0_8) AT=3540.1n

* CHECK dout0_9 Vdout0_9ck176 = 0 time = 3540
.meas tran vdout0_9ck176 FIND v(dout0_9) AT=3540.1n

* CHECK dout0_10 Vdout0_10ck176 = 1.8 time = 3540
.meas tran vdout0_10ck176 FIND v(dout0_10) AT=3540.1n

* CHECK dout0_11 Vdout0_11ck176 = 1.8 time = 3540
.meas tran vdout0_11ck176 FIND v(dout0_11) AT=3540.1n

* CHECK dout0_12 Vdout0_12ck176 = 0 time = 3540
.meas tran vdout0_12ck176 FIND v(dout0_12) AT=3540.1n

* CHECK dout0_13 Vdout0_13ck176 = 1.8 time = 3540
.meas tran vdout0_13ck176 FIND v(dout0_13) AT=3540.1n

* CHECK dout0_14 Vdout0_14ck176 = 1.8 time = 3540
.meas tran vdout0_14ck176 FIND v(dout0_14) AT=3540.1n

* CHECK dout0_15 Vdout0_15ck176 = 1.8 time = 3540
.meas tran vdout0_15ck176 FIND v(dout0_15) AT=3540.1n

* CHECK dout0_0 Vdout0_0ck178 = 1.8 time = 3580
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=3580.1n

* CHECK dout0_1 Vdout0_1ck178 = 1.8 time = 3580
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=3580.1n

* CHECK dout0_2 Vdout0_2ck178 = 1.8 time = 3580
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=3580.1n

* CHECK dout0_3 Vdout0_3ck178 = 0 time = 3580
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=3580.1n

* CHECK dout0_4 Vdout0_4ck178 = 0 time = 3580
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=3580.1n

* CHECK dout0_5 Vdout0_5ck178 = 0 time = 3580
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=3580.1n

* CHECK dout0_6 Vdout0_6ck178 = 0 time = 3580
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=3580.1n

* CHECK dout0_7 Vdout0_7ck178 = 1.8 time = 3580
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=3580.1n

* CHECK dout0_8 Vdout0_8ck178 = 0 time = 3580
.meas tran vdout0_8ck178 FIND v(dout0_8) AT=3580.1n

* CHECK dout0_9 Vdout0_9ck178 = 1.8 time = 3580
.meas tran vdout0_9ck178 FIND v(dout0_9) AT=3580.1n

* CHECK dout0_10 Vdout0_10ck178 = 0 time = 3580
.meas tran vdout0_10ck178 FIND v(dout0_10) AT=3580.1n

* CHECK dout0_11 Vdout0_11ck178 = 0 time = 3580
.meas tran vdout0_11ck178 FIND v(dout0_11) AT=3580.1n

* CHECK dout0_12 Vdout0_12ck178 = 0 time = 3580
.meas tran vdout0_12ck178 FIND v(dout0_12) AT=3580.1n

* CHECK dout0_13 Vdout0_13ck178 = 0 time = 3580
.meas tran vdout0_13ck178 FIND v(dout0_13) AT=3580.1n

* CHECK dout0_14 Vdout0_14ck178 = 1.8 time = 3580
.meas tran vdout0_14ck178 FIND v(dout0_14) AT=3580.1n

* CHECK dout0_15 Vdout0_15ck178 = 1.8 time = 3580
.meas tran vdout0_15ck178 FIND v(dout0_15) AT=3580.1n

* CHECK dout0_0 Vdout0_0ck180 = 1.8 time = 3620
.meas tran vdout0_0ck180 FIND v(dout0_0) AT=3620.1n

* CHECK dout0_1 Vdout0_1ck180 = 0 time = 3620
.meas tran vdout0_1ck180 FIND v(dout0_1) AT=3620.1n

* CHECK dout0_2 Vdout0_2ck180 = 0 time = 3620
.meas tran vdout0_2ck180 FIND v(dout0_2) AT=3620.1n

* CHECK dout0_3 Vdout0_3ck180 = 1.8 time = 3620
.meas tran vdout0_3ck180 FIND v(dout0_3) AT=3620.1n

* CHECK dout0_4 Vdout0_4ck180 = 0 time = 3620
.meas tran vdout0_4ck180 FIND v(dout0_4) AT=3620.1n

* CHECK dout0_5 Vdout0_5ck180 = 0 time = 3620
.meas tran vdout0_5ck180 FIND v(dout0_5) AT=3620.1n

* CHECK dout0_6 Vdout0_6ck180 = 1.8 time = 3620
.meas tran vdout0_6ck180 FIND v(dout0_6) AT=3620.1n

* CHECK dout0_7 Vdout0_7ck180 = 1.8 time = 3620
.meas tran vdout0_7ck180 FIND v(dout0_7) AT=3620.1n

* CHECK dout0_8 Vdout0_8ck180 = 1.8 time = 3620
.meas tran vdout0_8ck180 FIND v(dout0_8) AT=3620.1n

* CHECK dout0_9 Vdout0_9ck180 = 1.8 time = 3620
.meas tran vdout0_9ck180 FIND v(dout0_9) AT=3620.1n

* CHECK dout0_10 Vdout0_10ck180 = 0 time = 3620
.meas tran vdout0_10ck180 FIND v(dout0_10) AT=3620.1n

* CHECK dout0_11 Vdout0_11ck180 = 1.8 time = 3620
.meas tran vdout0_11ck180 FIND v(dout0_11) AT=3620.1n

* CHECK dout0_12 Vdout0_12ck180 = 1.8 time = 3620
.meas tran vdout0_12ck180 FIND v(dout0_12) AT=3620.1n

* CHECK dout0_13 Vdout0_13ck180 = 0 time = 3620
.meas tran vdout0_13ck180 FIND v(dout0_13) AT=3620.1n

* CHECK dout0_14 Vdout0_14ck180 = 0 time = 3620
.meas tran vdout0_14ck180 FIND v(dout0_14) AT=3620.1n

* CHECK dout0_15 Vdout0_15ck180 = 1.8 time = 3620
.meas tran vdout0_15ck180 FIND v(dout0_15) AT=3620.1n

* CHECK dout0_0 Vdout0_0ck181 = 1.8 time = 3640
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=3640.1n

* CHECK dout0_1 Vdout0_1ck181 = 1.8 time = 3640
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=3640.1n

* CHECK dout0_2 Vdout0_2ck181 = 1.8 time = 3640
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=3640.1n

* CHECK dout0_3 Vdout0_3ck181 = 0 time = 3640
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=3640.1n

* CHECK dout0_4 Vdout0_4ck181 = 0 time = 3640
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=3640.1n

* CHECK dout0_5 Vdout0_5ck181 = 1.8 time = 3640
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=3640.1n

* CHECK dout0_6 Vdout0_6ck181 = 1.8 time = 3640
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=3640.1n

* CHECK dout0_7 Vdout0_7ck181 = 0 time = 3640
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=3640.1n

* CHECK dout0_8 Vdout0_8ck181 = 0 time = 3640
.meas tran vdout0_8ck181 FIND v(dout0_8) AT=3640.1n

* CHECK dout0_9 Vdout0_9ck181 = 1.8 time = 3640
.meas tran vdout0_9ck181 FIND v(dout0_9) AT=3640.1n

* CHECK dout0_10 Vdout0_10ck181 = 0 time = 3640
.meas tran vdout0_10ck181 FIND v(dout0_10) AT=3640.1n

* CHECK dout0_11 Vdout0_11ck181 = 0 time = 3640
.meas tran vdout0_11ck181 FIND v(dout0_11) AT=3640.1n

* CHECK dout0_12 Vdout0_12ck181 = 1.8 time = 3640
.meas tran vdout0_12ck181 FIND v(dout0_12) AT=3640.1n

* CHECK dout0_13 Vdout0_13ck181 = 1.8 time = 3640
.meas tran vdout0_13ck181 FIND v(dout0_13) AT=3640.1n

* CHECK dout0_14 Vdout0_14ck181 = 1.8 time = 3640
.meas tran vdout0_14ck181 FIND v(dout0_14) AT=3640.1n

* CHECK dout0_15 Vdout0_15ck181 = 1.8 time = 3640
.meas tran vdout0_15ck181 FIND v(dout0_15) AT=3640.1n

* CHECK dout0_0 Vdout0_0ck183 = 0 time = 3680
.meas tran vdout0_0ck183 FIND v(dout0_0) AT=3680.1n

* CHECK dout0_1 Vdout0_1ck183 = 1.8 time = 3680
.meas tran vdout0_1ck183 FIND v(dout0_1) AT=3680.1n

* CHECK dout0_2 Vdout0_2ck183 = 1.8 time = 3680
.meas tran vdout0_2ck183 FIND v(dout0_2) AT=3680.1n

* CHECK dout0_3 Vdout0_3ck183 = 1.8 time = 3680
.meas tran vdout0_3ck183 FIND v(dout0_3) AT=3680.1n

* CHECK dout0_4 Vdout0_4ck183 = 1.8 time = 3680
.meas tran vdout0_4ck183 FIND v(dout0_4) AT=3680.1n

* CHECK dout0_5 Vdout0_5ck183 = 0 time = 3680
.meas tran vdout0_5ck183 FIND v(dout0_5) AT=3680.1n

* CHECK dout0_6 Vdout0_6ck183 = 0 time = 3680
.meas tran vdout0_6ck183 FIND v(dout0_6) AT=3680.1n

* CHECK dout0_7 Vdout0_7ck183 = 1.8 time = 3680
.meas tran vdout0_7ck183 FIND v(dout0_7) AT=3680.1n

* CHECK dout0_8 Vdout0_8ck183 = 0 time = 3680
.meas tran vdout0_8ck183 FIND v(dout0_8) AT=3680.1n

* CHECK dout0_9 Vdout0_9ck183 = 1.8 time = 3680
.meas tran vdout0_9ck183 FIND v(dout0_9) AT=3680.1n

* CHECK dout0_10 Vdout0_10ck183 = 0 time = 3680
.meas tran vdout0_10ck183 FIND v(dout0_10) AT=3680.1n

* CHECK dout0_11 Vdout0_11ck183 = 0 time = 3680
.meas tran vdout0_11ck183 FIND v(dout0_11) AT=3680.1n

* CHECK dout0_12 Vdout0_12ck183 = 0 time = 3680
.meas tran vdout0_12ck183 FIND v(dout0_12) AT=3680.1n

* CHECK dout0_13 Vdout0_13ck183 = 0 time = 3680
.meas tran vdout0_13ck183 FIND v(dout0_13) AT=3680.1n

* CHECK dout0_14 Vdout0_14ck183 = 0 time = 3680
.meas tran vdout0_14ck183 FIND v(dout0_14) AT=3680.1n

* CHECK dout0_15 Vdout0_15ck183 = 0 time = 3680
.meas tran vdout0_15ck183 FIND v(dout0_15) AT=3680.1n

* CHECK dout0_0 Vdout0_0ck186 = 1.8 time = 3740
.meas tran vdout0_0ck186 FIND v(dout0_0) AT=3740.1n

* CHECK dout0_1 Vdout0_1ck186 = 0 time = 3740
.meas tran vdout0_1ck186 FIND v(dout0_1) AT=3740.1n

* CHECK dout0_2 Vdout0_2ck186 = 0 time = 3740
.meas tran vdout0_2ck186 FIND v(dout0_2) AT=3740.1n

* CHECK dout0_3 Vdout0_3ck186 = 1.8 time = 3740
.meas tran vdout0_3ck186 FIND v(dout0_3) AT=3740.1n

* CHECK dout0_4 Vdout0_4ck186 = 0 time = 3740
.meas tran vdout0_4ck186 FIND v(dout0_4) AT=3740.1n

* CHECK dout0_5 Vdout0_5ck186 = 1.8 time = 3740
.meas tran vdout0_5ck186 FIND v(dout0_5) AT=3740.1n

* CHECK dout0_6 Vdout0_6ck186 = 0 time = 3740
.meas tran vdout0_6ck186 FIND v(dout0_6) AT=3740.1n

* CHECK dout0_7 Vdout0_7ck186 = 0 time = 3740
.meas tran vdout0_7ck186 FIND v(dout0_7) AT=3740.1n

* CHECK dout0_8 Vdout0_8ck186 = 1.8 time = 3740
.meas tran vdout0_8ck186 FIND v(dout0_8) AT=3740.1n

* CHECK dout0_9 Vdout0_9ck186 = 1.8 time = 3740
.meas tran vdout0_9ck186 FIND v(dout0_9) AT=3740.1n

* CHECK dout0_10 Vdout0_10ck186 = 1.8 time = 3740
.meas tran vdout0_10ck186 FIND v(dout0_10) AT=3740.1n

* CHECK dout0_11 Vdout0_11ck186 = 1.8 time = 3740
.meas tran vdout0_11ck186 FIND v(dout0_11) AT=3740.1n

* CHECK dout0_12 Vdout0_12ck186 = 0 time = 3740
.meas tran vdout0_12ck186 FIND v(dout0_12) AT=3740.1n

* CHECK dout0_13 Vdout0_13ck186 = 1.8 time = 3740
.meas tran vdout0_13ck186 FIND v(dout0_13) AT=3740.1n

* CHECK dout0_14 Vdout0_14ck186 = 0 time = 3740
.meas tran vdout0_14ck186 FIND v(dout0_14) AT=3740.1n

* CHECK dout0_15 Vdout0_15ck186 = 1.8 time = 3740
.meas tran vdout0_15ck186 FIND v(dout0_15) AT=3740.1n

* CHECK dout0_0 Vdout0_0ck187 = 1.8 time = 3760
.meas tran vdout0_0ck187 FIND v(dout0_0) AT=3760.1n

* CHECK dout0_1 Vdout0_1ck187 = 1.8 time = 3760
.meas tran vdout0_1ck187 FIND v(dout0_1) AT=3760.1n

* CHECK dout0_2 Vdout0_2ck187 = 1.8 time = 3760
.meas tran vdout0_2ck187 FIND v(dout0_2) AT=3760.1n

* CHECK dout0_3 Vdout0_3ck187 = 1.8 time = 3760
.meas tran vdout0_3ck187 FIND v(dout0_3) AT=3760.1n

* CHECK dout0_4 Vdout0_4ck187 = 0 time = 3760
.meas tran vdout0_4ck187 FIND v(dout0_4) AT=3760.1n

* CHECK dout0_5 Vdout0_5ck187 = 0 time = 3760
.meas tran vdout0_5ck187 FIND v(dout0_5) AT=3760.1n

* CHECK dout0_6 Vdout0_6ck187 = 0 time = 3760
.meas tran vdout0_6ck187 FIND v(dout0_6) AT=3760.1n

* CHECK dout0_7 Vdout0_7ck187 = 1.8 time = 3760
.meas tran vdout0_7ck187 FIND v(dout0_7) AT=3760.1n

* CHECK dout0_8 Vdout0_8ck187 = 1.8 time = 3760
.meas tran vdout0_8ck187 FIND v(dout0_8) AT=3760.1n

* CHECK dout0_9 Vdout0_9ck187 = 0 time = 3760
.meas tran vdout0_9ck187 FIND v(dout0_9) AT=3760.1n

* CHECK dout0_10 Vdout0_10ck187 = 0 time = 3760
.meas tran vdout0_10ck187 FIND v(dout0_10) AT=3760.1n

* CHECK dout0_11 Vdout0_11ck187 = 0 time = 3760
.meas tran vdout0_11ck187 FIND v(dout0_11) AT=3760.1n

* CHECK dout0_12 Vdout0_12ck187 = 1.8 time = 3760
.meas tran vdout0_12ck187 FIND v(dout0_12) AT=3760.1n

* CHECK dout0_13 Vdout0_13ck187 = 1.8 time = 3760
.meas tran vdout0_13ck187 FIND v(dout0_13) AT=3760.1n

* CHECK dout0_14 Vdout0_14ck187 = 0 time = 3760
.meas tran vdout0_14ck187 FIND v(dout0_14) AT=3760.1n

* CHECK dout0_15 Vdout0_15ck187 = 0 time = 3760
.meas tran vdout0_15ck187 FIND v(dout0_15) AT=3760.1n

* CHECK dout0_0 Vdout0_0ck192 = 0 time = 3860
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=3860.1n

* CHECK dout0_1 Vdout0_1ck192 = 1.8 time = 3860
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=3860.1n

* CHECK dout0_2 Vdout0_2ck192 = 1.8 time = 3860
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=3860.1n

* CHECK dout0_3 Vdout0_3ck192 = 1.8 time = 3860
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=3860.1n

* CHECK dout0_4 Vdout0_4ck192 = 1.8 time = 3860
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=3860.1n

* CHECK dout0_5 Vdout0_5ck192 = 0 time = 3860
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=3860.1n

* CHECK dout0_6 Vdout0_6ck192 = 0 time = 3860
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=3860.1n

* CHECK dout0_7 Vdout0_7ck192 = 1.8 time = 3860
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=3860.1n

* CHECK dout0_8 Vdout0_8ck192 = 0 time = 3860
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=3860.1n

* CHECK dout0_9 Vdout0_9ck192 = 1.8 time = 3860
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=3860.1n

* CHECK dout0_10 Vdout0_10ck192 = 0 time = 3860
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=3860.1n

* CHECK dout0_11 Vdout0_11ck192 = 0 time = 3860
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=3860.1n

* CHECK dout0_12 Vdout0_12ck192 = 0 time = 3860
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=3860.1n

* CHECK dout0_13 Vdout0_13ck192 = 0 time = 3860
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=3860.1n

* CHECK dout0_14 Vdout0_14ck192 = 0 time = 3860
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=3860.1n

* CHECK dout0_15 Vdout0_15ck192 = 0 time = 3860
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=3860.1n

* CHECK dout0_0 Vdout0_0ck194 = 1.8 time = 3900
.meas tran vdout0_0ck194 FIND v(dout0_0) AT=3900.1n

* CHECK dout0_1 Vdout0_1ck194 = 1.8 time = 3900
.meas tran vdout0_1ck194 FIND v(dout0_1) AT=3900.1n

* CHECK dout0_2 Vdout0_2ck194 = 1.8 time = 3900
.meas tran vdout0_2ck194 FIND v(dout0_2) AT=3900.1n

* CHECK dout0_3 Vdout0_3ck194 = 0 time = 3900
.meas tran vdout0_3ck194 FIND v(dout0_3) AT=3900.1n

* CHECK dout0_4 Vdout0_4ck194 = 0 time = 3900
.meas tran vdout0_4ck194 FIND v(dout0_4) AT=3900.1n

* CHECK dout0_5 Vdout0_5ck194 = 1.8 time = 3900
.meas tran vdout0_5ck194 FIND v(dout0_5) AT=3900.1n

* CHECK dout0_6 Vdout0_6ck194 = 1.8 time = 3900
.meas tran vdout0_6ck194 FIND v(dout0_6) AT=3900.1n

* CHECK dout0_7 Vdout0_7ck194 = 0 time = 3900
.meas tran vdout0_7ck194 FIND v(dout0_7) AT=3900.1n

* CHECK dout0_8 Vdout0_8ck194 = 0 time = 3900
.meas tran vdout0_8ck194 FIND v(dout0_8) AT=3900.1n

* CHECK dout0_9 Vdout0_9ck194 = 1.8 time = 3900
.meas tran vdout0_9ck194 FIND v(dout0_9) AT=3900.1n

* CHECK dout0_10 Vdout0_10ck194 = 0 time = 3900
.meas tran vdout0_10ck194 FIND v(dout0_10) AT=3900.1n

* CHECK dout0_11 Vdout0_11ck194 = 0 time = 3900
.meas tran vdout0_11ck194 FIND v(dout0_11) AT=3900.1n

* CHECK dout0_12 Vdout0_12ck194 = 1.8 time = 3900
.meas tran vdout0_12ck194 FIND v(dout0_12) AT=3900.1n

* CHECK dout0_13 Vdout0_13ck194 = 1.8 time = 3900
.meas tran vdout0_13ck194 FIND v(dout0_13) AT=3900.1n

* CHECK dout0_14 Vdout0_14ck194 = 1.8 time = 3900
.meas tran vdout0_14ck194 FIND v(dout0_14) AT=3900.1n

* CHECK dout0_15 Vdout0_15ck194 = 1.8 time = 3900
.meas tran vdout0_15ck194 FIND v(dout0_15) AT=3900.1n

* CHECK dout0_0 Vdout0_0ck195 = 0 time = 3920
.meas tran vdout0_0ck195 FIND v(dout0_0) AT=3920.1n

* CHECK dout0_1 Vdout0_1ck195 = 1.8 time = 3920
.meas tran vdout0_1ck195 FIND v(dout0_1) AT=3920.1n

* CHECK dout0_2 Vdout0_2ck195 = 1.8 time = 3920
.meas tran vdout0_2ck195 FIND v(dout0_2) AT=3920.1n

* CHECK dout0_3 Vdout0_3ck195 = 1.8 time = 3920
.meas tran vdout0_3ck195 FIND v(dout0_3) AT=3920.1n

* CHECK dout0_4 Vdout0_4ck195 = 1.8 time = 3920
.meas tran vdout0_4ck195 FIND v(dout0_4) AT=3920.1n

* CHECK dout0_5 Vdout0_5ck195 = 1.8 time = 3920
.meas tran vdout0_5ck195 FIND v(dout0_5) AT=3920.1n

* CHECK dout0_6 Vdout0_6ck195 = 0 time = 3920
.meas tran vdout0_6ck195 FIND v(dout0_6) AT=3920.1n

* CHECK dout0_7 Vdout0_7ck195 = 1.8 time = 3920
.meas tran vdout0_7ck195 FIND v(dout0_7) AT=3920.1n

* CHECK dout0_8 Vdout0_8ck195 = 1.8 time = 3920
.meas tran vdout0_8ck195 FIND v(dout0_8) AT=3920.1n

* CHECK dout0_9 Vdout0_9ck195 = 1.8 time = 3920
.meas tran vdout0_9ck195 FIND v(dout0_9) AT=3920.1n

* CHECK dout0_10 Vdout0_10ck195 = 1.8 time = 3920
.meas tran vdout0_10ck195 FIND v(dout0_10) AT=3920.1n

* CHECK dout0_11 Vdout0_11ck195 = 1.8 time = 3920
.meas tran vdout0_11ck195 FIND v(dout0_11) AT=3920.1n

* CHECK dout0_12 Vdout0_12ck195 = 1.8 time = 3920
.meas tran vdout0_12ck195 FIND v(dout0_12) AT=3920.1n

* CHECK dout0_13 Vdout0_13ck195 = 1.8 time = 3920
.meas tran vdout0_13ck195 FIND v(dout0_13) AT=3920.1n

* CHECK dout0_14 Vdout0_14ck195 = 1.8 time = 3920
.meas tran vdout0_14ck195 FIND v(dout0_14) AT=3920.1n

* CHECK dout0_15 Vdout0_15ck195 = 0 time = 3920
.meas tran vdout0_15ck195 FIND v(dout0_15) AT=3920.1n

* CHECK dout0_0 Vdout0_0ck197 = 0 time = 3960
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=3960.1n

* CHECK dout0_1 Vdout0_1ck197 = 1.8 time = 3960
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=3960.1n

* CHECK dout0_2 Vdout0_2ck197 = 1.8 time = 3960
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=3960.1n

* CHECK dout0_3 Vdout0_3ck197 = 1.8 time = 3960
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=3960.1n

* CHECK dout0_4 Vdout0_4ck197 = 1.8 time = 3960
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=3960.1n

* CHECK dout0_5 Vdout0_5ck197 = 1.8 time = 3960
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=3960.1n

* CHECK dout0_6 Vdout0_6ck197 = 0 time = 3960
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=3960.1n

* CHECK dout0_7 Vdout0_7ck197 = 1.8 time = 3960
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=3960.1n

* CHECK dout0_8 Vdout0_8ck197 = 1.8 time = 3960
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=3960.1n

* CHECK dout0_9 Vdout0_9ck197 = 1.8 time = 3960
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=3960.1n

* CHECK dout0_10 Vdout0_10ck197 = 1.8 time = 3960
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=3960.1n

* CHECK dout0_11 Vdout0_11ck197 = 1.8 time = 3960
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=3960.1n

* CHECK dout0_12 Vdout0_12ck197 = 1.8 time = 3960
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=3960.1n

* CHECK dout0_13 Vdout0_13ck197 = 1.8 time = 3960
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=3960.1n

* CHECK dout0_14 Vdout0_14ck197 = 1.8 time = 3960
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=3960.1n

* CHECK dout0_15 Vdout0_15ck197 = 0 time = 3960
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=3960.1n

* CHECK dout0_0 Vdout0_0ck198 = 0 time = 3980
.meas tran vdout0_0ck198 FIND v(dout0_0) AT=3980.1n

* CHECK dout0_1 Vdout0_1ck198 = 1.8 time = 3980
.meas tran vdout0_1ck198 FIND v(dout0_1) AT=3980.1n

* CHECK dout0_2 Vdout0_2ck198 = 0 time = 3980
.meas tran vdout0_2ck198 FIND v(dout0_2) AT=3980.1n

* CHECK dout0_3 Vdout0_3ck198 = 0 time = 3980
.meas tran vdout0_3ck198 FIND v(dout0_3) AT=3980.1n

* CHECK dout0_4 Vdout0_4ck198 = 1.8 time = 3980
.meas tran vdout0_4ck198 FIND v(dout0_4) AT=3980.1n

* CHECK dout0_5 Vdout0_5ck198 = 1.8 time = 3980
.meas tran vdout0_5ck198 FIND v(dout0_5) AT=3980.1n

* CHECK dout0_6 Vdout0_6ck198 = 0 time = 3980
.meas tran vdout0_6ck198 FIND v(dout0_6) AT=3980.1n

* CHECK dout0_7 Vdout0_7ck198 = 1.8 time = 3980
.meas tran vdout0_7ck198 FIND v(dout0_7) AT=3980.1n

* CHECK dout0_8 Vdout0_8ck198 = 0 time = 3980
.meas tran vdout0_8ck198 FIND v(dout0_8) AT=3980.1n

* CHECK dout0_9 Vdout0_9ck198 = 0 time = 3980
.meas tran vdout0_9ck198 FIND v(dout0_9) AT=3980.1n

* CHECK dout0_10 Vdout0_10ck198 = 1.8 time = 3980
.meas tran vdout0_10ck198 FIND v(dout0_10) AT=3980.1n

* CHECK dout0_11 Vdout0_11ck198 = 1.8 time = 3980
.meas tran vdout0_11ck198 FIND v(dout0_11) AT=3980.1n

* CHECK dout0_12 Vdout0_12ck198 = 0 time = 3980
.meas tran vdout0_12ck198 FIND v(dout0_12) AT=3980.1n

* CHECK dout0_13 Vdout0_13ck198 = 0 time = 3980
.meas tran vdout0_13ck198 FIND v(dout0_13) AT=3980.1n

* CHECK dout0_14 Vdout0_14ck198 = 1.8 time = 3980
.meas tran vdout0_14ck198 FIND v(dout0_14) AT=3980.1n

* CHECK dout0_15 Vdout0_15ck198 = 1.8 time = 3980
.meas tran vdout0_15ck198 FIND v(dout0_15) AT=3980.1n

* CHECK dout0_0 Vdout0_0ck199 = 1.8 time = 4000
.meas tran vdout0_0ck199 FIND v(dout0_0) AT=4000.1n

* CHECK dout0_1 Vdout0_1ck199 = 1.8 time = 4000
.meas tran vdout0_1ck199 FIND v(dout0_1) AT=4000.1n

* CHECK dout0_2 Vdout0_2ck199 = 1.8 time = 4000
.meas tran vdout0_2ck199 FIND v(dout0_2) AT=4000.1n

* CHECK dout0_3 Vdout0_3ck199 = 0 time = 4000
.meas tran vdout0_3ck199 FIND v(dout0_3) AT=4000.1n

* CHECK dout0_4 Vdout0_4ck199 = 0 time = 4000
.meas tran vdout0_4ck199 FIND v(dout0_4) AT=4000.1n

* CHECK dout0_5 Vdout0_5ck199 = 1.8 time = 4000
.meas tran vdout0_5ck199 FIND v(dout0_5) AT=4000.1n

* CHECK dout0_6 Vdout0_6ck199 = 1.8 time = 4000
.meas tran vdout0_6ck199 FIND v(dout0_6) AT=4000.1n

* CHECK dout0_7 Vdout0_7ck199 = 0 time = 4000
.meas tran vdout0_7ck199 FIND v(dout0_7) AT=4000.1n

* CHECK dout0_8 Vdout0_8ck199 = 0 time = 4000
.meas tran vdout0_8ck199 FIND v(dout0_8) AT=4000.1n

* CHECK dout0_9 Vdout0_9ck199 = 1.8 time = 4000
.meas tran vdout0_9ck199 FIND v(dout0_9) AT=4000.1n

* CHECK dout0_10 Vdout0_10ck199 = 0 time = 4000
.meas tran vdout0_10ck199 FIND v(dout0_10) AT=4000.1n

* CHECK dout0_11 Vdout0_11ck199 = 0 time = 4000
.meas tran vdout0_11ck199 FIND v(dout0_11) AT=4000.1n

* CHECK dout0_12 Vdout0_12ck199 = 1.8 time = 4000
.meas tran vdout0_12ck199 FIND v(dout0_12) AT=4000.1n

* CHECK dout0_13 Vdout0_13ck199 = 1.8 time = 4000
.meas tran vdout0_13ck199 FIND v(dout0_13) AT=4000.1n

* CHECK dout0_14 Vdout0_14ck199 = 1.8 time = 4000
.meas tran vdout0_14ck199 FIND v(dout0_14) AT=4000.1n

* CHECK dout0_15 Vdout0_15ck199 = 1.8 time = 4000
.meas tran vdout0_15ck199 FIND v(dout0_15) AT=4000.1n

* CHECK dout0_0 Vdout0_0ck200 = 1.8 time = 4020
.meas tran vdout0_0ck200 FIND v(dout0_0) AT=4020.1n

* CHECK dout0_1 Vdout0_1ck200 = 0 time = 4020
.meas tran vdout0_1ck200 FIND v(dout0_1) AT=4020.1n

* CHECK dout0_2 Vdout0_2ck200 = 1.8 time = 4020
.meas tran vdout0_2ck200 FIND v(dout0_2) AT=4020.1n

* CHECK dout0_3 Vdout0_3ck200 = 1.8 time = 4020
.meas tran vdout0_3ck200 FIND v(dout0_3) AT=4020.1n

* CHECK dout0_4 Vdout0_4ck200 = 0 time = 4020
.meas tran vdout0_4ck200 FIND v(dout0_4) AT=4020.1n

* CHECK dout0_5 Vdout0_5ck200 = 0 time = 4020
.meas tran vdout0_5ck200 FIND v(dout0_5) AT=4020.1n

* CHECK dout0_6 Vdout0_6ck200 = 0 time = 4020
.meas tran vdout0_6ck200 FIND v(dout0_6) AT=4020.1n

* CHECK dout0_7 Vdout0_7ck200 = 1.8 time = 4020
.meas tran vdout0_7ck200 FIND v(dout0_7) AT=4020.1n

* CHECK dout0_8 Vdout0_8ck200 = 1.8 time = 4020
.meas tran vdout0_8ck200 FIND v(dout0_8) AT=4020.1n

* CHECK dout0_9 Vdout0_9ck200 = 0 time = 4020
.meas tran vdout0_9ck200 FIND v(dout0_9) AT=4020.1n

* CHECK dout0_10 Vdout0_10ck200 = 1.8 time = 4020
.meas tran vdout0_10ck200 FIND v(dout0_10) AT=4020.1n

* CHECK dout0_11 Vdout0_11ck200 = 1.8 time = 4020
.meas tran vdout0_11ck200 FIND v(dout0_11) AT=4020.1n

* CHECK dout0_12 Vdout0_12ck200 = 0 time = 4020
.meas tran vdout0_12ck200 FIND v(dout0_12) AT=4020.1n

* CHECK dout0_13 Vdout0_13ck200 = 1.8 time = 4020
.meas tran vdout0_13ck200 FIND v(dout0_13) AT=4020.1n

* CHECK dout0_14 Vdout0_14ck200 = 1.8 time = 4020
.meas tran vdout0_14ck200 FIND v(dout0_14) AT=4020.1n

* CHECK dout0_15 Vdout0_15ck200 = 1.8 time = 4020
.meas tran vdout0_15ck200 FIND v(dout0_15) AT=4020.1n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
