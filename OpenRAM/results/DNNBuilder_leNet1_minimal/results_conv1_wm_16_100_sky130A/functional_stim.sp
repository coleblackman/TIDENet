* Functional test stimulus file for 20ns period

* TT process corner
.include "/home/mm4uz/Documents/openram/vsdsram_sky130/OpenRAM/technology/sky130A/models/tt.sp"
.include "conv1_wm_sram_16_100_sky130A.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xconv1_wm_sram_16_100_sky130A din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 vdd gnd conv1_wm_sram_16_100_sky130A

* SRAM output loads
CD00 dout0_0  0 39.2968f
CD01 dout0_1  0 39.2968f
CD02 dout0_2  0 39.2968f
CD03 dout0_3  0 39.2968f
CD04 dout0_4  0 39.2968f
CD05 dout0_5  0 39.2968f
CD06 dout0_6  0 39.2968f
CD07 dout0_7  0 39.2968f
CD08 dout0_8  0 39.2968f
CD09 dout0_9  0 39.2968f
CD010 dout0_10  0 39.2968f
CD011 dout0_11  0 39.2968f
CD012 dout0_12  0 39.2968f
CD013 dout0_13  0 39.2968f
CD014 dout0_14  0 39.2968f
CD015 dout0_15  0 39.2968f

* Important signals for debug
* bl:	xconv1_wm_sram_16_100_sky130a.xbank0.bl_0_0
* br:	xconv1_wm_sram_16_100_sky130a.xbank0.br_0_0
* s_en:	xconv1_wm_sram_16_100_sky130a.s_en
* q:	xconv1_wm_sram_16_100_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xconv1_wm_sram_16_100_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 20ns)
*	Writing 1001001000011010  to  address 0000001 (from port 0) during cycle 1 (20ns - 40ns)
*	Writing 1001111010011101  to  address 1100010 (from port 0) during cycle 2 (40ns - 60ns)
*	Writing 0011010111010111  to  address 1100010 (from port 0) during cycle 3 (60ns - 80ns)
*	Reading 0011010111010111 from address 1100010 (from port 0) during cycle 4 (80ns - 100ns)
*	Reading 0011010111010111 from address 1100010 (from port 0) during cycle 5 (100ns - 120ns)
*	Reading 0011010111010111 from address 1100010 (from port 0) during cycle 6 (120ns - 140ns)
*	Reading 1001001000011010 from address 0000001 (from port 0) during cycle 8 (160ns - 180ns)
*	Reading 0011010111010111 from address 1100010 (from port 0) during cycle 9 (180ns - 200ns)
*	Reading 1001001000011010 from address 0000001 (from port 0) during cycle 10 (200ns - 220ns)
*	Reading 1001001000011010 from address 0000001 (from port 0) during cycle 12 (240ns - 260ns)
*	Reading 0011010111010111 from address 1100010 (from port 0) during cycle 13 (260ns - 280ns)
*	Writing 1101000000001101  to  address 1100010 (from port 0) during cycle 14 (280ns - 300ns)
*	Writing 0001000011101100  to  address 1100001 (from port 0) during cycle 16 (320ns - 340ns)
*	Reading 1101000000001101 from address 1100010 (from port 0) during cycle 19 (380ns - 400ns)
*	Writing 0001010001011010  to  address 1100001 (from port 0) during cycle 20 (400ns - 420ns)
*	Reading 1001001000011010 from address 0000001 (from port 0) during cycle 21 (420ns - 440ns)
*	Reading 1101000000001101 from address 1100010 (from port 0) during cycle 22 (440ns - 460ns)
*	Reading 0001010001011010 from address 1100001 (from port 0) during cycle 24 (480ns - 500ns)
*	Reading 0001010001011010 from address 1100001 (from port 0) during cycle 26 (520ns - 540ns)
*	Reading 0001010001011010 from address 1100001 (from port 0) during cycle 28 (560ns - 580ns)
*	Reading 1101000000001101 from address 1100010 (from port 0) during cycle 29 (580ns - 600ns)
*	Reading 0001010001011010 from address 1100001 (from port 0) during cycle 32 (640ns - 660ns)
*	Reading 0001010001011010 from address 1100001 (from port 0) during cycle 33 (660ns - 680ns)
*	Reading 0001010001011010 from address 1100001 (from port 0) during cycle 34 (680ns - 700ns)
*	Writing 1100011000110001  to  address 1100010 (from port 0) during cycle 35 (700ns - 720ns)
*	Reading 0001010001011010 from address 1100001 (from port 0) during cycle 37 (740ns - 760ns)
*	Writing 1100010001111111  to  address 1100010 (from port 0) during cycle 38 (760ns - 780ns)
*	Writing 0011111111000000  to  address 1100010 (from port 0) during cycle 39 (780ns - 800ns)
*	Reading 0001010001011010 from address 1100001 (from port 0) during cycle 40 (800ns - 820ns)
*	Writing 0110100010000110  to  address 0000000 (from port 0) during cycle 41 (820ns - 840ns)
*	Reading 1001001000011010 from address 0000001 (from port 0) during cycle 42 (840ns - 860ns)
*	Reading 0001010001011010 from address 1100001 (from port 0) during cycle 44 (880ns - 900ns)
*	Writing 0101100100001011  to  address 1100001 (from port 0) during cycle 45 (900ns - 920ns)
*	Reading 0011111111000000 from address 1100010 (from port 0) during cycle 46 (920ns - 940ns)
*	Writing 0100001000111000  to  address 1100010 (from port 0) during cycle 47 (940ns - 960ns)
*	Reading 0101100100001011 from address 1100001 (from port 0) during cycle 48 (960ns - 980ns)
*	Reading 1001001000011010 from address 0000001 (from port 0) during cycle 49 (980ns - 1000ns)
*	Writing 0100100110001100  to  address 1100001 (from port 0) during cycle 51 (1020ns - 1040ns)
*	Reading 0100001000111000 from address 1100010 (from port 0) during cycle 52 (1040ns - 1060ns)
*	Reading 1001001000011010 from address 0000001 (from port 0) during cycle 53 (1060ns - 1080ns)
*	Reading 0100001000111000 from address 1100010 (from port 0) during cycle 54 (1080ns - 1100ns)
*	Reading 0110100010000110 from address 0000000 (from port 0) during cycle 55 (1100ns - 1120ns)
*	Writing 0101110010000011  to  address 0000001 (from port 0) during cycle 56 (1120ns - 1140ns)
*	Writing 1000010011010011  to  address 1100010 (from port 0) during cycle 57 (1140ns - 1160ns)
*	Reading 1000010011010011 from address 1100010 (from port 0) during cycle 59 (1180ns - 1200ns)
*	Reading 0100100110001100 from address 1100001 (from port 0) during cycle 60 (1200ns - 1220ns)
*	Reading 0100100110001100 from address 1100001 (from port 0) during cycle 62 (1240ns - 1260ns)
*	Writing 0110110001110100  to  address 1100010 (from port 0) during cycle 64 (1280ns - 1300ns)
*	Reading 0100100110001100 from address 1100001 (from port 0) during cycle 65 (1300ns - 1320ns)
*	Reading 0100100110001100 from address 1100001 (from port 0) during cycle 66 (1320ns - 1340ns)
*	Writing 1001100100100110  to  address 0000000 (from port 0) during cycle 67 (1340ns - 1360ns)
*	Writing 1001110100011110  to  address 1100010 (from port 0) during cycle 69 (1380ns - 1400ns)
*	Reading 1001110100011110 from address 1100010 (from port 0) during cycle 70 (1400ns - 1420ns)
*	Reading 1001100100100110 from address 0000000 (from port 0) during cycle 71 (1420ns - 1440ns)
*	Reading 0100100110001100 from address 1100001 (from port 0) during cycle 73 (1460ns - 1480ns)
*	Writing 0001000101101011  to  address 0000001 (from port 0) during cycle 74 (1480ns - 1500ns)
*	Reading 0001000101101011 from address 0000001 (from port 0) during cycle 75 (1500ns - 1520ns)
*	Reading 0100100110001100 from address 1100001 (from port 0) during cycle 76 (1520ns - 1540ns)
*	Writing 1100001000111010  to  address 1100001 (from port 0) during cycle 77 (1540ns - 1560ns)
*	Reading 0001000101101011 from address 0000001 (from port 0) during cycle 78 (1560ns - 1580ns)
*	Writing 1101101000111111  to  address 1100001 (from port 0) during cycle 79 (1580ns - 1600ns)
*	Reading 1001100100100110 from address 0000000 (from port 0) during cycle 80 (1600ns - 1620ns)
*	Reading 0001000101101011 from address 0000001 (from port 0) during cycle 81 (1620ns - 1640ns)
*	Reading 1001100100100110 from address 0000000 (from port 0) during cycle 84 (1680ns - 1700ns)
*	Reading 1001100100100110 from address 0000000 (from port 0) during cycle 86 (1720ns - 1740ns)
*	Reading 1001110100011110 from address 1100010 (from port 0) during cycle 88 (1760ns - 1780ns)
*	Writing 1000011100111011  to  address 0000000 (from port 0) during cycle 90 (1800ns - 1820ns)
*	Writing 1111101111110101  to  address 0000001 (from port 0) during cycle 91 (1820ns - 1840ns)
*	Reading 1000011100111011 from address 0000000 (from port 0) during cycle 92 (1840ns - 1860ns)
*	Writing 0111011101011001  to  address 1100001 (from port 0) during cycle 95 (1900ns - 1920ns)
*	Reading 0111011101011001 from address 1100001 (from port 0) during cycle 96 (1920ns - 1940ns)
*	Reading 1001110100011110 from address 1100010 (from port 0) during cycle 97 (1940ns - 1960ns)
*	Writing 0011000100100001  to  address 0000001 (from port 0) during cycle 99 (1980ns - 2000ns)
*	Reading 0011000100100001 from address 0000001 (from port 0) during cycle 100 (2000ns - 2020ns)
*	Writing 1110001010101000  to  address 1100010 (from port 0) during cycle 101 (2020ns - 2040ns)
*	Writing 1101011001000101  to  address 0000001 (from port 0) during cycle 102 (2040ns - 2060ns)
*	Reading 1000011100111011 from address 0000000 (from port 0) during cycle 103 (2060ns - 2080ns)
*	Reading 1000011100111011 from address 0000000 (from port 0) during cycle 104 (2080ns - 2100ns)
*	Reading 1110001010101000 from address 1100010 (from port 0) during cycle 105 (2100ns - 2120ns)
*	Reading 1000011100111011 from address 0000000 (from port 0) during cycle 108 (2160ns - 2180ns)
*	Writing 0110001110100000  to  address 0000001 (from port 0) during cycle 109 (2180ns - 2200ns)
*	Reading 1110001010101000 from address 1100010 (from port 0) during cycle 114 (2280ns - 2300ns)
*	Writing 0010110001001010  to  address 1100010 (from port 0) during cycle 115 (2300ns - 2320ns)
*	Reading 0010110001001010 from address 1100010 (from port 0) during cycle 116 (2320ns - 2340ns)
*	Reading 0110001110100000 from address 0000001 (from port 0) during cycle 117 (2340ns - 2360ns)
*	Reading 1000011100111011 from address 0000000 (from port 0) during cycle 118 (2360ns - 2380ns)
*	Reading 0110001110100000 from address 0000001 (from port 0) during cycle 119 (2380ns - 2400ns)
*	Reading 0110001110100000 from address 0000001 (from port 0) during cycle 120 (2400ns - 2420ns)
*	Writing 1011101000111011  to  address 1100001 (from port 0) during cycle 123 (2460ns - 2480ns)
*	Writing 1001111110111011  to  address 0000001 (from port 0) during cycle 125 (2500ns - 2520ns)
*	Reading 1001111110111011 from address 0000001 (from port 0) during cycle 126 (2520ns - 2540ns)
*	Reading 1000011100111011 from address 0000000 (from port 0) during cycle 127 (2540ns - 2560ns)
*	Writing 1101111010110100  to  address 0000000 (from port 0) during cycle 128 (2560ns - 2580ns)
*	Writing 1000100111001011  to  address 0000001 (from port 0) during cycle 129 (2580ns - 2600ns)
*	Writing 0010001001110010  to  address 1100010 (from port 0) during cycle 130 (2600ns - 2620ns)
*	Reading 0010001001110010 from address 1100010 (from port 0) during cycle 132 (2640ns - 2660ns)
*	Writing 1001000101001010  to  address 0000000 (from port 0) during cycle 133 (2660ns - 2680ns)
*	Reading 1001000101001010 from address 0000000 (from port 0) during cycle 134 (2680ns - 2700ns)
*	Writing 1010110110001111  to  address 1100010 (from port 0) during cycle 136 (2720ns - 2740ns)
*	Writing 0010111000010110  to  address 0000000 (from port 0) during cycle 138 (2760ns - 2780ns)
*	Reading 1010110110001111 from address 1100010 (from port 0) during cycle 140 (2800ns - 2820ns)
*	Writing 1000011000010000  to  address 0000001 (from port 0) during cycle 141 (2820ns - 2840ns)
*	Writing 0111110000100000  to  address 1100010 (from port 0) during cycle 142 (2840ns - 2860ns)
*	Reading 0010111000010110 from address 0000000 (from port 0) during cycle 145 (2900ns - 2920ns)
*	Writing 1111010000000011  to  address 0000001 (from port 0) during cycle 146 (2920ns - 2940ns)
*	Reading 1011101000111011 from address 1100001 (from port 0) during cycle 147 (2940ns - 2960ns)
*	Reading 0111110000100000 from address 1100010 (from port 0) during cycle 148 (2960ns - 2980ns)
*	Writing 1110100001100111  to  address 1100001 (from port 0) during cycle 149 (2980ns - 3000ns)
*	Reading 1111010000000011 from address 0000001 (from port 0) during cycle 150 (3000ns - 3020ns)
*	Reading 0010111000010110 from address 0000000 (from port 0) during cycle 151 (3020ns - 3040ns)
*	Reading 0111110000100000 from address 1100010 (from port 0) during cycle 152 (3040ns - 3060ns)
*	Writing 1010000001111110  to  address 0000001 (from port 0) during cycle 153 (3060ns - 3080ns)
*	Writing 0100001111111100  to  address 0000000 (from port 0) during cycle 158 (3160ns - 3180ns)
*	Reading 0111110000100000 from address 1100010 (from port 0) during cycle 164 (3280ns - 3300ns)
*	Writing 0001101100000101  to  address 0000001 (from port 0) during cycle 165 (3300ns - 3320ns)
*	Reading 0111110000100000 from address 1100010 (from port 0) during cycle 166 (3320ns - 3340ns)
*	Reading 1110100001100111 from address 1100001 (from port 0) during cycle 167 (3340ns - 3360ns)
*	Reading 0001101100000101 from address 0000001 (from port 0) during cycle 168 (3360ns - 3380ns)
*	Reading 0111110000100000 from address 1100010 (from port 0) during cycle 170 (3400ns - 3420ns)
*	Reading 1110100001100111 from address 1100001 (from port 0) during cycle 171 (3420ns - 3440ns)
*	Reading 0111110000100000 from address 1100010 (from port 0) during cycle 172 (3440ns - 3460ns)
*	Reading 0001101100000101 from address 0000001 (from port 0) during cycle 174 (3480ns - 3500ns)
*	Reading 0111110000100000 from address 1100010 (from port 0) during cycle 175 (3500ns - 3520ns)
*	Writing 1001000111101011  to  address 0000001 (from port 0) during cycle 176 (3520ns - 3540ns)
*	Reading 1001000111101011 from address 0000001 (from port 0) during cycle 177 (3540ns - 3560ns)
*	Reading 1110100001100111 from address 1100001 (from port 0) during cycle 178 (3560ns - 3580ns)
*	Reading 0111110000100000 from address 1100010 (from port 0) during cycle 181 (3620ns - 3640ns)
*	Writing 0011111110000000  to  address 1100010 (from port 0) during cycle 182 (3640ns - 3660ns)
*	Reading 1001000111101011 from address 0000001 (from port 0) during cycle 183 (3660ns - 3680ns)
*	Reading 0011111110000000 from address 1100010 (from port 0) during cycle 184 (3680ns - 3700ns)
*	Reading 0100001111111100 from address 0000000 (from port 0) during cycle 185 (3700ns - 3720ns)
*	Writing 1010000101101100  to  address 0000001 (from port 0) during cycle 186 (3720ns - 3740ns)
*	Reading 0011111110000000 from address 1100010 (from port 0) during cycle 187 (3740ns - 3760ns)
*	Reading 0011111110000000 from address 1100010 (from port 0) during cycle 188 (3760ns - 3780ns)
*	Reading 1110100001100111 from address 1100001 (from port 0) during cycle 189 (3780ns - 3800ns)
*	Reading 0100001111111100 from address 0000000 (from port 0) during cycle 190 (3800ns - 3820ns)
*	Reading 0100001111111100 from address 0000000 (from port 0) during cycle 192 (3840ns - 3860ns)
*	Writing 0000001110100000  to  address 0000001 (from port 0) during cycle 193 (3860ns - 3880ns)
*	Writing 0011111010000000  to  address 1100001 (from port 0) during cycle 194 (3880ns - 3900ns)
*	Reading 0011111110000000 from address 1100010 (from port 0) during cycle 196 (3920ns - 3940ns)
*	Reading 0000001110100000 from address 0000001 (from port 0) during cycle 197 (3940ns - 3960ns)
*	Writing 0000001101110100  to  address 0000001 (from port 0) during cycle 198 (3960ns - 3980ns)
*	Reading 0011111110000000 from address 1100010 (from port 0) during cycle 199 (3980ns - 4000ns)
*	Reading 0100001111111100 from address 0000000 (from port 0) during cycle 200 (4000ns - 4020ns)
*	Writing 1010111111111000  to  address 0000000 (from port 0) during cycle 201 (4020ns - 4040ns)
*	Reading 1010111111111000 from address 0000000 (from port 0) during cycle 202 (4040ns - 4060ns)
*	Reading 0011111110000000 from address 1100010 (from port 0) during cycle 203 (4060ns - 4080ns)
*	Idle during cycle 205 (4100ns - 4120ns)

* Generation of data and address signals
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 1), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 1), (1500, 1), (1520, 1), (1540, 0), (1560, 0), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 0), (720, 0), (740, 0), (760, 1), (780, 0), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 1), (780, 0), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 1), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 1), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 0), (720, 0), (740, 0), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 0), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 0), (720, 0), (740, 0), (760, 1), (780, 1), (800, 1), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 1), (1500, 1), (1520, 1), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 0), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 0), (840, 0), (860, 0), (880, 0), (900, 1), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 1), (2520, 1), (2540, 1), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 0), (780, 1), (800, 1), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 0), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 0), (2480, 0), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 0), (840, 0), (860, 0), (880, 0), (900, 1), (920, 1), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 0), (1560, 0), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 1), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 0), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 0), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 0), (320, 1), (340, 1), (360, 1), (380, 0), (400, 1), (420, 1), (440, 0), (460, 0), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 0), (600, 0), (620, 0), (640, 1), (660, 1), (680, 1), (700, 0), (720, 0), (740, 1), (760, 0), (780, 0), (800, 1), (820, 0), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 0), (1060, 1), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 0), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 0), (1620, 1), (1640, 1), (1660, 1), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 1), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 0), (1960, 0), (1980, 1), (2000, 1), (2020, 0), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 0), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 0), (2560, 0), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 0), (3340, 1), (3360, 1), (3380, 1), (3400, 0), (3420, 1), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 0), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 1), (3740, 0), (3760, 0), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 1), (3960, 1), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 1), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 0), (340, 0), (360, 0), (380, 1), (400, 0), (420, 0), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 1), (600, 1), (620, 1), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 0), (760, 1), (780, 1), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 1), (940, 1), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 1), (1060, 0), (1080, 1), (1100, 0), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 1), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 0), (2920, 0), (2940, 0), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 0), (3320, 1), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 0), (3500, 1), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 1), (3640, 1), (3660, 0), (3680, 1), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 1), (3940, 0), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 1), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 0), (840, 0), (860, 0), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 1), (1040, 1), (1060, 0), (1080, 1), (1100, 0), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 1), (1480, 0), (1500, 0), (1520, 1), (1540, 1), (1560, 0), (1580, 1), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 1), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 0), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 0), (3500, 1), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 1), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Va0_5  a0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 1), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 0), (840, 0), (860, 0), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 0), (1000, 0), (1020, 1), (1040, 1), (1060, 0), (1080, 1), (1100, 0), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 0), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 1), (1480, 0), (1500, 0), (1520, 1), (1540, 1), (1560, 0), (1580, 1), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 1), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 1), (3000, 0), (3020, 0), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 0), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 0), (3500, 1), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 0), (3680, 1), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Va0_6  a0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )

 * Generation of control signals
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 1), (160, 0), (180, 0), (200, 0), (220, 1), (240, 0), (260, 0), (280, 0), (300, 1), (320, 0), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 1), (480, 0), (500, 1), (520, 0), (540, 1), (560, 0), (580, 0), (600, 1), (620, 1), (640, 0), (660, 0), (680, 0), (700, 0), (720, 1), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 1), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 1), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 0), (1200, 0), (1220, 1), (1240, 0), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 0), (1400, 0), (1420, 0), (1440, 1), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 1), (1660, 1), (1680, 0), (1700, 1), (1720, 0), (1740, 1), (1760, 0), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 1), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 1), (2440, 1), (2460, 0), (2480, 1), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 0), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 1), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 1), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 0), (300, 1), (320, 0), (340, 1), (360, 1), (380, 1), (400, 0), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 0), (720, 1), (740, 1), (760, 0), (780, 0), (800, 1), (820, 0), (840, 1), (860, 1), (880, 1), (900, 0), (920, 1), (940, 0), (960, 1), (980, 1), (1000, 1), (1020, 0), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 0), (1300, 1), (1320, 1), (1340, 0), (1360, 1), (1380, 0), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 1), (1540, 0), (1560, 1), (1580, 0), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 0), (2000, 1), (2020, 0), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 0), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 0), (2480, 1), (2500, 0), (2520, 1), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 0), (2680, 1), (2700, 1), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 0), (2940, 1), (2960, 1), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 0), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 0), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 0), (3660, 1), (3680, 1), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 1), (4000, 1), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 0.0v 418.95n 0.0v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* PULSE: period=20
Vclk0 clk0 0 PULSE (0 1.8 19.95n 0.1n 0.1n 9.899999999999999n 20n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 1.8 time = 100
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=100.1n

* CHECK dout0_1 Vdout0_1ck4 = 1.8 time = 100
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=100.1n

* CHECK dout0_2 Vdout0_2ck4 = 1.8 time = 100
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=100.1n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 100
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=100.1n

* CHECK dout0_4 Vdout0_4ck4 = 1.8 time = 100
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=100.1n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 100
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=100.1n

* CHECK dout0_6 Vdout0_6ck4 = 1.8 time = 100
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=100.1n

* CHECK dout0_7 Vdout0_7ck4 = 1.8 time = 100
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=100.1n

* CHECK dout0_8 Vdout0_8ck4 = 1.8 time = 100
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=100.1n

* CHECK dout0_9 Vdout0_9ck4 = 0 time = 100
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=100.1n

* CHECK dout0_10 Vdout0_10ck4 = 1.8 time = 100
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=100.1n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 100
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=100.1n

* CHECK dout0_12 Vdout0_12ck4 = 1.8 time = 100
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=100.1n

* CHECK dout0_13 Vdout0_13ck4 = 1.8 time = 100
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=100.1n

* CHECK dout0_14 Vdout0_14ck4 = 0 time = 100
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=100.1n

* CHECK dout0_15 Vdout0_15ck4 = 0 time = 100
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=100.1n

* CHECK dout0_0 Vdout0_0ck5 = 1.8 time = 120
.meas tran vdout0_0ck5 FIND v(dout0_0) AT=120.1n

* CHECK dout0_1 Vdout0_1ck5 = 1.8 time = 120
.meas tran vdout0_1ck5 FIND v(dout0_1) AT=120.1n

* CHECK dout0_2 Vdout0_2ck5 = 1.8 time = 120
.meas tran vdout0_2ck5 FIND v(dout0_2) AT=120.1n

* CHECK dout0_3 Vdout0_3ck5 = 0 time = 120
.meas tran vdout0_3ck5 FIND v(dout0_3) AT=120.1n

* CHECK dout0_4 Vdout0_4ck5 = 1.8 time = 120
.meas tran vdout0_4ck5 FIND v(dout0_4) AT=120.1n

* CHECK dout0_5 Vdout0_5ck5 = 0 time = 120
.meas tran vdout0_5ck5 FIND v(dout0_5) AT=120.1n

* CHECK dout0_6 Vdout0_6ck5 = 1.8 time = 120
.meas tran vdout0_6ck5 FIND v(dout0_6) AT=120.1n

* CHECK dout0_7 Vdout0_7ck5 = 1.8 time = 120
.meas tran vdout0_7ck5 FIND v(dout0_7) AT=120.1n

* CHECK dout0_8 Vdout0_8ck5 = 1.8 time = 120
.meas tran vdout0_8ck5 FIND v(dout0_8) AT=120.1n

* CHECK dout0_9 Vdout0_9ck5 = 0 time = 120
.meas tran vdout0_9ck5 FIND v(dout0_9) AT=120.1n

* CHECK dout0_10 Vdout0_10ck5 = 1.8 time = 120
.meas tran vdout0_10ck5 FIND v(dout0_10) AT=120.1n

* CHECK dout0_11 Vdout0_11ck5 = 0 time = 120
.meas tran vdout0_11ck5 FIND v(dout0_11) AT=120.1n

* CHECK dout0_12 Vdout0_12ck5 = 1.8 time = 120
.meas tran vdout0_12ck5 FIND v(dout0_12) AT=120.1n

* CHECK dout0_13 Vdout0_13ck5 = 1.8 time = 120
.meas tran vdout0_13ck5 FIND v(dout0_13) AT=120.1n

* CHECK dout0_14 Vdout0_14ck5 = 0 time = 120
.meas tran vdout0_14ck5 FIND v(dout0_14) AT=120.1n

* CHECK dout0_15 Vdout0_15ck5 = 0 time = 120
.meas tran vdout0_15ck5 FIND v(dout0_15) AT=120.1n

* CHECK dout0_0 Vdout0_0ck6 = 1.8 time = 140
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=140.1n

* CHECK dout0_1 Vdout0_1ck6 = 1.8 time = 140
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=140.1n

* CHECK dout0_2 Vdout0_2ck6 = 1.8 time = 140
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=140.1n

* CHECK dout0_3 Vdout0_3ck6 = 0 time = 140
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=140.1n

* CHECK dout0_4 Vdout0_4ck6 = 1.8 time = 140
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=140.1n

* CHECK dout0_5 Vdout0_5ck6 = 0 time = 140
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=140.1n

* CHECK dout0_6 Vdout0_6ck6 = 1.8 time = 140
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=140.1n

* CHECK dout0_7 Vdout0_7ck6 = 1.8 time = 140
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=140.1n

* CHECK dout0_8 Vdout0_8ck6 = 1.8 time = 140
.meas tran vdout0_8ck6 FIND v(dout0_8) AT=140.1n

* CHECK dout0_9 Vdout0_9ck6 = 0 time = 140
.meas tran vdout0_9ck6 FIND v(dout0_9) AT=140.1n

* CHECK dout0_10 Vdout0_10ck6 = 1.8 time = 140
.meas tran vdout0_10ck6 FIND v(dout0_10) AT=140.1n

* CHECK dout0_11 Vdout0_11ck6 = 0 time = 140
.meas tran vdout0_11ck6 FIND v(dout0_11) AT=140.1n

* CHECK dout0_12 Vdout0_12ck6 = 1.8 time = 140
.meas tran vdout0_12ck6 FIND v(dout0_12) AT=140.1n

* CHECK dout0_13 Vdout0_13ck6 = 1.8 time = 140
.meas tran vdout0_13ck6 FIND v(dout0_13) AT=140.1n

* CHECK dout0_14 Vdout0_14ck6 = 0 time = 140
.meas tran vdout0_14ck6 FIND v(dout0_14) AT=140.1n

* CHECK dout0_15 Vdout0_15ck6 = 0 time = 140
.meas tran vdout0_15ck6 FIND v(dout0_15) AT=140.1n

* CHECK dout0_0 Vdout0_0ck8 = 0 time = 180
.meas tran vdout0_0ck8 FIND v(dout0_0) AT=180.1n

* CHECK dout0_1 Vdout0_1ck8 = 1.8 time = 180
.meas tran vdout0_1ck8 FIND v(dout0_1) AT=180.1n

* CHECK dout0_2 Vdout0_2ck8 = 0 time = 180
.meas tran vdout0_2ck8 FIND v(dout0_2) AT=180.1n

* CHECK dout0_3 Vdout0_3ck8 = 1.8 time = 180
.meas tran vdout0_3ck8 FIND v(dout0_3) AT=180.1n

* CHECK dout0_4 Vdout0_4ck8 = 1.8 time = 180
.meas tran vdout0_4ck8 FIND v(dout0_4) AT=180.1n

* CHECK dout0_5 Vdout0_5ck8 = 0 time = 180
.meas tran vdout0_5ck8 FIND v(dout0_5) AT=180.1n

* CHECK dout0_6 Vdout0_6ck8 = 0 time = 180
.meas tran vdout0_6ck8 FIND v(dout0_6) AT=180.1n

* CHECK dout0_7 Vdout0_7ck8 = 0 time = 180
.meas tran vdout0_7ck8 FIND v(dout0_7) AT=180.1n

* CHECK dout0_8 Vdout0_8ck8 = 0 time = 180
.meas tran vdout0_8ck8 FIND v(dout0_8) AT=180.1n

* CHECK dout0_9 Vdout0_9ck8 = 1.8 time = 180
.meas tran vdout0_9ck8 FIND v(dout0_9) AT=180.1n

* CHECK dout0_10 Vdout0_10ck8 = 0 time = 180
.meas tran vdout0_10ck8 FIND v(dout0_10) AT=180.1n

* CHECK dout0_11 Vdout0_11ck8 = 0 time = 180
.meas tran vdout0_11ck8 FIND v(dout0_11) AT=180.1n

* CHECK dout0_12 Vdout0_12ck8 = 1.8 time = 180
.meas tran vdout0_12ck8 FIND v(dout0_12) AT=180.1n

* CHECK dout0_13 Vdout0_13ck8 = 0 time = 180
.meas tran vdout0_13ck8 FIND v(dout0_13) AT=180.1n

* CHECK dout0_14 Vdout0_14ck8 = 0 time = 180
.meas tran vdout0_14ck8 FIND v(dout0_14) AT=180.1n

* CHECK dout0_15 Vdout0_15ck8 = 1.8 time = 180
.meas tran vdout0_15ck8 FIND v(dout0_15) AT=180.1n

* CHECK dout0_0 Vdout0_0ck9 = 1.8 time = 200
.meas tran vdout0_0ck9 FIND v(dout0_0) AT=200.1n

* CHECK dout0_1 Vdout0_1ck9 = 1.8 time = 200
.meas tran vdout0_1ck9 FIND v(dout0_1) AT=200.1n

* CHECK dout0_2 Vdout0_2ck9 = 1.8 time = 200
.meas tran vdout0_2ck9 FIND v(dout0_2) AT=200.1n

* CHECK dout0_3 Vdout0_3ck9 = 0 time = 200
.meas tran vdout0_3ck9 FIND v(dout0_3) AT=200.1n

* CHECK dout0_4 Vdout0_4ck9 = 1.8 time = 200
.meas tran vdout0_4ck9 FIND v(dout0_4) AT=200.1n

* CHECK dout0_5 Vdout0_5ck9 = 0 time = 200
.meas tran vdout0_5ck9 FIND v(dout0_5) AT=200.1n

* CHECK dout0_6 Vdout0_6ck9 = 1.8 time = 200
.meas tran vdout0_6ck9 FIND v(dout0_6) AT=200.1n

* CHECK dout0_7 Vdout0_7ck9 = 1.8 time = 200
.meas tran vdout0_7ck9 FIND v(dout0_7) AT=200.1n

* CHECK dout0_8 Vdout0_8ck9 = 1.8 time = 200
.meas tran vdout0_8ck9 FIND v(dout0_8) AT=200.1n

* CHECK dout0_9 Vdout0_9ck9 = 0 time = 200
.meas tran vdout0_9ck9 FIND v(dout0_9) AT=200.1n

* CHECK dout0_10 Vdout0_10ck9 = 1.8 time = 200
.meas tran vdout0_10ck9 FIND v(dout0_10) AT=200.1n

* CHECK dout0_11 Vdout0_11ck9 = 0 time = 200
.meas tran vdout0_11ck9 FIND v(dout0_11) AT=200.1n

* CHECK dout0_12 Vdout0_12ck9 = 1.8 time = 200
.meas tran vdout0_12ck9 FIND v(dout0_12) AT=200.1n

* CHECK dout0_13 Vdout0_13ck9 = 1.8 time = 200
.meas tran vdout0_13ck9 FIND v(dout0_13) AT=200.1n

* CHECK dout0_14 Vdout0_14ck9 = 0 time = 200
.meas tran vdout0_14ck9 FIND v(dout0_14) AT=200.1n

* CHECK dout0_15 Vdout0_15ck9 = 0 time = 200
.meas tran vdout0_15ck9 FIND v(dout0_15) AT=200.1n

* CHECK dout0_0 Vdout0_0ck10 = 0 time = 220
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=220.1n

* CHECK dout0_1 Vdout0_1ck10 = 1.8 time = 220
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=220.1n

* CHECK dout0_2 Vdout0_2ck10 = 0 time = 220
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=220.1n

* CHECK dout0_3 Vdout0_3ck10 = 1.8 time = 220
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=220.1n

* CHECK dout0_4 Vdout0_4ck10 = 1.8 time = 220
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=220.1n

* CHECK dout0_5 Vdout0_5ck10 = 0 time = 220
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=220.1n

* CHECK dout0_6 Vdout0_6ck10 = 0 time = 220
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=220.1n

* CHECK dout0_7 Vdout0_7ck10 = 0 time = 220
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=220.1n

* CHECK dout0_8 Vdout0_8ck10 = 0 time = 220
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=220.1n

* CHECK dout0_9 Vdout0_9ck10 = 1.8 time = 220
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=220.1n

* CHECK dout0_10 Vdout0_10ck10 = 0 time = 220
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=220.1n

* CHECK dout0_11 Vdout0_11ck10 = 0 time = 220
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=220.1n

* CHECK dout0_12 Vdout0_12ck10 = 1.8 time = 220
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=220.1n

* CHECK dout0_13 Vdout0_13ck10 = 0 time = 220
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=220.1n

* CHECK dout0_14 Vdout0_14ck10 = 0 time = 220
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=220.1n

* CHECK dout0_15 Vdout0_15ck10 = 1.8 time = 220
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=220.1n

* CHECK dout0_0 Vdout0_0ck12 = 0 time = 260
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=260.1n

* CHECK dout0_1 Vdout0_1ck12 = 1.8 time = 260
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=260.1n

* CHECK dout0_2 Vdout0_2ck12 = 0 time = 260
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=260.1n

* CHECK dout0_3 Vdout0_3ck12 = 1.8 time = 260
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=260.1n

* CHECK dout0_4 Vdout0_4ck12 = 1.8 time = 260
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=260.1n

* CHECK dout0_5 Vdout0_5ck12 = 0 time = 260
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=260.1n

* CHECK dout0_6 Vdout0_6ck12 = 0 time = 260
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=260.1n

* CHECK dout0_7 Vdout0_7ck12 = 0 time = 260
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=260.1n

* CHECK dout0_8 Vdout0_8ck12 = 0 time = 260
.meas tran vdout0_8ck12 FIND v(dout0_8) AT=260.1n

* CHECK dout0_9 Vdout0_9ck12 = 1.8 time = 260
.meas tran vdout0_9ck12 FIND v(dout0_9) AT=260.1n

* CHECK dout0_10 Vdout0_10ck12 = 0 time = 260
.meas tran vdout0_10ck12 FIND v(dout0_10) AT=260.1n

* CHECK dout0_11 Vdout0_11ck12 = 0 time = 260
.meas tran vdout0_11ck12 FIND v(dout0_11) AT=260.1n

* CHECK dout0_12 Vdout0_12ck12 = 1.8 time = 260
.meas tran vdout0_12ck12 FIND v(dout0_12) AT=260.1n

* CHECK dout0_13 Vdout0_13ck12 = 0 time = 260
.meas tran vdout0_13ck12 FIND v(dout0_13) AT=260.1n

* CHECK dout0_14 Vdout0_14ck12 = 0 time = 260
.meas tran vdout0_14ck12 FIND v(dout0_14) AT=260.1n

* CHECK dout0_15 Vdout0_15ck12 = 1.8 time = 260
.meas tran vdout0_15ck12 FIND v(dout0_15) AT=260.1n

* CHECK dout0_0 Vdout0_0ck13 = 1.8 time = 280
.meas tran vdout0_0ck13 FIND v(dout0_0) AT=280.1n

* CHECK dout0_1 Vdout0_1ck13 = 1.8 time = 280
.meas tran vdout0_1ck13 FIND v(dout0_1) AT=280.1n

* CHECK dout0_2 Vdout0_2ck13 = 1.8 time = 280
.meas tran vdout0_2ck13 FIND v(dout0_2) AT=280.1n

* CHECK dout0_3 Vdout0_3ck13 = 0 time = 280
.meas tran vdout0_3ck13 FIND v(dout0_3) AT=280.1n

* CHECK dout0_4 Vdout0_4ck13 = 1.8 time = 280
.meas tran vdout0_4ck13 FIND v(dout0_4) AT=280.1n

* CHECK dout0_5 Vdout0_5ck13 = 0 time = 280
.meas tran vdout0_5ck13 FIND v(dout0_5) AT=280.1n

* CHECK dout0_6 Vdout0_6ck13 = 1.8 time = 280
.meas tran vdout0_6ck13 FIND v(dout0_6) AT=280.1n

* CHECK dout0_7 Vdout0_7ck13 = 1.8 time = 280
.meas tran vdout0_7ck13 FIND v(dout0_7) AT=280.1n

* CHECK dout0_8 Vdout0_8ck13 = 1.8 time = 280
.meas tran vdout0_8ck13 FIND v(dout0_8) AT=280.1n

* CHECK dout0_9 Vdout0_9ck13 = 0 time = 280
.meas tran vdout0_9ck13 FIND v(dout0_9) AT=280.1n

* CHECK dout0_10 Vdout0_10ck13 = 1.8 time = 280
.meas tran vdout0_10ck13 FIND v(dout0_10) AT=280.1n

* CHECK dout0_11 Vdout0_11ck13 = 0 time = 280
.meas tran vdout0_11ck13 FIND v(dout0_11) AT=280.1n

* CHECK dout0_12 Vdout0_12ck13 = 1.8 time = 280
.meas tran vdout0_12ck13 FIND v(dout0_12) AT=280.1n

* CHECK dout0_13 Vdout0_13ck13 = 1.8 time = 280
.meas tran vdout0_13ck13 FIND v(dout0_13) AT=280.1n

* CHECK dout0_14 Vdout0_14ck13 = 0 time = 280
.meas tran vdout0_14ck13 FIND v(dout0_14) AT=280.1n

* CHECK dout0_15 Vdout0_15ck13 = 0 time = 280
.meas tran vdout0_15ck13 FIND v(dout0_15) AT=280.1n

* CHECK dout0_0 Vdout0_0ck19 = 1.8 time = 400
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=400.1n

* CHECK dout0_1 Vdout0_1ck19 = 0 time = 400
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=400.1n

* CHECK dout0_2 Vdout0_2ck19 = 1.8 time = 400
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=400.1n

* CHECK dout0_3 Vdout0_3ck19 = 1.8 time = 400
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=400.1n

* CHECK dout0_4 Vdout0_4ck19 = 0 time = 400
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=400.1n

* CHECK dout0_5 Vdout0_5ck19 = 0 time = 400
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=400.1n

* CHECK dout0_6 Vdout0_6ck19 = 0 time = 400
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=400.1n

* CHECK dout0_7 Vdout0_7ck19 = 0 time = 400
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=400.1n

* CHECK dout0_8 Vdout0_8ck19 = 0 time = 400
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=400.1n

* CHECK dout0_9 Vdout0_9ck19 = 0 time = 400
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=400.1n

* CHECK dout0_10 Vdout0_10ck19 = 0 time = 400
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=400.1n

* CHECK dout0_11 Vdout0_11ck19 = 0 time = 400
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=400.1n

* CHECK dout0_12 Vdout0_12ck19 = 1.8 time = 400
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=400.1n

* CHECK dout0_13 Vdout0_13ck19 = 0 time = 400
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=400.1n

* CHECK dout0_14 Vdout0_14ck19 = 1.8 time = 400
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=400.1n

* CHECK dout0_15 Vdout0_15ck19 = 1.8 time = 400
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=400.1n

* CHECK dout0_0 Vdout0_0ck21 = 0 time = 440
.meas tran vdout0_0ck21 FIND v(dout0_0) AT=440.1n

* CHECK dout0_1 Vdout0_1ck21 = 1.8 time = 440
.meas tran vdout0_1ck21 FIND v(dout0_1) AT=440.1n

* CHECK dout0_2 Vdout0_2ck21 = 0 time = 440
.meas tran vdout0_2ck21 FIND v(dout0_2) AT=440.1n

* CHECK dout0_3 Vdout0_3ck21 = 1.8 time = 440
.meas tran vdout0_3ck21 FIND v(dout0_3) AT=440.1n

* CHECK dout0_4 Vdout0_4ck21 = 1.8 time = 440
.meas tran vdout0_4ck21 FIND v(dout0_4) AT=440.1n

* CHECK dout0_5 Vdout0_5ck21 = 0 time = 440
.meas tran vdout0_5ck21 FIND v(dout0_5) AT=440.1n

* CHECK dout0_6 Vdout0_6ck21 = 0 time = 440
.meas tran vdout0_6ck21 FIND v(dout0_6) AT=440.1n

* CHECK dout0_7 Vdout0_7ck21 = 0 time = 440
.meas tran vdout0_7ck21 FIND v(dout0_7) AT=440.1n

* CHECK dout0_8 Vdout0_8ck21 = 0 time = 440
.meas tran vdout0_8ck21 FIND v(dout0_8) AT=440.1n

* CHECK dout0_9 Vdout0_9ck21 = 1.8 time = 440
.meas tran vdout0_9ck21 FIND v(dout0_9) AT=440.1n

* CHECK dout0_10 Vdout0_10ck21 = 0 time = 440
.meas tran vdout0_10ck21 FIND v(dout0_10) AT=440.1n

* CHECK dout0_11 Vdout0_11ck21 = 0 time = 440
.meas tran vdout0_11ck21 FIND v(dout0_11) AT=440.1n

* CHECK dout0_12 Vdout0_12ck21 = 1.8 time = 440
.meas tran vdout0_12ck21 FIND v(dout0_12) AT=440.1n

* CHECK dout0_13 Vdout0_13ck21 = 0 time = 440
.meas tran vdout0_13ck21 FIND v(dout0_13) AT=440.1n

* CHECK dout0_14 Vdout0_14ck21 = 0 time = 440
.meas tran vdout0_14ck21 FIND v(dout0_14) AT=440.1n

* CHECK dout0_15 Vdout0_15ck21 = 1.8 time = 440
.meas tran vdout0_15ck21 FIND v(dout0_15) AT=440.1n

* CHECK dout0_0 Vdout0_0ck22 = 1.8 time = 460
.meas tran vdout0_0ck22 FIND v(dout0_0) AT=460.1n

* CHECK dout0_1 Vdout0_1ck22 = 0 time = 460
.meas tran vdout0_1ck22 FIND v(dout0_1) AT=460.1n

* CHECK dout0_2 Vdout0_2ck22 = 1.8 time = 460
.meas tran vdout0_2ck22 FIND v(dout0_2) AT=460.1n

* CHECK dout0_3 Vdout0_3ck22 = 1.8 time = 460
.meas tran vdout0_3ck22 FIND v(dout0_3) AT=460.1n

* CHECK dout0_4 Vdout0_4ck22 = 0 time = 460
.meas tran vdout0_4ck22 FIND v(dout0_4) AT=460.1n

* CHECK dout0_5 Vdout0_5ck22 = 0 time = 460
.meas tran vdout0_5ck22 FIND v(dout0_5) AT=460.1n

* CHECK dout0_6 Vdout0_6ck22 = 0 time = 460
.meas tran vdout0_6ck22 FIND v(dout0_6) AT=460.1n

* CHECK dout0_7 Vdout0_7ck22 = 0 time = 460
.meas tran vdout0_7ck22 FIND v(dout0_7) AT=460.1n

* CHECK dout0_8 Vdout0_8ck22 = 0 time = 460
.meas tran vdout0_8ck22 FIND v(dout0_8) AT=460.1n

* CHECK dout0_9 Vdout0_9ck22 = 0 time = 460
.meas tran vdout0_9ck22 FIND v(dout0_9) AT=460.1n

* CHECK dout0_10 Vdout0_10ck22 = 0 time = 460
.meas tran vdout0_10ck22 FIND v(dout0_10) AT=460.1n

* CHECK dout0_11 Vdout0_11ck22 = 0 time = 460
.meas tran vdout0_11ck22 FIND v(dout0_11) AT=460.1n

* CHECK dout0_12 Vdout0_12ck22 = 1.8 time = 460
.meas tran vdout0_12ck22 FIND v(dout0_12) AT=460.1n

* CHECK dout0_13 Vdout0_13ck22 = 0 time = 460
.meas tran vdout0_13ck22 FIND v(dout0_13) AT=460.1n

* CHECK dout0_14 Vdout0_14ck22 = 1.8 time = 460
.meas tran vdout0_14ck22 FIND v(dout0_14) AT=460.1n

* CHECK dout0_15 Vdout0_15ck22 = 1.8 time = 460
.meas tran vdout0_15ck22 FIND v(dout0_15) AT=460.1n

* CHECK dout0_0 Vdout0_0ck24 = 0 time = 500
.meas tran vdout0_0ck24 FIND v(dout0_0) AT=500.1n

* CHECK dout0_1 Vdout0_1ck24 = 1.8 time = 500
.meas tran vdout0_1ck24 FIND v(dout0_1) AT=500.1n

* CHECK dout0_2 Vdout0_2ck24 = 0 time = 500
.meas tran vdout0_2ck24 FIND v(dout0_2) AT=500.1n

* CHECK dout0_3 Vdout0_3ck24 = 1.8 time = 500
.meas tran vdout0_3ck24 FIND v(dout0_3) AT=500.1n

* CHECK dout0_4 Vdout0_4ck24 = 1.8 time = 500
.meas tran vdout0_4ck24 FIND v(dout0_4) AT=500.1n

* CHECK dout0_5 Vdout0_5ck24 = 0 time = 500
.meas tran vdout0_5ck24 FIND v(dout0_5) AT=500.1n

* CHECK dout0_6 Vdout0_6ck24 = 1.8 time = 500
.meas tran vdout0_6ck24 FIND v(dout0_6) AT=500.1n

* CHECK dout0_7 Vdout0_7ck24 = 0 time = 500
.meas tran vdout0_7ck24 FIND v(dout0_7) AT=500.1n

* CHECK dout0_8 Vdout0_8ck24 = 0 time = 500
.meas tran vdout0_8ck24 FIND v(dout0_8) AT=500.1n

* CHECK dout0_9 Vdout0_9ck24 = 0 time = 500
.meas tran vdout0_9ck24 FIND v(dout0_9) AT=500.1n

* CHECK dout0_10 Vdout0_10ck24 = 1.8 time = 500
.meas tran vdout0_10ck24 FIND v(dout0_10) AT=500.1n

* CHECK dout0_11 Vdout0_11ck24 = 0 time = 500
.meas tran vdout0_11ck24 FIND v(dout0_11) AT=500.1n

* CHECK dout0_12 Vdout0_12ck24 = 1.8 time = 500
.meas tran vdout0_12ck24 FIND v(dout0_12) AT=500.1n

* CHECK dout0_13 Vdout0_13ck24 = 0 time = 500
.meas tran vdout0_13ck24 FIND v(dout0_13) AT=500.1n

* CHECK dout0_14 Vdout0_14ck24 = 0 time = 500
.meas tran vdout0_14ck24 FIND v(dout0_14) AT=500.1n

* CHECK dout0_15 Vdout0_15ck24 = 0 time = 500
.meas tran vdout0_15ck24 FIND v(dout0_15) AT=500.1n

* CHECK dout0_0 Vdout0_0ck26 = 0 time = 540
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=540.1n

* CHECK dout0_1 Vdout0_1ck26 = 1.8 time = 540
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=540.1n

* CHECK dout0_2 Vdout0_2ck26 = 0 time = 540
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=540.1n

* CHECK dout0_3 Vdout0_3ck26 = 1.8 time = 540
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=540.1n

* CHECK dout0_4 Vdout0_4ck26 = 1.8 time = 540
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=540.1n

* CHECK dout0_5 Vdout0_5ck26 = 0 time = 540
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=540.1n

* CHECK dout0_6 Vdout0_6ck26 = 1.8 time = 540
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=540.1n

* CHECK dout0_7 Vdout0_7ck26 = 0 time = 540
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=540.1n

* CHECK dout0_8 Vdout0_8ck26 = 0 time = 540
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=540.1n

* CHECK dout0_9 Vdout0_9ck26 = 0 time = 540
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=540.1n

* CHECK dout0_10 Vdout0_10ck26 = 1.8 time = 540
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=540.1n

* CHECK dout0_11 Vdout0_11ck26 = 0 time = 540
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=540.1n

* CHECK dout0_12 Vdout0_12ck26 = 1.8 time = 540
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=540.1n

* CHECK dout0_13 Vdout0_13ck26 = 0 time = 540
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=540.1n

* CHECK dout0_14 Vdout0_14ck26 = 0 time = 540
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=540.1n

* CHECK dout0_15 Vdout0_15ck26 = 0 time = 540
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=540.1n

* CHECK dout0_0 Vdout0_0ck28 = 0 time = 580
.meas tran vdout0_0ck28 FIND v(dout0_0) AT=580.1n

* CHECK dout0_1 Vdout0_1ck28 = 1.8 time = 580
.meas tran vdout0_1ck28 FIND v(dout0_1) AT=580.1n

* CHECK dout0_2 Vdout0_2ck28 = 0 time = 580
.meas tran vdout0_2ck28 FIND v(dout0_2) AT=580.1n

* CHECK dout0_3 Vdout0_3ck28 = 1.8 time = 580
.meas tran vdout0_3ck28 FIND v(dout0_3) AT=580.1n

* CHECK dout0_4 Vdout0_4ck28 = 1.8 time = 580
.meas tran vdout0_4ck28 FIND v(dout0_4) AT=580.1n

* CHECK dout0_5 Vdout0_5ck28 = 0 time = 580
.meas tran vdout0_5ck28 FIND v(dout0_5) AT=580.1n

* CHECK dout0_6 Vdout0_6ck28 = 1.8 time = 580
.meas tran vdout0_6ck28 FIND v(dout0_6) AT=580.1n

* CHECK dout0_7 Vdout0_7ck28 = 0 time = 580
.meas tran vdout0_7ck28 FIND v(dout0_7) AT=580.1n

* CHECK dout0_8 Vdout0_8ck28 = 0 time = 580
.meas tran vdout0_8ck28 FIND v(dout0_8) AT=580.1n

* CHECK dout0_9 Vdout0_9ck28 = 0 time = 580
.meas tran vdout0_9ck28 FIND v(dout0_9) AT=580.1n

* CHECK dout0_10 Vdout0_10ck28 = 1.8 time = 580
.meas tran vdout0_10ck28 FIND v(dout0_10) AT=580.1n

* CHECK dout0_11 Vdout0_11ck28 = 0 time = 580
.meas tran vdout0_11ck28 FIND v(dout0_11) AT=580.1n

* CHECK dout0_12 Vdout0_12ck28 = 1.8 time = 580
.meas tran vdout0_12ck28 FIND v(dout0_12) AT=580.1n

* CHECK dout0_13 Vdout0_13ck28 = 0 time = 580
.meas tran vdout0_13ck28 FIND v(dout0_13) AT=580.1n

* CHECK dout0_14 Vdout0_14ck28 = 0 time = 580
.meas tran vdout0_14ck28 FIND v(dout0_14) AT=580.1n

* CHECK dout0_15 Vdout0_15ck28 = 0 time = 580
.meas tran vdout0_15ck28 FIND v(dout0_15) AT=580.1n

* CHECK dout0_0 Vdout0_0ck29 = 1.8 time = 600
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=600.1n

* CHECK dout0_1 Vdout0_1ck29 = 0 time = 600
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=600.1n

* CHECK dout0_2 Vdout0_2ck29 = 1.8 time = 600
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=600.1n

* CHECK dout0_3 Vdout0_3ck29 = 1.8 time = 600
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=600.1n

* CHECK dout0_4 Vdout0_4ck29 = 0 time = 600
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=600.1n

* CHECK dout0_5 Vdout0_5ck29 = 0 time = 600
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=600.1n

* CHECK dout0_6 Vdout0_6ck29 = 0 time = 600
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=600.1n

* CHECK dout0_7 Vdout0_7ck29 = 0 time = 600
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=600.1n

* CHECK dout0_8 Vdout0_8ck29 = 0 time = 600
.meas tran vdout0_8ck29 FIND v(dout0_8) AT=600.1n

* CHECK dout0_9 Vdout0_9ck29 = 0 time = 600
.meas tran vdout0_9ck29 FIND v(dout0_9) AT=600.1n

* CHECK dout0_10 Vdout0_10ck29 = 0 time = 600
.meas tran vdout0_10ck29 FIND v(dout0_10) AT=600.1n

* CHECK dout0_11 Vdout0_11ck29 = 0 time = 600
.meas tran vdout0_11ck29 FIND v(dout0_11) AT=600.1n

* CHECK dout0_12 Vdout0_12ck29 = 1.8 time = 600
.meas tran vdout0_12ck29 FIND v(dout0_12) AT=600.1n

* CHECK dout0_13 Vdout0_13ck29 = 0 time = 600
.meas tran vdout0_13ck29 FIND v(dout0_13) AT=600.1n

* CHECK dout0_14 Vdout0_14ck29 = 1.8 time = 600
.meas tran vdout0_14ck29 FIND v(dout0_14) AT=600.1n

* CHECK dout0_15 Vdout0_15ck29 = 1.8 time = 600
.meas tran vdout0_15ck29 FIND v(dout0_15) AT=600.1n

* CHECK dout0_0 Vdout0_0ck32 = 0 time = 660
.meas tran vdout0_0ck32 FIND v(dout0_0) AT=660.1n

* CHECK dout0_1 Vdout0_1ck32 = 1.8 time = 660
.meas tran vdout0_1ck32 FIND v(dout0_1) AT=660.1n

* CHECK dout0_2 Vdout0_2ck32 = 0 time = 660
.meas tran vdout0_2ck32 FIND v(dout0_2) AT=660.1n

* CHECK dout0_3 Vdout0_3ck32 = 1.8 time = 660
.meas tran vdout0_3ck32 FIND v(dout0_3) AT=660.1n

* CHECK dout0_4 Vdout0_4ck32 = 1.8 time = 660
.meas tran vdout0_4ck32 FIND v(dout0_4) AT=660.1n

* CHECK dout0_5 Vdout0_5ck32 = 0 time = 660
.meas tran vdout0_5ck32 FIND v(dout0_5) AT=660.1n

* CHECK dout0_6 Vdout0_6ck32 = 1.8 time = 660
.meas tran vdout0_6ck32 FIND v(dout0_6) AT=660.1n

* CHECK dout0_7 Vdout0_7ck32 = 0 time = 660
.meas tran vdout0_7ck32 FIND v(dout0_7) AT=660.1n

* CHECK dout0_8 Vdout0_8ck32 = 0 time = 660
.meas tran vdout0_8ck32 FIND v(dout0_8) AT=660.1n

* CHECK dout0_9 Vdout0_9ck32 = 0 time = 660
.meas tran vdout0_9ck32 FIND v(dout0_9) AT=660.1n

* CHECK dout0_10 Vdout0_10ck32 = 1.8 time = 660
.meas tran vdout0_10ck32 FIND v(dout0_10) AT=660.1n

* CHECK dout0_11 Vdout0_11ck32 = 0 time = 660
.meas tran vdout0_11ck32 FIND v(dout0_11) AT=660.1n

* CHECK dout0_12 Vdout0_12ck32 = 1.8 time = 660
.meas tran vdout0_12ck32 FIND v(dout0_12) AT=660.1n

* CHECK dout0_13 Vdout0_13ck32 = 0 time = 660
.meas tran vdout0_13ck32 FIND v(dout0_13) AT=660.1n

* CHECK dout0_14 Vdout0_14ck32 = 0 time = 660
.meas tran vdout0_14ck32 FIND v(dout0_14) AT=660.1n

* CHECK dout0_15 Vdout0_15ck32 = 0 time = 660
.meas tran vdout0_15ck32 FIND v(dout0_15) AT=660.1n

* CHECK dout0_0 Vdout0_0ck33 = 0 time = 680
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=680.1n

* CHECK dout0_1 Vdout0_1ck33 = 1.8 time = 680
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=680.1n

* CHECK dout0_2 Vdout0_2ck33 = 0 time = 680
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=680.1n

* CHECK dout0_3 Vdout0_3ck33 = 1.8 time = 680
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=680.1n

* CHECK dout0_4 Vdout0_4ck33 = 1.8 time = 680
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=680.1n

* CHECK dout0_5 Vdout0_5ck33 = 0 time = 680
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=680.1n

* CHECK dout0_6 Vdout0_6ck33 = 1.8 time = 680
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=680.1n

* CHECK dout0_7 Vdout0_7ck33 = 0 time = 680
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=680.1n

* CHECK dout0_8 Vdout0_8ck33 = 0 time = 680
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=680.1n

* CHECK dout0_9 Vdout0_9ck33 = 0 time = 680
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=680.1n

* CHECK dout0_10 Vdout0_10ck33 = 1.8 time = 680
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=680.1n

* CHECK dout0_11 Vdout0_11ck33 = 0 time = 680
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=680.1n

* CHECK dout0_12 Vdout0_12ck33 = 1.8 time = 680
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=680.1n

* CHECK dout0_13 Vdout0_13ck33 = 0 time = 680
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=680.1n

* CHECK dout0_14 Vdout0_14ck33 = 0 time = 680
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=680.1n

* CHECK dout0_15 Vdout0_15ck33 = 0 time = 680
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=680.1n

* CHECK dout0_0 Vdout0_0ck34 = 0 time = 700
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=700.1n

* CHECK dout0_1 Vdout0_1ck34 = 1.8 time = 700
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=700.1n

* CHECK dout0_2 Vdout0_2ck34 = 0 time = 700
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=700.1n

* CHECK dout0_3 Vdout0_3ck34 = 1.8 time = 700
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=700.1n

* CHECK dout0_4 Vdout0_4ck34 = 1.8 time = 700
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=700.1n

* CHECK dout0_5 Vdout0_5ck34 = 0 time = 700
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=700.1n

* CHECK dout0_6 Vdout0_6ck34 = 1.8 time = 700
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=700.1n

* CHECK dout0_7 Vdout0_7ck34 = 0 time = 700
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=700.1n

* CHECK dout0_8 Vdout0_8ck34 = 0 time = 700
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=700.1n

* CHECK dout0_9 Vdout0_9ck34 = 0 time = 700
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=700.1n

* CHECK dout0_10 Vdout0_10ck34 = 1.8 time = 700
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=700.1n

* CHECK dout0_11 Vdout0_11ck34 = 0 time = 700
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=700.1n

* CHECK dout0_12 Vdout0_12ck34 = 1.8 time = 700
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=700.1n

* CHECK dout0_13 Vdout0_13ck34 = 0 time = 700
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=700.1n

* CHECK dout0_14 Vdout0_14ck34 = 0 time = 700
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=700.1n

* CHECK dout0_15 Vdout0_15ck34 = 0 time = 700
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=700.1n

* CHECK dout0_0 Vdout0_0ck37 = 0 time = 760
.meas tran vdout0_0ck37 FIND v(dout0_0) AT=760.1n

* CHECK dout0_1 Vdout0_1ck37 = 1.8 time = 760
.meas tran vdout0_1ck37 FIND v(dout0_1) AT=760.1n

* CHECK dout0_2 Vdout0_2ck37 = 0 time = 760
.meas tran vdout0_2ck37 FIND v(dout0_2) AT=760.1n

* CHECK dout0_3 Vdout0_3ck37 = 1.8 time = 760
.meas tran vdout0_3ck37 FIND v(dout0_3) AT=760.1n

* CHECK dout0_4 Vdout0_4ck37 = 1.8 time = 760
.meas tran vdout0_4ck37 FIND v(dout0_4) AT=760.1n

* CHECK dout0_5 Vdout0_5ck37 = 0 time = 760
.meas tran vdout0_5ck37 FIND v(dout0_5) AT=760.1n

* CHECK dout0_6 Vdout0_6ck37 = 1.8 time = 760
.meas tran vdout0_6ck37 FIND v(dout0_6) AT=760.1n

* CHECK dout0_7 Vdout0_7ck37 = 0 time = 760
.meas tran vdout0_7ck37 FIND v(dout0_7) AT=760.1n

* CHECK dout0_8 Vdout0_8ck37 = 0 time = 760
.meas tran vdout0_8ck37 FIND v(dout0_8) AT=760.1n

* CHECK dout0_9 Vdout0_9ck37 = 0 time = 760
.meas tran vdout0_9ck37 FIND v(dout0_9) AT=760.1n

* CHECK dout0_10 Vdout0_10ck37 = 1.8 time = 760
.meas tran vdout0_10ck37 FIND v(dout0_10) AT=760.1n

* CHECK dout0_11 Vdout0_11ck37 = 0 time = 760
.meas tran vdout0_11ck37 FIND v(dout0_11) AT=760.1n

* CHECK dout0_12 Vdout0_12ck37 = 1.8 time = 760
.meas tran vdout0_12ck37 FIND v(dout0_12) AT=760.1n

* CHECK dout0_13 Vdout0_13ck37 = 0 time = 760
.meas tran vdout0_13ck37 FIND v(dout0_13) AT=760.1n

* CHECK dout0_14 Vdout0_14ck37 = 0 time = 760
.meas tran vdout0_14ck37 FIND v(dout0_14) AT=760.1n

* CHECK dout0_15 Vdout0_15ck37 = 0 time = 760
.meas tran vdout0_15ck37 FIND v(dout0_15) AT=760.1n

* CHECK dout0_0 Vdout0_0ck40 = 0 time = 820
.meas tran vdout0_0ck40 FIND v(dout0_0) AT=820.1n

* CHECK dout0_1 Vdout0_1ck40 = 1.8 time = 820
.meas tran vdout0_1ck40 FIND v(dout0_1) AT=820.1n

* CHECK dout0_2 Vdout0_2ck40 = 0 time = 820
.meas tran vdout0_2ck40 FIND v(dout0_2) AT=820.1n

* CHECK dout0_3 Vdout0_3ck40 = 1.8 time = 820
.meas tran vdout0_3ck40 FIND v(dout0_3) AT=820.1n

* CHECK dout0_4 Vdout0_4ck40 = 1.8 time = 820
.meas tran vdout0_4ck40 FIND v(dout0_4) AT=820.1n

* CHECK dout0_5 Vdout0_5ck40 = 0 time = 820
.meas tran vdout0_5ck40 FIND v(dout0_5) AT=820.1n

* CHECK dout0_6 Vdout0_6ck40 = 1.8 time = 820
.meas tran vdout0_6ck40 FIND v(dout0_6) AT=820.1n

* CHECK dout0_7 Vdout0_7ck40 = 0 time = 820
.meas tran vdout0_7ck40 FIND v(dout0_7) AT=820.1n

* CHECK dout0_8 Vdout0_8ck40 = 0 time = 820
.meas tran vdout0_8ck40 FIND v(dout0_8) AT=820.1n

* CHECK dout0_9 Vdout0_9ck40 = 0 time = 820
.meas tran vdout0_9ck40 FIND v(dout0_9) AT=820.1n

* CHECK dout0_10 Vdout0_10ck40 = 1.8 time = 820
.meas tran vdout0_10ck40 FIND v(dout0_10) AT=820.1n

* CHECK dout0_11 Vdout0_11ck40 = 0 time = 820
.meas tran vdout0_11ck40 FIND v(dout0_11) AT=820.1n

* CHECK dout0_12 Vdout0_12ck40 = 1.8 time = 820
.meas tran vdout0_12ck40 FIND v(dout0_12) AT=820.1n

* CHECK dout0_13 Vdout0_13ck40 = 0 time = 820
.meas tran vdout0_13ck40 FIND v(dout0_13) AT=820.1n

* CHECK dout0_14 Vdout0_14ck40 = 0 time = 820
.meas tran vdout0_14ck40 FIND v(dout0_14) AT=820.1n

* CHECK dout0_15 Vdout0_15ck40 = 0 time = 820
.meas tran vdout0_15ck40 FIND v(dout0_15) AT=820.1n

* CHECK dout0_0 Vdout0_0ck42 = 0 time = 860
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=860.1n

* CHECK dout0_1 Vdout0_1ck42 = 1.8 time = 860
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=860.1n

* CHECK dout0_2 Vdout0_2ck42 = 0 time = 860
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=860.1n

* CHECK dout0_3 Vdout0_3ck42 = 1.8 time = 860
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=860.1n

* CHECK dout0_4 Vdout0_4ck42 = 1.8 time = 860
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=860.1n

* CHECK dout0_5 Vdout0_5ck42 = 0 time = 860
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=860.1n

* CHECK dout0_6 Vdout0_6ck42 = 0 time = 860
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=860.1n

* CHECK dout0_7 Vdout0_7ck42 = 0 time = 860
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=860.1n

* CHECK dout0_8 Vdout0_8ck42 = 0 time = 860
.meas tran vdout0_8ck42 FIND v(dout0_8) AT=860.1n

* CHECK dout0_9 Vdout0_9ck42 = 1.8 time = 860
.meas tran vdout0_9ck42 FIND v(dout0_9) AT=860.1n

* CHECK dout0_10 Vdout0_10ck42 = 0 time = 860
.meas tran vdout0_10ck42 FIND v(dout0_10) AT=860.1n

* CHECK dout0_11 Vdout0_11ck42 = 0 time = 860
.meas tran vdout0_11ck42 FIND v(dout0_11) AT=860.1n

* CHECK dout0_12 Vdout0_12ck42 = 1.8 time = 860
.meas tran vdout0_12ck42 FIND v(dout0_12) AT=860.1n

* CHECK dout0_13 Vdout0_13ck42 = 0 time = 860
.meas tran vdout0_13ck42 FIND v(dout0_13) AT=860.1n

* CHECK dout0_14 Vdout0_14ck42 = 0 time = 860
.meas tran vdout0_14ck42 FIND v(dout0_14) AT=860.1n

* CHECK dout0_15 Vdout0_15ck42 = 1.8 time = 860
.meas tran vdout0_15ck42 FIND v(dout0_15) AT=860.1n

* CHECK dout0_0 Vdout0_0ck44 = 0 time = 900
.meas tran vdout0_0ck44 FIND v(dout0_0) AT=900.1n

* CHECK dout0_1 Vdout0_1ck44 = 1.8 time = 900
.meas tran vdout0_1ck44 FIND v(dout0_1) AT=900.1n

* CHECK dout0_2 Vdout0_2ck44 = 0 time = 900
.meas tran vdout0_2ck44 FIND v(dout0_2) AT=900.1n

* CHECK dout0_3 Vdout0_3ck44 = 1.8 time = 900
.meas tran vdout0_3ck44 FIND v(dout0_3) AT=900.1n

* CHECK dout0_4 Vdout0_4ck44 = 1.8 time = 900
.meas tran vdout0_4ck44 FIND v(dout0_4) AT=900.1n

* CHECK dout0_5 Vdout0_5ck44 = 0 time = 900
.meas tran vdout0_5ck44 FIND v(dout0_5) AT=900.1n

* CHECK dout0_6 Vdout0_6ck44 = 1.8 time = 900
.meas tran vdout0_6ck44 FIND v(dout0_6) AT=900.1n

* CHECK dout0_7 Vdout0_7ck44 = 0 time = 900
.meas tran vdout0_7ck44 FIND v(dout0_7) AT=900.1n

* CHECK dout0_8 Vdout0_8ck44 = 0 time = 900
.meas tran vdout0_8ck44 FIND v(dout0_8) AT=900.1n

* CHECK dout0_9 Vdout0_9ck44 = 0 time = 900
.meas tran vdout0_9ck44 FIND v(dout0_9) AT=900.1n

* CHECK dout0_10 Vdout0_10ck44 = 1.8 time = 900
.meas tran vdout0_10ck44 FIND v(dout0_10) AT=900.1n

* CHECK dout0_11 Vdout0_11ck44 = 0 time = 900
.meas tran vdout0_11ck44 FIND v(dout0_11) AT=900.1n

* CHECK dout0_12 Vdout0_12ck44 = 1.8 time = 900
.meas tran vdout0_12ck44 FIND v(dout0_12) AT=900.1n

* CHECK dout0_13 Vdout0_13ck44 = 0 time = 900
.meas tran vdout0_13ck44 FIND v(dout0_13) AT=900.1n

* CHECK dout0_14 Vdout0_14ck44 = 0 time = 900
.meas tran vdout0_14ck44 FIND v(dout0_14) AT=900.1n

* CHECK dout0_15 Vdout0_15ck44 = 0 time = 900
.meas tran vdout0_15ck44 FIND v(dout0_15) AT=900.1n

* CHECK dout0_0 Vdout0_0ck46 = 0 time = 940
.meas tran vdout0_0ck46 FIND v(dout0_0) AT=940.1n

* CHECK dout0_1 Vdout0_1ck46 = 0 time = 940
.meas tran vdout0_1ck46 FIND v(dout0_1) AT=940.1n

* CHECK dout0_2 Vdout0_2ck46 = 0 time = 940
.meas tran vdout0_2ck46 FIND v(dout0_2) AT=940.1n

* CHECK dout0_3 Vdout0_3ck46 = 0 time = 940
.meas tran vdout0_3ck46 FIND v(dout0_3) AT=940.1n

* CHECK dout0_4 Vdout0_4ck46 = 0 time = 940
.meas tran vdout0_4ck46 FIND v(dout0_4) AT=940.1n

* CHECK dout0_5 Vdout0_5ck46 = 0 time = 940
.meas tran vdout0_5ck46 FIND v(dout0_5) AT=940.1n

* CHECK dout0_6 Vdout0_6ck46 = 1.8 time = 940
.meas tran vdout0_6ck46 FIND v(dout0_6) AT=940.1n

* CHECK dout0_7 Vdout0_7ck46 = 1.8 time = 940
.meas tran vdout0_7ck46 FIND v(dout0_7) AT=940.1n

* CHECK dout0_8 Vdout0_8ck46 = 1.8 time = 940
.meas tran vdout0_8ck46 FIND v(dout0_8) AT=940.1n

* CHECK dout0_9 Vdout0_9ck46 = 1.8 time = 940
.meas tran vdout0_9ck46 FIND v(dout0_9) AT=940.1n

* CHECK dout0_10 Vdout0_10ck46 = 1.8 time = 940
.meas tran vdout0_10ck46 FIND v(dout0_10) AT=940.1n

* CHECK dout0_11 Vdout0_11ck46 = 1.8 time = 940
.meas tran vdout0_11ck46 FIND v(dout0_11) AT=940.1n

* CHECK dout0_12 Vdout0_12ck46 = 1.8 time = 940
.meas tran vdout0_12ck46 FIND v(dout0_12) AT=940.1n

* CHECK dout0_13 Vdout0_13ck46 = 1.8 time = 940
.meas tran vdout0_13ck46 FIND v(dout0_13) AT=940.1n

* CHECK dout0_14 Vdout0_14ck46 = 0 time = 940
.meas tran vdout0_14ck46 FIND v(dout0_14) AT=940.1n

* CHECK dout0_15 Vdout0_15ck46 = 0 time = 940
.meas tran vdout0_15ck46 FIND v(dout0_15) AT=940.1n

* CHECK dout0_0 Vdout0_0ck48 = 1.8 time = 980
.meas tran vdout0_0ck48 FIND v(dout0_0) AT=980.1n

* CHECK dout0_1 Vdout0_1ck48 = 1.8 time = 980
.meas tran vdout0_1ck48 FIND v(dout0_1) AT=980.1n

* CHECK dout0_2 Vdout0_2ck48 = 0 time = 980
.meas tran vdout0_2ck48 FIND v(dout0_2) AT=980.1n

* CHECK dout0_3 Vdout0_3ck48 = 1.8 time = 980
.meas tran vdout0_3ck48 FIND v(dout0_3) AT=980.1n

* CHECK dout0_4 Vdout0_4ck48 = 0 time = 980
.meas tran vdout0_4ck48 FIND v(dout0_4) AT=980.1n

* CHECK dout0_5 Vdout0_5ck48 = 0 time = 980
.meas tran vdout0_5ck48 FIND v(dout0_5) AT=980.1n

* CHECK dout0_6 Vdout0_6ck48 = 0 time = 980
.meas tran vdout0_6ck48 FIND v(dout0_6) AT=980.1n

* CHECK dout0_7 Vdout0_7ck48 = 0 time = 980
.meas tran vdout0_7ck48 FIND v(dout0_7) AT=980.1n

* CHECK dout0_8 Vdout0_8ck48 = 1.8 time = 980
.meas tran vdout0_8ck48 FIND v(dout0_8) AT=980.1n

* CHECK dout0_9 Vdout0_9ck48 = 0 time = 980
.meas tran vdout0_9ck48 FIND v(dout0_9) AT=980.1n

* CHECK dout0_10 Vdout0_10ck48 = 0 time = 980
.meas tran vdout0_10ck48 FIND v(dout0_10) AT=980.1n

* CHECK dout0_11 Vdout0_11ck48 = 1.8 time = 980
.meas tran vdout0_11ck48 FIND v(dout0_11) AT=980.1n

* CHECK dout0_12 Vdout0_12ck48 = 1.8 time = 980
.meas tran vdout0_12ck48 FIND v(dout0_12) AT=980.1n

* CHECK dout0_13 Vdout0_13ck48 = 0 time = 980
.meas tran vdout0_13ck48 FIND v(dout0_13) AT=980.1n

* CHECK dout0_14 Vdout0_14ck48 = 1.8 time = 980
.meas tran vdout0_14ck48 FIND v(dout0_14) AT=980.1n

* CHECK dout0_15 Vdout0_15ck48 = 0 time = 980
.meas tran vdout0_15ck48 FIND v(dout0_15) AT=980.1n

* CHECK dout0_0 Vdout0_0ck49 = 0 time = 1000
.meas tran vdout0_0ck49 FIND v(dout0_0) AT=1000.1n

* CHECK dout0_1 Vdout0_1ck49 = 1.8 time = 1000
.meas tran vdout0_1ck49 FIND v(dout0_1) AT=1000.1n

* CHECK dout0_2 Vdout0_2ck49 = 0 time = 1000
.meas tran vdout0_2ck49 FIND v(dout0_2) AT=1000.1n

* CHECK dout0_3 Vdout0_3ck49 = 1.8 time = 1000
.meas tran vdout0_3ck49 FIND v(dout0_3) AT=1000.1n

* CHECK dout0_4 Vdout0_4ck49 = 1.8 time = 1000
.meas tran vdout0_4ck49 FIND v(dout0_4) AT=1000.1n

* CHECK dout0_5 Vdout0_5ck49 = 0 time = 1000
.meas tran vdout0_5ck49 FIND v(dout0_5) AT=1000.1n

* CHECK dout0_6 Vdout0_6ck49 = 0 time = 1000
.meas tran vdout0_6ck49 FIND v(dout0_6) AT=1000.1n

* CHECK dout0_7 Vdout0_7ck49 = 0 time = 1000
.meas tran vdout0_7ck49 FIND v(dout0_7) AT=1000.1n

* CHECK dout0_8 Vdout0_8ck49 = 0 time = 1000
.meas tran vdout0_8ck49 FIND v(dout0_8) AT=1000.1n

* CHECK dout0_9 Vdout0_9ck49 = 1.8 time = 1000
.meas tran vdout0_9ck49 FIND v(dout0_9) AT=1000.1n

* CHECK dout0_10 Vdout0_10ck49 = 0 time = 1000
.meas tran vdout0_10ck49 FIND v(dout0_10) AT=1000.1n

* CHECK dout0_11 Vdout0_11ck49 = 0 time = 1000
.meas tran vdout0_11ck49 FIND v(dout0_11) AT=1000.1n

* CHECK dout0_12 Vdout0_12ck49 = 1.8 time = 1000
.meas tran vdout0_12ck49 FIND v(dout0_12) AT=1000.1n

* CHECK dout0_13 Vdout0_13ck49 = 0 time = 1000
.meas tran vdout0_13ck49 FIND v(dout0_13) AT=1000.1n

* CHECK dout0_14 Vdout0_14ck49 = 0 time = 1000
.meas tran vdout0_14ck49 FIND v(dout0_14) AT=1000.1n

* CHECK dout0_15 Vdout0_15ck49 = 1.8 time = 1000
.meas tran vdout0_15ck49 FIND v(dout0_15) AT=1000.1n

* CHECK dout0_0 Vdout0_0ck52 = 0 time = 1060
.meas tran vdout0_0ck52 FIND v(dout0_0) AT=1060.1n

* CHECK dout0_1 Vdout0_1ck52 = 0 time = 1060
.meas tran vdout0_1ck52 FIND v(dout0_1) AT=1060.1n

* CHECK dout0_2 Vdout0_2ck52 = 0 time = 1060
.meas tran vdout0_2ck52 FIND v(dout0_2) AT=1060.1n

* CHECK dout0_3 Vdout0_3ck52 = 1.8 time = 1060
.meas tran vdout0_3ck52 FIND v(dout0_3) AT=1060.1n

* CHECK dout0_4 Vdout0_4ck52 = 1.8 time = 1060
.meas tran vdout0_4ck52 FIND v(dout0_4) AT=1060.1n

* CHECK dout0_5 Vdout0_5ck52 = 1.8 time = 1060
.meas tran vdout0_5ck52 FIND v(dout0_5) AT=1060.1n

* CHECK dout0_6 Vdout0_6ck52 = 0 time = 1060
.meas tran vdout0_6ck52 FIND v(dout0_6) AT=1060.1n

* CHECK dout0_7 Vdout0_7ck52 = 0 time = 1060
.meas tran vdout0_7ck52 FIND v(dout0_7) AT=1060.1n

* CHECK dout0_8 Vdout0_8ck52 = 0 time = 1060
.meas tran vdout0_8ck52 FIND v(dout0_8) AT=1060.1n

* CHECK dout0_9 Vdout0_9ck52 = 1.8 time = 1060
.meas tran vdout0_9ck52 FIND v(dout0_9) AT=1060.1n

* CHECK dout0_10 Vdout0_10ck52 = 0 time = 1060
.meas tran vdout0_10ck52 FIND v(dout0_10) AT=1060.1n

* CHECK dout0_11 Vdout0_11ck52 = 0 time = 1060
.meas tran vdout0_11ck52 FIND v(dout0_11) AT=1060.1n

* CHECK dout0_12 Vdout0_12ck52 = 0 time = 1060
.meas tran vdout0_12ck52 FIND v(dout0_12) AT=1060.1n

* CHECK dout0_13 Vdout0_13ck52 = 0 time = 1060
.meas tran vdout0_13ck52 FIND v(dout0_13) AT=1060.1n

* CHECK dout0_14 Vdout0_14ck52 = 1.8 time = 1060
.meas tran vdout0_14ck52 FIND v(dout0_14) AT=1060.1n

* CHECK dout0_15 Vdout0_15ck52 = 0 time = 1060
.meas tran vdout0_15ck52 FIND v(dout0_15) AT=1060.1n

* CHECK dout0_0 Vdout0_0ck53 = 0 time = 1080
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=1080.1n

* CHECK dout0_1 Vdout0_1ck53 = 1.8 time = 1080
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=1080.1n

* CHECK dout0_2 Vdout0_2ck53 = 0 time = 1080
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=1080.1n

* CHECK dout0_3 Vdout0_3ck53 = 1.8 time = 1080
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=1080.1n

* CHECK dout0_4 Vdout0_4ck53 = 1.8 time = 1080
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=1080.1n

* CHECK dout0_5 Vdout0_5ck53 = 0 time = 1080
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=1080.1n

* CHECK dout0_6 Vdout0_6ck53 = 0 time = 1080
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=1080.1n

* CHECK dout0_7 Vdout0_7ck53 = 0 time = 1080
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=1080.1n

* CHECK dout0_8 Vdout0_8ck53 = 0 time = 1080
.meas tran vdout0_8ck53 FIND v(dout0_8) AT=1080.1n

* CHECK dout0_9 Vdout0_9ck53 = 1.8 time = 1080
.meas tran vdout0_9ck53 FIND v(dout0_9) AT=1080.1n

* CHECK dout0_10 Vdout0_10ck53 = 0 time = 1080
.meas tran vdout0_10ck53 FIND v(dout0_10) AT=1080.1n

* CHECK dout0_11 Vdout0_11ck53 = 0 time = 1080
.meas tran vdout0_11ck53 FIND v(dout0_11) AT=1080.1n

* CHECK dout0_12 Vdout0_12ck53 = 1.8 time = 1080
.meas tran vdout0_12ck53 FIND v(dout0_12) AT=1080.1n

* CHECK dout0_13 Vdout0_13ck53 = 0 time = 1080
.meas tran vdout0_13ck53 FIND v(dout0_13) AT=1080.1n

* CHECK dout0_14 Vdout0_14ck53 = 0 time = 1080
.meas tran vdout0_14ck53 FIND v(dout0_14) AT=1080.1n

* CHECK dout0_15 Vdout0_15ck53 = 1.8 time = 1080
.meas tran vdout0_15ck53 FIND v(dout0_15) AT=1080.1n

* CHECK dout0_0 Vdout0_0ck54 = 0 time = 1100
.meas tran vdout0_0ck54 FIND v(dout0_0) AT=1100.1n

* CHECK dout0_1 Vdout0_1ck54 = 0 time = 1100
.meas tran vdout0_1ck54 FIND v(dout0_1) AT=1100.1n

* CHECK dout0_2 Vdout0_2ck54 = 0 time = 1100
.meas tran vdout0_2ck54 FIND v(dout0_2) AT=1100.1n

* CHECK dout0_3 Vdout0_3ck54 = 1.8 time = 1100
.meas tran vdout0_3ck54 FIND v(dout0_3) AT=1100.1n

* CHECK dout0_4 Vdout0_4ck54 = 1.8 time = 1100
.meas tran vdout0_4ck54 FIND v(dout0_4) AT=1100.1n

* CHECK dout0_5 Vdout0_5ck54 = 1.8 time = 1100
.meas tran vdout0_5ck54 FIND v(dout0_5) AT=1100.1n

* CHECK dout0_6 Vdout0_6ck54 = 0 time = 1100
.meas tran vdout0_6ck54 FIND v(dout0_6) AT=1100.1n

* CHECK dout0_7 Vdout0_7ck54 = 0 time = 1100
.meas tran vdout0_7ck54 FIND v(dout0_7) AT=1100.1n

* CHECK dout0_8 Vdout0_8ck54 = 0 time = 1100
.meas tran vdout0_8ck54 FIND v(dout0_8) AT=1100.1n

* CHECK dout0_9 Vdout0_9ck54 = 1.8 time = 1100
.meas tran vdout0_9ck54 FIND v(dout0_9) AT=1100.1n

* CHECK dout0_10 Vdout0_10ck54 = 0 time = 1100
.meas tran vdout0_10ck54 FIND v(dout0_10) AT=1100.1n

* CHECK dout0_11 Vdout0_11ck54 = 0 time = 1100
.meas tran vdout0_11ck54 FIND v(dout0_11) AT=1100.1n

* CHECK dout0_12 Vdout0_12ck54 = 0 time = 1100
.meas tran vdout0_12ck54 FIND v(dout0_12) AT=1100.1n

* CHECK dout0_13 Vdout0_13ck54 = 0 time = 1100
.meas tran vdout0_13ck54 FIND v(dout0_13) AT=1100.1n

* CHECK dout0_14 Vdout0_14ck54 = 1.8 time = 1100
.meas tran vdout0_14ck54 FIND v(dout0_14) AT=1100.1n

* CHECK dout0_15 Vdout0_15ck54 = 0 time = 1100
.meas tran vdout0_15ck54 FIND v(dout0_15) AT=1100.1n

* CHECK dout0_0 Vdout0_0ck55 = 0 time = 1120
.meas tran vdout0_0ck55 FIND v(dout0_0) AT=1120.1n

* CHECK dout0_1 Vdout0_1ck55 = 1.8 time = 1120
.meas tran vdout0_1ck55 FIND v(dout0_1) AT=1120.1n

* CHECK dout0_2 Vdout0_2ck55 = 1.8 time = 1120
.meas tran vdout0_2ck55 FIND v(dout0_2) AT=1120.1n

* CHECK dout0_3 Vdout0_3ck55 = 0 time = 1120
.meas tran vdout0_3ck55 FIND v(dout0_3) AT=1120.1n

* CHECK dout0_4 Vdout0_4ck55 = 0 time = 1120
.meas tran vdout0_4ck55 FIND v(dout0_4) AT=1120.1n

* CHECK dout0_5 Vdout0_5ck55 = 0 time = 1120
.meas tran vdout0_5ck55 FIND v(dout0_5) AT=1120.1n

* CHECK dout0_6 Vdout0_6ck55 = 0 time = 1120
.meas tran vdout0_6ck55 FIND v(dout0_6) AT=1120.1n

* CHECK dout0_7 Vdout0_7ck55 = 1.8 time = 1120
.meas tran vdout0_7ck55 FIND v(dout0_7) AT=1120.1n

* CHECK dout0_8 Vdout0_8ck55 = 0 time = 1120
.meas tran vdout0_8ck55 FIND v(dout0_8) AT=1120.1n

* CHECK dout0_9 Vdout0_9ck55 = 0 time = 1120
.meas tran vdout0_9ck55 FIND v(dout0_9) AT=1120.1n

* CHECK dout0_10 Vdout0_10ck55 = 0 time = 1120
.meas tran vdout0_10ck55 FIND v(dout0_10) AT=1120.1n

* CHECK dout0_11 Vdout0_11ck55 = 1.8 time = 1120
.meas tran vdout0_11ck55 FIND v(dout0_11) AT=1120.1n

* CHECK dout0_12 Vdout0_12ck55 = 0 time = 1120
.meas tran vdout0_12ck55 FIND v(dout0_12) AT=1120.1n

* CHECK dout0_13 Vdout0_13ck55 = 1.8 time = 1120
.meas tran vdout0_13ck55 FIND v(dout0_13) AT=1120.1n

* CHECK dout0_14 Vdout0_14ck55 = 1.8 time = 1120
.meas tran vdout0_14ck55 FIND v(dout0_14) AT=1120.1n

* CHECK dout0_15 Vdout0_15ck55 = 0 time = 1120
.meas tran vdout0_15ck55 FIND v(dout0_15) AT=1120.1n

* CHECK dout0_0 Vdout0_0ck59 = 1.8 time = 1200
.meas tran vdout0_0ck59 FIND v(dout0_0) AT=1200.1n

* CHECK dout0_1 Vdout0_1ck59 = 1.8 time = 1200
.meas tran vdout0_1ck59 FIND v(dout0_1) AT=1200.1n

* CHECK dout0_2 Vdout0_2ck59 = 0 time = 1200
.meas tran vdout0_2ck59 FIND v(dout0_2) AT=1200.1n

* CHECK dout0_3 Vdout0_3ck59 = 0 time = 1200
.meas tran vdout0_3ck59 FIND v(dout0_3) AT=1200.1n

* CHECK dout0_4 Vdout0_4ck59 = 1.8 time = 1200
.meas tran vdout0_4ck59 FIND v(dout0_4) AT=1200.1n

* CHECK dout0_5 Vdout0_5ck59 = 0 time = 1200
.meas tran vdout0_5ck59 FIND v(dout0_5) AT=1200.1n

* CHECK dout0_6 Vdout0_6ck59 = 1.8 time = 1200
.meas tran vdout0_6ck59 FIND v(dout0_6) AT=1200.1n

* CHECK dout0_7 Vdout0_7ck59 = 1.8 time = 1200
.meas tran vdout0_7ck59 FIND v(dout0_7) AT=1200.1n

* CHECK dout0_8 Vdout0_8ck59 = 0 time = 1200
.meas tran vdout0_8ck59 FIND v(dout0_8) AT=1200.1n

* CHECK dout0_9 Vdout0_9ck59 = 0 time = 1200
.meas tran vdout0_9ck59 FIND v(dout0_9) AT=1200.1n

* CHECK dout0_10 Vdout0_10ck59 = 1.8 time = 1200
.meas tran vdout0_10ck59 FIND v(dout0_10) AT=1200.1n

* CHECK dout0_11 Vdout0_11ck59 = 0 time = 1200
.meas tran vdout0_11ck59 FIND v(dout0_11) AT=1200.1n

* CHECK dout0_12 Vdout0_12ck59 = 0 time = 1200
.meas tran vdout0_12ck59 FIND v(dout0_12) AT=1200.1n

* CHECK dout0_13 Vdout0_13ck59 = 0 time = 1200
.meas tran vdout0_13ck59 FIND v(dout0_13) AT=1200.1n

* CHECK dout0_14 Vdout0_14ck59 = 0 time = 1200
.meas tran vdout0_14ck59 FIND v(dout0_14) AT=1200.1n

* CHECK dout0_15 Vdout0_15ck59 = 1.8 time = 1200
.meas tran vdout0_15ck59 FIND v(dout0_15) AT=1200.1n

* CHECK dout0_0 Vdout0_0ck60 = 0 time = 1220
.meas tran vdout0_0ck60 FIND v(dout0_0) AT=1220.1n

* CHECK dout0_1 Vdout0_1ck60 = 0 time = 1220
.meas tran vdout0_1ck60 FIND v(dout0_1) AT=1220.1n

* CHECK dout0_2 Vdout0_2ck60 = 1.8 time = 1220
.meas tran vdout0_2ck60 FIND v(dout0_2) AT=1220.1n

* CHECK dout0_3 Vdout0_3ck60 = 1.8 time = 1220
.meas tran vdout0_3ck60 FIND v(dout0_3) AT=1220.1n

* CHECK dout0_4 Vdout0_4ck60 = 0 time = 1220
.meas tran vdout0_4ck60 FIND v(dout0_4) AT=1220.1n

* CHECK dout0_5 Vdout0_5ck60 = 0 time = 1220
.meas tran vdout0_5ck60 FIND v(dout0_5) AT=1220.1n

* CHECK dout0_6 Vdout0_6ck60 = 0 time = 1220
.meas tran vdout0_6ck60 FIND v(dout0_6) AT=1220.1n

* CHECK dout0_7 Vdout0_7ck60 = 1.8 time = 1220
.meas tran vdout0_7ck60 FIND v(dout0_7) AT=1220.1n

* CHECK dout0_8 Vdout0_8ck60 = 1.8 time = 1220
.meas tran vdout0_8ck60 FIND v(dout0_8) AT=1220.1n

* CHECK dout0_9 Vdout0_9ck60 = 0 time = 1220
.meas tran vdout0_9ck60 FIND v(dout0_9) AT=1220.1n

* CHECK dout0_10 Vdout0_10ck60 = 0 time = 1220
.meas tran vdout0_10ck60 FIND v(dout0_10) AT=1220.1n

* CHECK dout0_11 Vdout0_11ck60 = 1.8 time = 1220
.meas tran vdout0_11ck60 FIND v(dout0_11) AT=1220.1n

* CHECK dout0_12 Vdout0_12ck60 = 0 time = 1220
.meas tran vdout0_12ck60 FIND v(dout0_12) AT=1220.1n

* CHECK dout0_13 Vdout0_13ck60 = 0 time = 1220
.meas tran vdout0_13ck60 FIND v(dout0_13) AT=1220.1n

* CHECK dout0_14 Vdout0_14ck60 = 1.8 time = 1220
.meas tran vdout0_14ck60 FIND v(dout0_14) AT=1220.1n

* CHECK dout0_15 Vdout0_15ck60 = 0 time = 1220
.meas tran vdout0_15ck60 FIND v(dout0_15) AT=1220.1n

* CHECK dout0_0 Vdout0_0ck62 = 0 time = 1260
.meas tran vdout0_0ck62 FIND v(dout0_0) AT=1260.1n

* CHECK dout0_1 Vdout0_1ck62 = 0 time = 1260
.meas tran vdout0_1ck62 FIND v(dout0_1) AT=1260.1n

* CHECK dout0_2 Vdout0_2ck62 = 1.8 time = 1260
.meas tran vdout0_2ck62 FIND v(dout0_2) AT=1260.1n

* CHECK dout0_3 Vdout0_3ck62 = 1.8 time = 1260
.meas tran vdout0_3ck62 FIND v(dout0_3) AT=1260.1n

* CHECK dout0_4 Vdout0_4ck62 = 0 time = 1260
.meas tran vdout0_4ck62 FIND v(dout0_4) AT=1260.1n

* CHECK dout0_5 Vdout0_5ck62 = 0 time = 1260
.meas tran vdout0_5ck62 FIND v(dout0_5) AT=1260.1n

* CHECK dout0_6 Vdout0_6ck62 = 0 time = 1260
.meas tran vdout0_6ck62 FIND v(dout0_6) AT=1260.1n

* CHECK dout0_7 Vdout0_7ck62 = 1.8 time = 1260
.meas tran vdout0_7ck62 FIND v(dout0_7) AT=1260.1n

* CHECK dout0_8 Vdout0_8ck62 = 1.8 time = 1260
.meas tran vdout0_8ck62 FIND v(dout0_8) AT=1260.1n

* CHECK dout0_9 Vdout0_9ck62 = 0 time = 1260
.meas tran vdout0_9ck62 FIND v(dout0_9) AT=1260.1n

* CHECK dout0_10 Vdout0_10ck62 = 0 time = 1260
.meas tran vdout0_10ck62 FIND v(dout0_10) AT=1260.1n

* CHECK dout0_11 Vdout0_11ck62 = 1.8 time = 1260
.meas tran vdout0_11ck62 FIND v(dout0_11) AT=1260.1n

* CHECK dout0_12 Vdout0_12ck62 = 0 time = 1260
.meas tran vdout0_12ck62 FIND v(dout0_12) AT=1260.1n

* CHECK dout0_13 Vdout0_13ck62 = 0 time = 1260
.meas tran vdout0_13ck62 FIND v(dout0_13) AT=1260.1n

* CHECK dout0_14 Vdout0_14ck62 = 1.8 time = 1260
.meas tran vdout0_14ck62 FIND v(dout0_14) AT=1260.1n

* CHECK dout0_15 Vdout0_15ck62 = 0 time = 1260
.meas tran vdout0_15ck62 FIND v(dout0_15) AT=1260.1n

* CHECK dout0_0 Vdout0_0ck65 = 0 time = 1320
.meas tran vdout0_0ck65 FIND v(dout0_0) AT=1320.1n

* CHECK dout0_1 Vdout0_1ck65 = 0 time = 1320
.meas tran vdout0_1ck65 FIND v(dout0_1) AT=1320.1n

* CHECK dout0_2 Vdout0_2ck65 = 1.8 time = 1320
.meas tran vdout0_2ck65 FIND v(dout0_2) AT=1320.1n

* CHECK dout0_3 Vdout0_3ck65 = 1.8 time = 1320
.meas tran vdout0_3ck65 FIND v(dout0_3) AT=1320.1n

* CHECK dout0_4 Vdout0_4ck65 = 0 time = 1320
.meas tran vdout0_4ck65 FIND v(dout0_4) AT=1320.1n

* CHECK dout0_5 Vdout0_5ck65 = 0 time = 1320
.meas tran vdout0_5ck65 FIND v(dout0_5) AT=1320.1n

* CHECK dout0_6 Vdout0_6ck65 = 0 time = 1320
.meas tran vdout0_6ck65 FIND v(dout0_6) AT=1320.1n

* CHECK dout0_7 Vdout0_7ck65 = 1.8 time = 1320
.meas tran vdout0_7ck65 FIND v(dout0_7) AT=1320.1n

* CHECK dout0_8 Vdout0_8ck65 = 1.8 time = 1320
.meas tran vdout0_8ck65 FIND v(dout0_8) AT=1320.1n

* CHECK dout0_9 Vdout0_9ck65 = 0 time = 1320
.meas tran vdout0_9ck65 FIND v(dout0_9) AT=1320.1n

* CHECK dout0_10 Vdout0_10ck65 = 0 time = 1320
.meas tran vdout0_10ck65 FIND v(dout0_10) AT=1320.1n

* CHECK dout0_11 Vdout0_11ck65 = 1.8 time = 1320
.meas tran vdout0_11ck65 FIND v(dout0_11) AT=1320.1n

* CHECK dout0_12 Vdout0_12ck65 = 0 time = 1320
.meas tran vdout0_12ck65 FIND v(dout0_12) AT=1320.1n

* CHECK dout0_13 Vdout0_13ck65 = 0 time = 1320
.meas tran vdout0_13ck65 FIND v(dout0_13) AT=1320.1n

* CHECK dout0_14 Vdout0_14ck65 = 1.8 time = 1320
.meas tran vdout0_14ck65 FIND v(dout0_14) AT=1320.1n

* CHECK dout0_15 Vdout0_15ck65 = 0 time = 1320
.meas tran vdout0_15ck65 FIND v(dout0_15) AT=1320.1n

* CHECK dout0_0 Vdout0_0ck66 = 0 time = 1340
.meas tran vdout0_0ck66 FIND v(dout0_0) AT=1340.1n

* CHECK dout0_1 Vdout0_1ck66 = 0 time = 1340
.meas tran vdout0_1ck66 FIND v(dout0_1) AT=1340.1n

* CHECK dout0_2 Vdout0_2ck66 = 1.8 time = 1340
.meas tran vdout0_2ck66 FIND v(dout0_2) AT=1340.1n

* CHECK dout0_3 Vdout0_3ck66 = 1.8 time = 1340
.meas tran vdout0_3ck66 FIND v(dout0_3) AT=1340.1n

* CHECK dout0_4 Vdout0_4ck66 = 0 time = 1340
.meas tran vdout0_4ck66 FIND v(dout0_4) AT=1340.1n

* CHECK dout0_5 Vdout0_5ck66 = 0 time = 1340
.meas tran vdout0_5ck66 FIND v(dout0_5) AT=1340.1n

* CHECK dout0_6 Vdout0_6ck66 = 0 time = 1340
.meas tran vdout0_6ck66 FIND v(dout0_6) AT=1340.1n

* CHECK dout0_7 Vdout0_7ck66 = 1.8 time = 1340
.meas tran vdout0_7ck66 FIND v(dout0_7) AT=1340.1n

* CHECK dout0_8 Vdout0_8ck66 = 1.8 time = 1340
.meas tran vdout0_8ck66 FIND v(dout0_8) AT=1340.1n

* CHECK dout0_9 Vdout0_9ck66 = 0 time = 1340
.meas tran vdout0_9ck66 FIND v(dout0_9) AT=1340.1n

* CHECK dout0_10 Vdout0_10ck66 = 0 time = 1340
.meas tran vdout0_10ck66 FIND v(dout0_10) AT=1340.1n

* CHECK dout0_11 Vdout0_11ck66 = 1.8 time = 1340
.meas tran vdout0_11ck66 FIND v(dout0_11) AT=1340.1n

* CHECK dout0_12 Vdout0_12ck66 = 0 time = 1340
.meas tran vdout0_12ck66 FIND v(dout0_12) AT=1340.1n

* CHECK dout0_13 Vdout0_13ck66 = 0 time = 1340
.meas tran vdout0_13ck66 FIND v(dout0_13) AT=1340.1n

* CHECK dout0_14 Vdout0_14ck66 = 1.8 time = 1340
.meas tran vdout0_14ck66 FIND v(dout0_14) AT=1340.1n

* CHECK dout0_15 Vdout0_15ck66 = 0 time = 1340
.meas tran vdout0_15ck66 FIND v(dout0_15) AT=1340.1n

* CHECK dout0_0 Vdout0_0ck70 = 0 time = 1420
.meas tran vdout0_0ck70 FIND v(dout0_0) AT=1420.1n

* CHECK dout0_1 Vdout0_1ck70 = 1.8 time = 1420
.meas tran vdout0_1ck70 FIND v(dout0_1) AT=1420.1n

* CHECK dout0_2 Vdout0_2ck70 = 1.8 time = 1420
.meas tran vdout0_2ck70 FIND v(dout0_2) AT=1420.1n

* CHECK dout0_3 Vdout0_3ck70 = 1.8 time = 1420
.meas tran vdout0_3ck70 FIND v(dout0_3) AT=1420.1n

* CHECK dout0_4 Vdout0_4ck70 = 1.8 time = 1420
.meas tran vdout0_4ck70 FIND v(dout0_4) AT=1420.1n

* CHECK dout0_5 Vdout0_5ck70 = 0 time = 1420
.meas tran vdout0_5ck70 FIND v(dout0_5) AT=1420.1n

* CHECK dout0_6 Vdout0_6ck70 = 0 time = 1420
.meas tran vdout0_6ck70 FIND v(dout0_6) AT=1420.1n

* CHECK dout0_7 Vdout0_7ck70 = 0 time = 1420
.meas tran vdout0_7ck70 FIND v(dout0_7) AT=1420.1n

* CHECK dout0_8 Vdout0_8ck70 = 1.8 time = 1420
.meas tran vdout0_8ck70 FIND v(dout0_8) AT=1420.1n

* CHECK dout0_9 Vdout0_9ck70 = 0 time = 1420
.meas tran vdout0_9ck70 FIND v(dout0_9) AT=1420.1n

* CHECK dout0_10 Vdout0_10ck70 = 1.8 time = 1420
.meas tran vdout0_10ck70 FIND v(dout0_10) AT=1420.1n

* CHECK dout0_11 Vdout0_11ck70 = 1.8 time = 1420
.meas tran vdout0_11ck70 FIND v(dout0_11) AT=1420.1n

* CHECK dout0_12 Vdout0_12ck70 = 1.8 time = 1420
.meas tran vdout0_12ck70 FIND v(dout0_12) AT=1420.1n

* CHECK dout0_13 Vdout0_13ck70 = 0 time = 1420
.meas tran vdout0_13ck70 FIND v(dout0_13) AT=1420.1n

* CHECK dout0_14 Vdout0_14ck70 = 0 time = 1420
.meas tran vdout0_14ck70 FIND v(dout0_14) AT=1420.1n

* CHECK dout0_15 Vdout0_15ck70 = 1.8 time = 1420
.meas tran vdout0_15ck70 FIND v(dout0_15) AT=1420.1n

* CHECK dout0_0 Vdout0_0ck71 = 0 time = 1440
.meas tran vdout0_0ck71 FIND v(dout0_0) AT=1440.1n

* CHECK dout0_1 Vdout0_1ck71 = 1.8 time = 1440
.meas tran vdout0_1ck71 FIND v(dout0_1) AT=1440.1n

* CHECK dout0_2 Vdout0_2ck71 = 1.8 time = 1440
.meas tran vdout0_2ck71 FIND v(dout0_2) AT=1440.1n

* CHECK dout0_3 Vdout0_3ck71 = 0 time = 1440
.meas tran vdout0_3ck71 FIND v(dout0_3) AT=1440.1n

* CHECK dout0_4 Vdout0_4ck71 = 0 time = 1440
.meas tran vdout0_4ck71 FIND v(dout0_4) AT=1440.1n

* CHECK dout0_5 Vdout0_5ck71 = 1.8 time = 1440
.meas tran vdout0_5ck71 FIND v(dout0_5) AT=1440.1n

* CHECK dout0_6 Vdout0_6ck71 = 0 time = 1440
.meas tran vdout0_6ck71 FIND v(dout0_6) AT=1440.1n

* CHECK dout0_7 Vdout0_7ck71 = 0 time = 1440
.meas tran vdout0_7ck71 FIND v(dout0_7) AT=1440.1n

* CHECK dout0_8 Vdout0_8ck71 = 1.8 time = 1440
.meas tran vdout0_8ck71 FIND v(dout0_8) AT=1440.1n

* CHECK dout0_9 Vdout0_9ck71 = 0 time = 1440
.meas tran vdout0_9ck71 FIND v(dout0_9) AT=1440.1n

* CHECK dout0_10 Vdout0_10ck71 = 0 time = 1440
.meas tran vdout0_10ck71 FIND v(dout0_10) AT=1440.1n

* CHECK dout0_11 Vdout0_11ck71 = 1.8 time = 1440
.meas tran vdout0_11ck71 FIND v(dout0_11) AT=1440.1n

* CHECK dout0_12 Vdout0_12ck71 = 1.8 time = 1440
.meas tran vdout0_12ck71 FIND v(dout0_12) AT=1440.1n

* CHECK dout0_13 Vdout0_13ck71 = 0 time = 1440
.meas tran vdout0_13ck71 FIND v(dout0_13) AT=1440.1n

* CHECK dout0_14 Vdout0_14ck71 = 0 time = 1440
.meas tran vdout0_14ck71 FIND v(dout0_14) AT=1440.1n

* CHECK dout0_15 Vdout0_15ck71 = 1.8 time = 1440
.meas tran vdout0_15ck71 FIND v(dout0_15) AT=1440.1n

* CHECK dout0_0 Vdout0_0ck73 = 0 time = 1480
.meas tran vdout0_0ck73 FIND v(dout0_0) AT=1480.1n

* CHECK dout0_1 Vdout0_1ck73 = 0 time = 1480
.meas tran vdout0_1ck73 FIND v(dout0_1) AT=1480.1n

* CHECK dout0_2 Vdout0_2ck73 = 1.8 time = 1480
.meas tran vdout0_2ck73 FIND v(dout0_2) AT=1480.1n

* CHECK dout0_3 Vdout0_3ck73 = 1.8 time = 1480
.meas tran vdout0_3ck73 FIND v(dout0_3) AT=1480.1n

* CHECK dout0_4 Vdout0_4ck73 = 0 time = 1480
.meas tran vdout0_4ck73 FIND v(dout0_4) AT=1480.1n

* CHECK dout0_5 Vdout0_5ck73 = 0 time = 1480
.meas tran vdout0_5ck73 FIND v(dout0_5) AT=1480.1n

* CHECK dout0_6 Vdout0_6ck73 = 0 time = 1480
.meas tran vdout0_6ck73 FIND v(dout0_6) AT=1480.1n

* CHECK dout0_7 Vdout0_7ck73 = 1.8 time = 1480
.meas tran vdout0_7ck73 FIND v(dout0_7) AT=1480.1n

* CHECK dout0_8 Vdout0_8ck73 = 1.8 time = 1480
.meas tran vdout0_8ck73 FIND v(dout0_8) AT=1480.1n

* CHECK dout0_9 Vdout0_9ck73 = 0 time = 1480
.meas tran vdout0_9ck73 FIND v(dout0_9) AT=1480.1n

* CHECK dout0_10 Vdout0_10ck73 = 0 time = 1480
.meas tran vdout0_10ck73 FIND v(dout0_10) AT=1480.1n

* CHECK dout0_11 Vdout0_11ck73 = 1.8 time = 1480
.meas tran vdout0_11ck73 FIND v(dout0_11) AT=1480.1n

* CHECK dout0_12 Vdout0_12ck73 = 0 time = 1480
.meas tran vdout0_12ck73 FIND v(dout0_12) AT=1480.1n

* CHECK dout0_13 Vdout0_13ck73 = 0 time = 1480
.meas tran vdout0_13ck73 FIND v(dout0_13) AT=1480.1n

* CHECK dout0_14 Vdout0_14ck73 = 1.8 time = 1480
.meas tran vdout0_14ck73 FIND v(dout0_14) AT=1480.1n

* CHECK dout0_15 Vdout0_15ck73 = 0 time = 1480
.meas tran vdout0_15ck73 FIND v(dout0_15) AT=1480.1n

* CHECK dout0_0 Vdout0_0ck75 = 1.8 time = 1520
.meas tran vdout0_0ck75 FIND v(dout0_0) AT=1520.1n

* CHECK dout0_1 Vdout0_1ck75 = 1.8 time = 1520
.meas tran vdout0_1ck75 FIND v(dout0_1) AT=1520.1n

* CHECK dout0_2 Vdout0_2ck75 = 0 time = 1520
.meas tran vdout0_2ck75 FIND v(dout0_2) AT=1520.1n

* CHECK dout0_3 Vdout0_3ck75 = 1.8 time = 1520
.meas tran vdout0_3ck75 FIND v(dout0_3) AT=1520.1n

* CHECK dout0_4 Vdout0_4ck75 = 0 time = 1520
.meas tran vdout0_4ck75 FIND v(dout0_4) AT=1520.1n

* CHECK dout0_5 Vdout0_5ck75 = 1.8 time = 1520
.meas tran vdout0_5ck75 FIND v(dout0_5) AT=1520.1n

* CHECK dout0_6 Vdout0_6ck75 = 1.8 time = 1520
.meas tran vdout0_6ck75 FIND v(dout0_6) AT=1520.1n

* CHECK dout0_7 Vdout0_7ck75 = 0 time = 1520
.meas tran vdout0_7ck75 FIND v(dout0_7) AT=1520.1n

* CHECK dout0_8 Vdout0_8ck75 = 1.8 time = 1520
.meas tran vdout0_8ck75 FIND v(dout0_8) AT=1520.1n

* CHECK dout0_9 Vdout0_9ck75 = 0 time = 1520
.meas tran vdout0_9ck75 FIND v(dout0_9) AT=1520.1n

* CHECK dout0_10 Vdout0_10ck75 = 0 time = 1520
.meas tran vdout0_10ck75 FIND v(dout0_10) AT=1520.1n

* CHECK dout0_11 Vdout0_11ck75 = 0 time = 1520
.meas tran vdout0_11ck75 FIND v(dout0_11) AT=1520.1n

* CHECK dout0_12 Vdout0_12ck75 = 1.8 time = 1520
.meas tran vdout0_12ck75 FIND v(dout0_12) AT=1520.1n

* CHECK dout0_13 Vdout0_13ck75 = 0 time = 1520
.meas tran vdout0_13ck75 FIND v(dout0_13) AT=1520.1n

* CHECK dout0_14 Vdout0_14ck75 = 0 time = 1520
.meas tran vdout0_14ck75 FIND v(dout0_14) AT=1520.1n

* CHECK dout0_15 Vdout0_15ck75 = 0 time = 1520
.meas tran vdout0_15ck75 FIND v(dout0_15) AT=1520.1n

* CHECK dout0_0 Vdout0_0ck76 = 0 time = 1540
.meas tran vdout0_0ck76 FIND v(dout0_0) AT=1540.1n

* CHECK dout0_1 Vdout0_1ck76 = 0 time = 1540
.meas tran vdout0_1ck76 FIND v(dout0_1) AT=1540.1n

* CHECK dout0_2 Vdout0_2ck76 = 1.8 time = 1540
.meas tran vdout0_2ck76 FIND v(dout0_2) AT=1540.1n

* CHECK dout0_3 Vdout0_3ck76 = 1.8 time = 1540
.meas tran vdout0_3ck76 FIND v(dout0_3) AT=1540.1n

* CHECK dout0_4 Vdout0_4ck76 = 0 time = 1540
.meas tran vdout0_4ck76 FIND v(dout0_4) AT=1540.1n

* CHECK dout0_5 Vdout0_5ck76 = 0 time = 1540
.meas tran vdout0_5ck76 FIND v(dout0_5) AT=1540.1n

* CHECK dout0_6 Vdout0_6ck76 = 0 time = 1540
.meas tran vdout0_6ck76 FIND v(dout0_6) AT=1540.1n

* CHECK dout0_7 Vdout0_7ck76 = 1.8 time = 1540
.meas tran vdout0_7ck76 FIND v(dout0_7) AT=1540.1n

* CHECK dout0_8 Vdout0_8ck76 = 1.8 time = 1540
.meas tran vdout0_8ck76 FIND v(dout0_8) AT=1540.1n

* CHECK dout0_9 Vdout0_9ck76 = 0 time = 1540
.meas tran vdout0_9ck76 FIND v(dout0_9) AT=1540.1n

* CHECK dout0_10 Vdout0_10ck76 = 0 time = 1540
.meas tran vdout0_10ck76 FIND v(dout0_10) AT=1540.1n

* CHECK dout0_11 Vdout0_11ck76 = 1.8 time = 1540
.meas tran vdout0_11ck76 FIND v(dout0_11) AT=1540.1n

* CHECK dout0_12 Vdout0_12ck76 = 0 time = 1540
.meas tran vdout0_12ck76 FIND v(dout0_12) AT=1540.1n

* CHECK dout0_13 Vdout0_13ck76 = 0 time = 1540
.meas tran vdout0_13ck76 FIND v(dout0_13) AT=1540.1n

* CHECK dout0_14 Vdout0_14ck76 = 1.8 time = 1540
.meas tran vdout0_14ck76 FIND v(dout0_14) AT=1540.1n

* CHECK dout0_15 Vdout0_15ck76 = 0 time = 1540
.meas tran vdout0_15ck76 FIND v(dout0_15) AT=1540.1n

* CHECK dout0_0 Vdout0_0ck78 = 1.8 time = 1580
.meas tran vdout0_0ck78 FIND v(dout0_0) AT=1580.1n

* CHECK dout0_1 Vdout0_1ck78 = 1.8 time = 1580
.meas tran vdout0_1ck78 FIND v(dout0_1) AT=1580.1n

* CHECK dout0_2 Vdout0_2ck78 = 0 time = 1580
.meas tran vdout0_2ck78 FIND v(dout0_2) AT=1580.1n

* CHECK dout0_3 Vdout0_3ck78 = 1.8 time = 1580
.meas tran vdout0_3ck78 FIND v(dout0_3) AT=1580.1n

* CHECK dout0_4 Vdout0_4ck78 = 0 time = 1580
.meas tran vdout0_4ck78 FIND v(dout0_4) AT=1580.1n

* CHECK dout0_5 Vdout0_5ck78 = 1.8 time = 1580
.meas tran vdout0_5ck78 FIND v(dout0_5) AT=1580.1n

* CHECK dout0_6 Vdout0_6ck78 = 1.8 time = 1580
.meas tran vdout0_6ck78 FIND v(dout0_6) AT=1580.1n

* CHECK dout0_7 Vdout0_7ck78 = 0 time = 1580
.meas tran vdout0_7ck78 FIND v(dout0_7) AT=1580.1n

* CHECK dout0_8 Vdout0_8ck78 = 1.8 time = 1580
.meas tran vdout0_8ck78 FIND v(dout0_8) AT=1580.1n

* CHECK dout0_9 Vdout0_9ck78 = 0 time = 1580
.meas tran vdout0_9ck78 FIND v(dout0_9) AT=1580.1n

* CHECK dout0_10 Vdout0_10ck78 = 0 time = 1580
.meas tran vdout0_10ck78 FIND v(dout0_10) AT=1580.1n

* CHECK dout0_11 Vdout0_11ck78 = 0 time = 1580
.meas tran vdout0_11ck78 FIND v(dout0_11) AT=1580.1n

* CHECK dout0_12 Vdout0_12ck78 = 1.8 time = 1580
.meas tran vdout0_12ck78 FIND v(dout0_12) AT=1580.1n

* CHECK dout0_13 Vdout0_13ck78 = 0 time = 1580
.meas tran vdout0_13ck78 FIND v(dout0_13) AT=1580.1n

* CHECK dout0_14 Vdout0_14ck78 = 0 time = 1580
.meas tran vdout0_14ck78 FIND v(dout0_14) AT=1580.1n

* CHECK dout0_15 Vdout0_15ck78 = 0 time = 1580
.meas tran vdout0_15ck78 FIND v(dout0_15) AT=1580.1n

* CHECK dout0_0 Vdout0_0ck80 = 0 time = 1620
.meas tran vdout0_0ck80 FIND v(dout0_0) AT=1620.1n

* CHECK dout0_1 Vdout0_1ck80 = 1.8 time = 1620
.meas tran vdout0_1ck80 FIND v(dout0_1) AT=1620.1n

* CHECK dout0_2 Vdout0_2ck80 = 1.8 time = 1620
.meas tran vdout0_2ck80 FIND v(dout0_2) AT=1620.1n

* CHECK dout0_3 Vdout0_3ck80 = 0 time = 1620
.meas tran vdout0_3ck80 FIND v(dout0_3) AT=1620.1n

* CHECK dout0_4 Vdout0_4ck80 = 0 time = 1620
.meas tran vdout0_4ck80 FIND v(dout0_4) AT=1620.1n

* CHECK dout0_5 Vdout0_5ck80 = 1.8 time = 1620
.meas tran vdout0_5ck80 FIND v(dout0_5) AT=1620.1n

* CHECK dout0_6 Vdout0_6ck80 = 0 time = 1620
.meas tran vdout0_6ck80 FIND v(dout0_6) AT=1620.1n

* CHECK dout0_7 Vdout0_7ck80 = 0 time = 1620
.meas tran vdout0_7ck80 FIND v(dout0_7) AT=1620.1n

* CHECK dout0_8 Vdout0_8ck80 = 1.8 time = 1620
.meas tran vdout0_8ck80 FIND v(dout0_8) AT=1620.1n

* CHECK dout0_9 Vdout0_9ck80 = 0 time = 1620
.meas tran vdout0_9ck80 FIND v(dout0_9) AT=1620.1n

* CHECK dout0_10 Vdout0_10ck80 = 0 time = 1620
.meas tran vdout0_10ck80 FIND v(dout0_10) AT=1620.1n

* CHECK dout0_11 Vdout0_11ck80 = 1.8 time = 1620
.meas tran vdout0_11ck80 FIND v(dout0_11) AT=1620.1n

* CHECK dout0_12 Vdout0_12ck80 = 1.8 time = 1620
.meas tran vdout0_12ck80 FIND v(dout0_12) AT=1620.1n

* CHECK dout0_13 Vdout0_13ck80 = 0 time = 1620
.meas tran vdout0_13ck80 FIND v(dout0_13) AT=1620.1n

* CHECK dout0_14 Vdout0_14ck80 = 0 time = 1620
.meas tran vdout0_14ck80 FIND v(dout0_14) AT=1620.1n

* CHECK dout0_15 Vdout0_15ck80 = 1.8 time = 1620
.meas tran vdout0_15ck80 FIND v(dout0_15) AT=1620.1n

* CHECK dout0_0 Vdout0_0ck81 = 1.8 time = 1640
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=1640.1n

* CHECK dout0_1 Vdout0_1ck81 = 1.8 time = 1640
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=1640.1n

* CHECK dout0_2 Vdout0_2ck81 = 0 time = 1640
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=1640.1n

* CHECK dout0_3 Vdout0_3ck81 = 1.8 time = 1640
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=1640.1n

* CHECK dout0_4 Vdout0_4ck81 = 0 time = 1640
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=1640.1n

* CHECK dout0_5 Vdout0_5ck81 = 1.8 time = 1640
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=1640.1n

* CHECK dout0_6 Vdout0_6ck81 = 1.8 time = 1640
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=1640.1n

* CHECK dout0_7 Vdout0_7ck81 = 0 time = 1640
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=1640.1n

* CHECK dout0_8 Vdout0_8ck81 = 1.8 time = 1640
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=1640.1n

* CHECK dout0_9 Vdout0_9ck81 = 0 time = 1640
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=1640.1n

* CHECK dout0_10 Vdout0_10ck81 = 0 time = 1640
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=1640.1n

* CHECK dout0_11 Vdout0_11ck81 = 0 time = 1640
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=1640.1n

* CHECK dout0_12 Vdout0_12ck81 = 1.8 time = 1640
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=1640.1n

* CHECK dout0_13 Vdout0_13ck81 = 0 time = 1640
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=1640.1n

* CHECK dout0_14 Vdout0_14ck81 = 0 time = 1640
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=1640.1n

* CHECK dout0_15 Vdout0_15ck81 = 0 time = 1640
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=1640.1n

* CHECK dout0_0 Vdout0_0ck84 = 0 time = 1700
.meas tran vdout0_0ck84 FIND v(dout0_0) AT=1700.1n

* CHECK dout0_1 Vdout0_1ck84 = 1.8 time = 1700
.meas tran vdout0_1ck84 FIND v(dout0_1) AT=1700.1n

* CHECK dout0_2 Vdout0_2ck84 = 1.8 time = 1700
.meas tran vdout0_2ck84 FIND v(dout0_2) AT=1700.1n

* CHECK dout0_3 Vdout0_3ck84 = 0 time = 1700
.meas tran vdout0_3ck84 FIND v(dout0_3) AT=1700.1n

* CHECK dout0_4 Vdout0_4ck84 = 0 time = 1700
.meas tran vdout0_4ck84 FIND v(dout0_4) AT=1700.1n

* CHECK dout0_5 Vdout0_5ck84 = 1.8 time = 1700
.meas tran vdout0_5ck84 FIND v(dout0_5) AT=1700.1n

* CHECK dout0_6 Vdout0_6ck84 = 0 time = 1700
.meas tran vdout0_6ck84 FIND v(dout0_6) AT=1700.1n

* CHECK dout0_7 Vdout0_7ck84 = 0 time = 1700
.meas tran vdout0_7ck84 FIND v(dout0_7) AT=1700.1n

* CHECK dout0_8 Vdout0_8ck84 = 1.8 time = 1700
.meas tran vdout0_8ck84 FIND v(dout0_8) AT=1700.1n

* CHECK dout0_9 Vdout0_9ck84 = 0 time = 1700
.meas tran vdout0_9ck84 FIND v(dout0_9) AT=1700.1n

* CHECK dout0_10 Vdout0_10ck84 = 0 time = 1700
.meas tran vdout0_10ck84 FIND v(dout0_10) AT=1700.1n

* CHECK dout0_11 Vdout0_11ck84 = 1.8 time = 1700
.meas tran vdout0_11ck84 FIND v(dout0_11) AT=1700.1n

* CHECK dout0_12 Vdout0_12ck84 = 1.8 time = 1700
.meas tran vdout0_12ck84 FIND v(dout0_12) AT=1700.1n

* CHECK dout0_13 Vdout0_13ck84 = 0 time = 1700
.meas tran vdout0_13ck84 FIND v(dout0_13) AT=1700.1n

* CHECK dout0_14 Vdout0_14ck84 = 0 time = 1700
.meas tran vdout0_14ck84 FIND v(dout0_14) AT=1700.1n

* CHECK dout0_15 Vdout0_15ck84 = 1.8 time = 1700
.meas tran vdout0_15ck84 FIND v(dout0_15) AT=1700.1n

* CHECK dout0_0 Vdout0_0ck86 = 0 time = 1740
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=1740.1n

* CHECK dout0_1 Vdout0_1ck86 = 1.8 time = 1740
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=1740.1n

* CHECK dout0_2 Vdout0_2ck86 = 1.8 time = 1740
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=1740.1n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 1740
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=1740.1n

* CHECK dout0_4 Vdout0_4ck86 = 0 time = 1740
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=1740.1n

* CHECK dout0_5 Vdout0_5ck86 = 1.8 time = 1740
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=1740.1n

* CHECK dout0_6 Vdout0_6ck86 = 0 time = 1740
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=1740.1n

* CHECK dout0_7 Vdout0_7ck86 = 0 time = 1740
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=1740.1n

* CHECK dout0_8 Vdout0_8ck86 = 1.8 time = 1740
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=1740.1n

* CHECK dout0_9 Vdout0_9ck86 = 0 time = 1740
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=1740.1n

* CHECK dout0_10 Vdout0_10ck86 = 0 time = 1740
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=1740.1n

* CHECK dout0_11 Vdout0_11ck86 = 1.8 time = 1740
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=1740.1n

* CHECK dout0_12 Vdout0_12ck86 = 1.8 time = 1740
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=1740.1n

* CHECK dout0_13 Vdout0_13ck86 = 0 time = 1740
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=1740.1n

* CHECK dout0_14 Vdout0_14ck86 = 0 time = 1740
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=1740.1n

* CHECK dout0_15 Vdout0_15ck86 = 1.8 time = 1740
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=1740.1n

* CHECK dout0_0 Vdout0_0ck88 = 0 time = 1780
.meas tran vdout0_0ck88 FIND v(dout0_0) AT=1780.1n

* CHECK dout0_1 Vdout0_1ck88 = 1.8 time = 1780
.meas tran vdout0_1ck88 FIND v(dout0_1) AT=1780.1n

* CHECK dout0_2 Vdout0_2ck88 = 1.8 time = 1780
.meas tran vdout0_2ck88 FIND v(dout0_2) AT=1780.1n

* CHECK dout0_3 Vdout0_3ck88 = 1.8 time = 1780
.meas tran vdout0_3ck88 FIND v(dout0_3) AT=1780.1n

* CHECK dout0_4 Vdout0_4ck88 = 1.8 time = 1780
.meas tran vdout0_4ck88 FIND v(dout0_4) AT=1780.1n

* CHECK dout0_5 Vdout0_5ck88 = 0 time = 1780
.meas tran vdout0_5ck88 FIND v(dout0_5) AT=1780.1n

* CHECK dout0_6 Vdout0_6ck88 = 0 time = 1780
.meas tran vdout0_6ck88 FIND v(dout0_6) AT=1780.1n

* CHECK dout0_7 Vdout0_7ck88 = 0 time = 1780
.meas tran vdout0_7ck88 FIND v(dout0_7) AT=1780.1n

* CHECK dout0_8 Vdout0_8ck88 = 1.8 time = 1780
.meas tran vdout0_8ck88 FIND v(dout0_8) AT=1780.1n

* CHECK dout0_9 Vdout0_9ck88 = 0 time = 1780
.meas tran vdout0_9ck88 FIND v(dout0_9) AT=1780.1n

* CHECK dout0_10 Vdout0_10ck88 = 1.8 time = 1780
.meas tran vdout0_10ck88 FIND v(dout0_10) AT=1780.1n

* CHECK dout0_11 Vdout0_11ck88 = 1.8 time = 1780
.meas tran vdout0_11ck88 FIND v(dout0_11) AT=1780.1n

* CHECK dout0_12 Vdout0_12ck88 = 1.8 time = 1780
.meas tran vdout0_12ck88 FIND v(dout0_12) AT=1780.1n

* CHECK dout0_13 Vdout0_13ck88 = 0 time = 1780
.meas tran vdout0_13ck88 FIND v(dout0_13) AT=1780.1n

* CHECK dout0_14 Vdout0_14ck88 = 0 time = 1780
.meas tran vdout0_14ck88 FIND v(dout0_14) AT=1780.1n

* CHECK dout0_15 Vdout0_15ck88 = 1.8 time = 1780
.meas tran vdout0_15ck88 FIND v(dout0_15) AT=1780.1n

* CHECK dout0_0 Vdout0_0ck92 = 1.8 time = 1860
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=1860.1n

* CHECK dout0_1 Vdout0_1ck92 = 1.8 time = 1860
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=1860.1n

* CHECK dout0_2 Vdout0_2ck92 = 0 time = 1860
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=1860.1n

* CHECK dout0_3 Vdout0_3ck92 = 1.8 time = 1860
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=1860.1n

* CHECK dout0_4 Vdout0_4ck92 = 1.8 time = 1860
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=1860.1n

* CHECK dout0_5 Vdout0_5ck92 = 1.8 time = 1860
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=1860.1n

* CHECK dout0_6 Vdout0_6ck92 = 0 time = 1860
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=1860.1n

* CHECK dout0_7 Vdout0_7ck92 = 0 time = 1860
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=1860.1n

* CHECK dout0_8 Vdout0_8ck92 = 1.8 time = 1860
.meas tran vdout0_8ck92 FIND v(dout0_8) AT=1860.1n

* CHECK dout0_9 Vdout0_9ck92 = 1.8 time = 1860
.meas tran vdout0_9ck92 FIND v(dout0_9) AT=1860.1n

* CHECK dout0_10 Vdout0_10ck92 = 1.8 time = 1860
.meas tran vdout0_10ck92 FIND v(dout0_10) AT=1860.1n

* CHECK dout0_11 Vdout0_11ck92 = 0 time = 1860
.meas tran vdout0_11ck92 FIND v(dout0_11) AT=1860.1n

* CHECK dout0_12 Vdout0_12ck92 = 0 time = 1860
.meas tran vdout0_12ck92 FIND v(dout0_12) AT=1860.1n

* CHECK dout0_13 Vdout0_13ck92 = 0 time = 1860
.meas tran vdout0_13ck92 FIND v(dout0_13) AT=1860.1n

* CHECK dout0_14 Vdout0_14ck92 = 0 time = 1860
.meas tran vdout0_14ck92 FIND v(dout0_14) AT=1860.1n

* CHECK dout0_15 Vdout0_15ck92 = 1.8 time = 1860
.meas tran vdout0_15ck92 FIND v(dout0_15) AT=1860.1n

* CHECK dout0_0 Vdout0_0ck96 = 1.8 time = 1940
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=1940.1n

* CHECK dout0_1 Vdout0_1ck96 = 0 time = 1940
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=1940.1n

* CHECK dout0_2 Vdout0_2ck96 = 0 time = 1940
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=1940.1n

* CHECK dout0_3 Vdout0_3ck96 = 1.8 time = 1940
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=1940.1n

* CHECK dout0_4 Vdout0_4ck96 = 1.8 time = 1940
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=1940.1n

* CHECK dout0_5 Vdout0_5ck96 = 0 time = 1940
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=1940.1n

* CHECK dout0_6 Vdout0_6ck96 = 1.8 time = 1940
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=1940.1n

* CHECK dout0_7 Vdout0_7ck96 = 0 time = 1940
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=1940.1n

* CHECK dout0_8 Vdout0_8ck96 = 1.8 time = 1940
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=1940.1n

* CHECK dout0_9 Vdout0_9ck96 = 1.8 time = 1940
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=1940.1n

* CHECK dout0_10 Vdout0_10ck96 = 1.8 time = 1940
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=1940.1n

* CHECK dout0_11 Vdout0_11ck96 = 0 time = 1940
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=1940.1n

* CHECK dout0_12 Vdout0_12ck96 = 1.8 time = 1940
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=1940.1n

* CHECK dout0_13 Vdout0_13ck96 = 1.8 time = 1940
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=1940.1n

* CHECK dout0_14 Vdout0_14ck96 = 1.8 time = 1940
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=1940.1n

* CHECK dout0_15 Vdout0_15ck96 = 0 time = 1940
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=1940.1n

* CHECK dout0_0 Vdout0_0ck97 = 0 time = 1960
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=1960.1n

* CHECK dout0_1 Vdout0_1ck97 = 1.8 time = 1960
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=1960.1n

* CHECK dout0_2 Vdout0_2ck97 = 1.8 time = 1960
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=1960.1n

* CHECK dout0_3 Vdout0_3ck97 = 1.8 time = 1960
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=1960.1n

* CHECK dout0_4 Vdout0_4ck97 = 1.8 time = 1960
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=1960.1n

* CHECK dout0_5 Vdout0_5ck97 = 0 time = 1960
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=1960.1n

* CHECK dout0_6 Vdout0_6ck97 = 0 time = 1960
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=1960.1n

* CHECK dout0_7 Vdout0_7ck97 = 0 time = 1960
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=1960.1n

* CHECK dout0_8 Vdout0_8ck97 = 1.8 time = 1960
.meas tran vdout0_8ck97 FIND v(dout0_8) AT=1960.1n

* CHECK dout0_9 Vdout0_9ck97 = 0 time = 1960
.meas tran vdout0_9ck97 FIND v(dout0_9) AT=1960.1n

* CHECK dout0_10 Vdout0_10ck97 = 1.8 time = 1960
.meas tran vdout0_10ck97 FIND v(dout0_10) AT=1960.1n

* CHECK dout0_11 Vdout0_11ck97 = 1.8 time = 1960
.meas tran vdout0_11ck97 FIND v(dout0_11) AT=1960.1n

* CHECK dout0_12 Vdout0_12ck97 = 1.8 time = 1960
.meas tran vdout0_12ck97 FIND v(dout0_12) AT=1960.1n

* CHECK dout0_13 Vdout0_13ck97 = 0 time = 1960
.meas tran vdout0_13ck97 FIND v(dout0_13) AT=1960.1n

* CHECK dout0_14 Vdout0_14ck97 = 0 time = 1960
.meas tran vdout0_14ck97 FIND v(dout0_14) AT=1960.1n

* CHECK dout0_15 Vdout0_15ck97 = 1.8 time = 1960
.meas tran vdout0_15ck97 FIND v(dout0_15) AT=1960.1n

* CHECK dout0_0 Vdout0_0ck100 = 1.8 time = 2020
.meas tran vdout0_0ck100 FIND v(dout0_0) AT=2020.1n

* CHECK dout0_1 Vdout0_1ck100 = 0 time = 2020
.meas tran vdout0_1ck100 FIND v(dout0_1) AT=2020.1n

* CHECK dout0_2 Vdout0_2ck100 = 0 time = 2020
.meas tran vdout0_2ck100 FIND v(dout0_2) AT=2020.1n

* CHECK dout0_3 Vdout0_3ck100 = 0 time = 2020
.meas tran vdout0_3ck100 FIND v(dout0_3) AT=2020.1n

* CHECK dout0_4 Vdout0_4ck100 = 0 time = 2020
.meas tran vdout0_4ck100 FIND v(dout0_4) AT=2020.1n

* CHECK dout0_5 Vdout0_5ck100 = 1.8 time = 2020
.meas tran vdout0_5ck100 FIND v(dout0_5) AT=2020.1n

* CHECK dout0_6 Vdout0_6ck100 = 0 time = 2020
.meas tran vdout0_6ck100 FIND v(dout0_6) AT=2020.1n

* CHECK dout0_7 Vdout0_7ck100 = 0 time = 2020
.meas tran vdout0_7ck100 FIND v(dout0_7) AT=2020.1n

* CHECK dout0_8 Vdout0_8ck100 = 1.8 time = 2020
.meas tran vdout0_8ck100 FIND v(dout0_8) AT=2020.1n

* CHECK dout0_9 Vdout0_9ck100 = 0 time = 2020
.meas tran vdout0_9ck100 FIND v(dout0_9) AT=2020.1n

* CHECK dout0_10 Vdout0_10ck100 = 0 time = 2020
.meas tran vdout0_10ck100 FIND v(dout0_10) AT=2020.1n

* CHECK dout0_11 Vdout0_11ck100 = 0 time = 2020
.meas tran vdout0_11ck100 FIND v(dout0_11) AT=2020.1n

* CHECK dout0_12 Vdout0_12ck100 = 1.8 time = 2020
.meas tran vdout0_12ck100 FIND v(dout0_12) AT=2020.1n

* CHECK dout0_13 Vdout0_13ck100 = 1.8 time = 2020
.meas tran vdout0_13ck100 FIND v(dout0_13) AT=2020.1n

* CHECK dout0_14 Vdout0_14ck100 = 0 time = 2020
.meas tran vdout0_14ck100 FIND v(dout0_14) AT=2020.1n

* CHECK dout0_15 Vdout0_15ck100 = 0 time = 2020
.meas tran vdout0_15ck100 FIND v(dout0_15) AT=2020.1n

* CHECK dout0_0 Vdout0_0ck103 = 1.8 time = 2080
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=2080.1n

* CHECK dout0_1 Vdout0_1ck103 = 1.8 time = 2080
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=2080.1n

* CHECK dout0_2 Vdout0_2ck103 = 0 time = 2080
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=2080.1n

* CHECK dout0_3 Vdout0_3ck103 = 1.8 time = 2080
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=2080.1n

* CHECK dout0_4 Vdout0_4ck103 = 1.8 time = 2080
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=2080.1n

* CHECK dout0_5 Vdout0_5ck103 = 1.8 time = 2080
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=2080.1n

* CHECK dout0_6 Vdout0_6ck103 = 0 time = 2080
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=2080.1n

* CHECK dout0_7 Vdout0_7ck103 = 0 time = 2080
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=2080.1n

* CHECK dout0_8 Vdout0_8ck103 = 1.8 time = 2080
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=2080.1n

* CHECK dout0_9 Vdout0_9ck103 = 1.8 time = 2080
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=2080.1n

* CHECK dout0_10 Vdout0_10ck103 = 1.8 time = 2080
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=2080.1n

* CHECK dout0_11 Vdout0_11ck103 = 0 time = 2080
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=2080.1n

* CHECK dout0_12 Vdout0_12ck103 = 0 time = 2080
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=2080.1n

* CHECK dout0_13 Vdout0_13ck103 = 0 time = 2080
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=2080.1n

* CHECK dout0_14 Vdout0_14ck103 = 0 time = 2080
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=2080.1n

* CHECK dout0_15 Vdout0_15ck103 = 1.8 time = 2080
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=2080.1n

* CHECK dout0_0 Vdout0_0ck104 = 1.8 time = 2100
.meas tran vdout0_0ck104 FIND v(dout0_0) AT=2100.1n

* CHECK dout0_1 Vdout0_1ck104 = 1.8 time = 2100
.meas tran vdout0_1ck104 FIND v(dout0_1) AT=2100.1n

* CHECK dout0_2 Vdout0_2ck104 = 0 time = 2100
.meas tran vdout0_2ck104 FIND v(dout0_2) AT=2100.1n

* CHECK dout0_3 Vdout0_3ck104 = 1.8 time = 2100
.meas tran vdout0_3ck104 FIND v(dout0_3) AT=2100.1n

* CHECK dout0_4 Vdout0_4ck104 = 1.8 time = 2100
.meas tran vdout0_4ck104 FIND v(dout0_4) AT=2100.1n

* CHECK dout0_5 Vdout0_5ck104 = 1.8 time = 2100
.meas tran vdout0_5ck104 FIND v(dout0_5) AT=2100.1n

* CHECK dout0_6 Vdout0_6ck104 = 0 time = 2100
.meas tran vdout0_6ck104 FIND v(dout0_6) AT=2100.1n

* CHECK dout0_7 Vdout0_7ck104 = 0 time = 2100
.meas tran vdout0_7ck104 FIND v(dout0_7) AT=2100.1n

* CHECK dout0_8 Vdout0_8ck104 = 1.8 time = 2100
.meas tran vdout0_8ck104 FIND v(dout0_8) AT=2100.1n

* CHECK dout0_9 Vdout0_9ck104 = 1.8 time = 2100
.meas tran vdout0_9ck104 FIND v(dout0_9) AT=2100.1n

* CHECK dout0_10 Vdout0_10ck104 = 1.8 time = 2100
.meas tran vdout0_10ck104 FIND v(dout0_10) AT=2100.1n

* CHECK dout0_11 Vdout0_11ck104 = 0 time = 2100
.meas tran vdout0_11ck104 FIND v(dout0_11) AT=2100.1n

* CHECK dout0_12 Vdout0_12ck104 = 0 time = 2100
.meas tran vdout0_12ck104 FIND v(dout0_12) AT=2100.1n

* CHECK dout0_13 Vdout0_13ck104 = 0 time = 2100
.meas tran vdout0_13ck104 FIND v(dout0_13) AT=2100.1n

* CHECK dout0_14 Vdout0_14ck104 = 0 time = 2100
.meas tran vdout0_14ck104 FIND v(dout0_14) AT=2100.1n

* CHECK dout0_15 Vdout0_15ck104 = 1.8 time = 2100
.meas tran vdout0_15ck104 FIND v(dout0_15) AT=2100.1n

* CHECK dout0_0 Vdout0_0ck105 = 0 time = 2120
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=2120.1n

* CHECK dout0_1 Vdout0_1ck105 = 0 time = 2120
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=2120.1n

* CHECK dout0_2 Vdout0_2ck105 = 0 time = 2120
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=2120.1n

* CHECK dout0_3 Vdout0_3ck105 = 1.8 time = 2120
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=2120.1n

* CHECK dout0_4 Vdout0_4ck105 = 0 time = 2120
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=2120.1n

* CHECK dout0_5 Vdout0_5ck105 = 1.8 time = 2120
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=2120.1n

* CHECK dout0_6 Vdout0_6ck105 = 0 time = 2120
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=2120.1n

* CHECK dout0_7 Vdout0_7ck105 = 1.8 time = 2120
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=2120.1n

* CHECK dout0_8 Vdout0_8ck105 = 0 time = 2120
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=2120.1n

* CHECK dout0_9 Vdout0_9ck105 = 1.8 time = 2120
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=2120.1n

* CHECK dout0_10 Vdout0_10ck105 = 0 time = 2120
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=2120.1n

* CHECK dout0_11 Vdout0_11ck105 = 0 time = 2120
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=2120.1n

* CHECK dout0_12 Vdout0_12ck105 = 0 time = 2120
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=2120.1n

* CHECK dout0_13 Vdout0_13ck105 = 1.8 time = 2120
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=2120.1n

* CHECK dout0_14 Vdout0_14ck105 = 1.8 time = 2120
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=2120.1n

* CHECK dout0_15 Vdout0_15ck105 = 1.8 time = 2120
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=2120.1n

* CHECK dout0_0 Vdout0_0ck108 = 1.8 time = 2180
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=2180.1n

* CHECK dout0_1 Vdout0_1ck108 = 1.8 time = 2180
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=2180.1n

* CHECK dout0_2 Vdout0_2ck108 = 0 time = 2180
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=2180.1n

* CHECK dout0_3 Vdout0_3ck108 = 1.8 time = 2180
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=2180.1n

* CHECK dout0_4 Vdout0_4ck108 = 1.8 time = 2180
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=2180.1n

* CHECK dout0_5 Vdout0_5ck108 = 1.8 time = 2180
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=2180.1n

* CHECK dout0_6 Vdout0_6ck108 = 0 time = 2180
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=2180.1n

* CHECK dout0_7 Vdout0_7ck108 = 0 time = 2180
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=2180.1n

* CHECK dout0_8 Vdout0_8ck108 = 1.8 time = 2180
.meas tran vdout0_8ck108 FIND v(dout0_8) AT=2180.1n

* CHECK dout0_9 Vdout0_9ck108 = 1.8 time = 2180
.meas tran vdout0_9ck108 FIND v(dout0_9) AT=2180.1n

* CHECK dout0_10 Vdout0_10ck108 = 1.8 time = 2180
.meas tran vdout0_10ck108 FIND v(dout0_10) AT=2180.1n

* CHECK dout0_11 Vdout0_11ck108 = 0 time = 2180
.meas tran vdout0_11ck108 FIND v(dout0_11) AT=2180.1n

* CHECK dout0_12 Vdout0_12ck108 = 0 time = 2180
.meas tran vdout0_12ck108 FIND v(dout0_12) AT=2180.1n

* CHECK dout0_13 Vdout0_13ck108 = 0 time = 2180
.meas tran vdout0_13ck108 FIND v(dout0_13) AT=2180.1n

* CHECK dout0_14 Vdout0_14ck108 = 0 time = 2180
.meas tran vdout0_14ck108 FIND v(dout0_14) AT=2180.1n

* CHECK dout0_15 Vdout0_15ck108 = 1.8 time = 2180
.meas tran vdout0_15ck108 FIND v(dout0_15) AT=2180.1n

* CHECK dout0_0 Vdout0_0ck114 = 0 time = 2300
.meas tran vdout0_0ck114 FIND v(dout0_0) AT=2300.1n

* CHECK dout0_1 Vdout0_1ck114 = 0 time = 2300
.meas tran vdout0_1ck114 FIND v(dout0_1) AT=2300.1n

* CHECK dout0_2 Vdout0_2ck114 = 0 time = 2300
.meas tran vdout0_2ck114 FIND v(dout0_2) AT=2300.1n

* CHECK dout0_3 Vdout0_3ck114 = 1.8 time = 2300
.meas tran vdout0_3ck114 FIND v(dout0_3) AT=2300.1n

* CHECK dout0_4 Vdout0_4ck114 = 0 time = 2300
.meas tran vdout0_4ck114 FIND v(dout0_4) AT=2300.1n

* CHECK dout0_5 Vdout0_5ck114 = 1.8 time = 2300
.meas tran vdout0_5ck114 FIND v(dout0_5) AT=2300.1n

* CHECK dout0_6 Vdout0_6ck114 = 0 time = 2300
.meas tran vdout0_6ck114 FIND v(dout0_6) AT=2300.1n

* CHECK dout0_7 Vdout0_7ck114 = 1.8 time = 2300
.meas tran vdout0_7ck114 FIND v(dout0_7) AT=2300.1n

* CHECK dout0_8 Vdout0_8ck114 = 0 time = 2300
.meas tran vdout0_8ck114 FIND v(dout0_8) AT=2300.1n

* CHECK dout0_9 Vdout0_9ck114 = 1.8 time = 2300
.meas tran vdout0_9ck114 FIND v(dout0_9) AT=2300.1n

* CHECK dout0_10 Vdout0_10ck114 = 0 time = 2300
.meas tran vdout0_10ck114 FIND v(dout0_10) AT=2300.1n

* CHECK dout0_11 Vdout0_11ck114 = 0 time = 2300
.meas tran vdout0_11ck114 FIND v(dout0_11) AT=2300.1n

* CHECK dout0_12 Vdout0_12ck114 = 0 time = 2300
.meas tran vdout0_12ck114 FIND v(dout0_12) AT=2300.1n

* CHECK dout0_13 Vdout0_13ck114 = 1.8 time = 2300
.meas tran vdout0_13ck114 FIND v(dout0_13) AT=2300.1n

* CHECK dout0_14 Vdout0_14ck114 = 1.8 time = 2300
.meas tran vdout0_14ck114 FIND v(dout0_14) AT=2300.1n

* CHECK dout0_15 Vdout0_15ck114 = 1.8 time = 2300
.meas tran vdout0_15ck114 FIND v(dout0_15) AT=2300.1n

* CHECK dout0_0 Vdout0_0ck116 = 0 time = 2340
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=2340.1n

* CHECK dout0_1 Vdout0_1ck116 = 1.8 time = 2340
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=2340.1n

* CHECK dout0_2 Vdout0_2ck116 = 0 time = 2340
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=2340.1n

* CHECK dout0_3 Vdout0_3ck116 = 1.8 time = 2340
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=2340.1n

* CHECK dout0_4 Vdout0_4ck116 = 0 time = 2340
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=2340.1n

* CHECK dout0_5 Vdout0_5ck116 = 0 time = 2340
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=2340.1n

* CHECK dout0_6 Vdout0_6ck116 = 1.8 time = 2340
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=2340.1n

* CHECK dout0_7 Vdout0_7ck116 = 0 time = 2340
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=2340.1n

* CHECK dout0_8 Vdout0_8ck116 = 0 time = 2340
.meas tran vdout0_8ck116 FIND v(dout0_8) AT=2340.1n

* CHECK dout0_9 Vdout0_9ck116 = 0 time = 2340
.meas tran vdout0_9ck116 FIND v(dout0_9) AT=2340.1n

* CHECK dout0_10 Vdout0_10ck116 = 1.8 time = 2340
.meas tran vdout0_10ck116 FIND v(dout0_10) AT=2340.1n

* CHECK dout0_11 Vdout0_11ck116 = 1.8 time = 2340
.meas tran vdout0_11ck116 FIND v(dout0_11) AT=2340.1n

* CHECK dout0_12 Vdout0_12ck116 = 0 time = 2340
.meas tran vdout0_12ck116 FIND v(dout0_12) AT=2340.1n

* CHECK dout0_13 Vdout0_13ck116 = 1.8 time = 2340
.meas tran vdout0_13ck116 FIND v(dout0_13) AT=2340.1n

* CHECK dout0_14 Vdout0_14ck116 = 0 time = 2340
.meas tran vdout0_14ck116 FIND v(dout0_14) AT=2340.1n

* CHECK dout0_15 Vdout0_15ck116 = 0 time = 2340
.meas tran vdout0_15ck116 FIND v(dout0_15) AT=2340.1n

* CHECK dout0_0 Vdout0_0ck117 = 0 time = 2360
.meas tran vdout0_0ck117 FIND v(dout0_0) AT=2360.1n

* CHECK dout0_1 Vdout0_1ck117 = 0 time = 2360
.meas tran vdout0_1ck117 FIND v(dout0_1) AT=2360.1n

* CHECK dout0_2 Vdout0_2ck117 = 0 time = 2360
.meas tran vdout0_2ck117 FIND v(dout0_2) AT=2360.1n

* CHECK dout0_3 Vdout0_3ck117 = 0 time = 2360
.meas tran vdout0_3ck117 FIND v(dout0_3) AT=2360.1n

* CHECK dout0_4 Vdout0_4ck117 = 0 time = 2360
.meas tran vdout0_4ck117 FIND v(dout0_4) AT=2360.1n

* CHECK dout0_5 Vdout0_5ck117 = 1.8 time = 2360
.meas tran vdout0_5ck117 FIND v(dout0_5) AT=2360.1n

* CHECK dout0_6 Vdout0_6ck117 = 0 time = 2360
.meas tran vdout0_6ck117 FIND v(dout0_6) AT=2360.1n

* CHECK dout0_7 Vdout0_7ck117 = 1.8 time = 2360
.meas tran vdout0_7ck117 FIND v(dout0_7) AT=2360.1n

* CHECK dout0_8 Vdout0_8ck117 = 1.8 time = 2360
.meas tran vdout0_8ck117 FIND v(dout0_8) AT=2360.1n

* CHECK dout0_9 Vdout0_9ck117 = 1.8 time = 2360
.meas tran vdout0_9ck117 FIND v(dout0_9) AT=2360.1n

* CHECK dout0_10 Vdout0_10ck117 = 0 time = 2360
.meas tran vdout0_10ck117 FIND v(dout0_10) AT=2360.1n

* CHECK dout0_11 Vdout0_11ck117 = 0 time = 2360
.meas tran vdout0_11ck117 FIND v(dout0_11) AT=2360.1n

* CHECK dout0_12 Vdout0_12ck117 = 0 time = 2360
.meas tran vdout0_12ck117 FIND v(dout0_12) AT=2360.1n

* CHECK dout0_13 Vdout0_13ck117 = 1.8 time = 2360
.meas tran vdout0_13ck117 FIND v(dout0_13) AT=2360.1n

* CHECK dout0_14 Vdout0_14ck117 = 1.8 time = 2360
.meas tran vdout0_14ck117 FIND v(dout0_14) AT=2360.1n

* CHECK dout0_15 Vdout0_15ck117 = 0 time = 2360
.meas tran vdout0_15ck117 FIND v(dout0_15) AT=2360.1n

* CHECK dout0_0 Vdout0_0ck118 = 1.8 time = 2380
.meas tran vdout0_0ck118 FIND v(dout0_0) AT=2380.1n

* CHECK dout0_1 Vdout0_1ck118 = 1.8 time = 2380
.meas tran vdout0_1ck118 FIND v(dout0_1) AT=2380.1n

* CHECK dout0_2 Vdout0_2ck118 = 0 time = 2380
.meas tran vdout0_2ck118 FIND v(dout0_2) AT=2380.1n

* CHECK dout0_3 Vdout0_3ck118 = 1.8 time = 2380
.meas tran vdout0_3ck118 FIND v(dout0_3) AT=2380.1n

* CHECK dout0_4 Vdout0_4ck118 = 1.8 time = 2380
.meas tran vdout0_4ck118 FIND v(dout0_4) AT=2380.1n

* CHECK dout0_5 Vdout0_5ck118 = 1.8 time = 2380
.meas tran vdout0_5ck118 FIND v(dout0_5) AT=2380.1n

* CHECK dout0_6 Vdout0_6ck118 = 0 time = 2380
.meas tran vdout0_6ck118 FIND v(dout0_6) AT=2380.1n

* CHECK dout0_7 Vdout0_7ck118 = 0 time = 2380
.meas tran vdout0_7ck118 FIND v(dout0_7) AT=2380.1n

* CHECK dout0_8 Vdout0_8ck118 = 1.8 time = 2380
.meas tran vdout0_8ck118 FIND v(dout0_8) AT=2380.1n

* CHECK dout0_9 Vdout0_9ck118 = 1.8 time = 2380
.meas tran vdout0_9ck118 FIND v(dout0_9) AT=2380.1n

* CHECK dout0_10 Vdout0_10ck118 = 1.8 time = 2380
.meas tran vdout0_10ck118 FIND v(dout0_10) AT=2380.1n

* CHECK dout0_11 Vdout0_11ck118 = 0 time = 2380
.meas tran vdout0_11ck118 FIND v(dout0_11) AT=2380.1n

* CHECK dout0_12 Vdout0_12ck118 = 0 time = 2380
.meas tran vdout0_12ck118 FIND v(dout0_12) AT=2380.1n

* CHECK dout0_13 Vdout0_13ck118 = 0 time = 2380
.meas tran vdout0_13ck118 FIND v(dout0_13) AT=2380.1n

* CHECK dout0_14 Vdout0_14ck118 = 0 time = 2380
.meas tran vdout0_14ck118 FIND v(dout0_14) AT=2380.1n

* CHECK dout0_15 Vdout0_15ck118 = 1.8 time = 2380
.meas tran vdout0_15ck118 FIND v(dout0_15) AT=2380.1n

* CHECK dout0_0 Vdout0_0ck119 = 0 time = 2400
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=2400.1n

* CHECK dout0_1 Vdout0_1ck119 = 0 time = 2400
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=2400.1n

* CHECK dout0_2 Vdout0_2ck119 = 0 time = 2400
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=2400.1n

* CHECK dout0_3 Vdout0_3ck119 = 0 time = 2400
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=2400.1n

* CHECK dout0_4 Vdout0_4ck119 = 0 time = 2400
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=2400.1n

* CHECK dout0_5 Vdout0_5ck119 = 1.8 time = 2400
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=2400.1n

* CHECK dout0_6 Vdout0_6ck119 = 0 time = 2400
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=2400.1n

* CHECK dout0_7 Vdout0_7ck119 = 1.8 time = 2400
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=2400.1n

* CHECK dout0_8 Vdout0_8ck119 = 1.8 time = 2400
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=2400.1n

* CHECK dout0_9 Vdout0_9ck119 = 1.8 time = 2400
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=2400.1n

* CHECK dout0_10 Vdout0_10ck119 = 0 time = 2400
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=2400.1n

* CHECK dout0_11 Vdout0_11ck119 = 0 time = 2400
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=2400.1n

* CHECK dout0_12 Vdout0_12ck119 = 0 time = 2400
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=2400.1n

* CHECK dout0_13 Vdout0_13ck119 = 1.8 time = 2400
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=2400.1n

* CHECK dout0_14 Vdout0_14ck119 = 1.8 time = 2400
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=2400.1n

* CHECK dout0_15 Vdout0_15ck119 = 0 time = 2400
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=2400.1n

* CHECK dout0_0 Vdout0_0ck120 = 0 time = 2420
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=2420.1n

* CHECK dout0_1 Vdout0_1ck120 = 0 time = 2420
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=2420.1n

* CHECK dout0_2 Vdout0_2ck120 = 0 time = 2420
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=2420.1n

* CHECK dout0_3 Vdout0_3ck120 = 0 time = 2420
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=2420.1n

* CHECK dout0_4 Vdout0_4ck120 = 0 time = 2420
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=2420.1n

* CHECK dout0_5 Vdout0_5ck120 = 1.8 time = 2420
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=2420.1n

* CHECK dout0_6 Vdout0_6ck120 = 0 time = 2420
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=2420.1n

* CHECK dout0_7 Vdout0_7ck120 = 1.8 time = 2420
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=2420.1n

* CHECK dout0_8 Vdout0_8ck120 = 1.8 time = 2420
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=2420.1n

* CHECK dout0_9 Vdout0_9ck120 = 1.8 time = 2420
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=2420.1n

* CHECK dout0_10 Vdout0_10ck120 = 0 time = 2420
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=2420.1n

* CHECK dout0_11 Vdout0_11ck120 = 0 time = 2420
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=2420.1n

* CHECK dout0_12 Vdout0_12ck120 = 0 time = 2420
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=2420.1n

* CHECK dout0_13 Vdout0_13ck120 = 1.8 time = 2420
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=2420.1n

* CHECK dout0_14 Vdout0_14ck120 = 1.8 time = 2420
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=2420.1n

* CHECK dout0_15 Vdout0_15ck120 = 0 time = 2420
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=2420.1n

* CHECK dout0_0 Vdout0_0ck126 = 1.8 time = 2540
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=2540.1n

* CHECK dout0_1 Vdout0_1ck126 = 1.8 time = 2540
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=2540.1n

* CHECK dout0_2 Vdout0_2ck126 = 0 time = 2540
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=2540.1n

* CHECK dout0_3 Vdout0_3ck126 = 1.8 time = 2540
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=2540.1n

* CHECK dout0_4 Vdout0_4ck126 = 1.8 time = 2540
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=2540.1n

* CHECK dout0_5 Vdout0_5ck126 = 1.8 time = 2540
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=2540.1n

* CHECK dout0_6 Vdout0_6ck126 = 0 time = 2540
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=2540.1n

* CHECK dout0_7 Vdout0_7ck126 = 1.8 time = 2540
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=2540.1n

* CHECK dout0_8 Vdout0_8ck126 = 1.8 time = 2540
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=2540.1n

* CHECK dout0_9 Vdout0_9ck126 = 1.8 time = 2540
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=2540.1n

* CHECK dout0_10 Vdout0_10ck126 = 1.8 time = 2540
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=2540.1n

* CHECK dout0_11 Vdout0_11ck126 = 1.8 time = 2540
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=2540.1n

* CHECK dout0_12 Vdout0_12ck126 = 1.8 time = 2540
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=2540.1n

* CHECK dout0_13 Vdout0_13ck126 = 0 time = 2540
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=2540.1n

* CHECK dout0_14 Vdout0_14ck126 = 0 time = 2540
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=2540.1n

* CHECK dout0_15 Vdout0_15ck126 = 1.8 time = 2540
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=2540.1n

* CHECK dout0_0 Vdout0_0ck127 = 1.8 time = 2560
.meas tran vdout0_0ck127 FIND v(dout0_0) AT=2560.1n

* CHECK dout0_1 Vdout0_1ck127 = 1.8 time = 2560
.meas tran vdout0_1ck127 FIND v(dout0_1) AT=2560.1n

* CHECK dout0_2 Vdout0_2ck127 = 0 time = 2560
.meas tran vdout0_2ck127 FIND v(dout0_2) AT=2560.1n

* CHECK dout0_3 Vdout0_3ck127 = 1.8 time = 2560
.meas tran vdout0_3ck127 FIND v(dout0_3) AT=2560.1n

* CHECK dout0_4 Vdout0_4ck127 = 1.8 time = 2560
.meas tran vdout0_4ck127 FIND v(dout0_4) AT=2560.1n

* CHECK dout0_5 Vdout0_5ck127 = 1.8 time = 2560
.meas tran vdout0_5ck127 FIND v(dout0_5) AT=2560.1n

* CHECK dout0_6 Vdout0_6ck127 = 0 time = 2560
.meas tran vdout0_6ck127 FIND v(dout0_6) AT=2560.1n

* CHECK dout0_7 Vdout0_7ck127 = 0 time = 2560
.meas tran vdout0_7ck127 FIND v(dout0_7) AT=2560.1n

* CHECK dout0_8 Vdout0_8ck127 = 1.8 time = 2560
.meas tran vdout0_8ck127 FIND v(dout0_8) AT=2560.1n

* CHECK dout0_9 Vdout0_9ck127 = 1.8 time = 2560
.meas tran vdout0_9ck127 FIND v(dout0_9) AT=2560.1n

* CHECK dout0_10 Vdout0_10ck127 = 1.8 time = 2560
.meas tran vdout0_10ck127 FIND v(dout0_10) AT=2560.1n

* CHECK dout0_11 Vdout0_11ck127 = 0 time = 2560
.meas tran vdout0_11ck127 FIND v(dout0_11) AT=2560.1n

* CHECK dout0_12 Vdout0_12ck127 = 0 time = 2560
.meas tran vdout0_12ck127 FIND v(dout0_12) AT=2560.1n

* CHECK dout0_13 Vdout0_13ck127 = 0 time = 2560
.meas tran vdout0_13ck127 FIND v(dout0_13) AT=2560.1n

* CHECK dout0_14 Vdout0_14ck127 = 0 time = 2560
.meas tran vdout0_14ck127 FIND v(dout0_14) AT=2560.1n

* CHECK dout0_15 Vdout0_15ck127 = 1.8 time = 2560
.meas tran vdout0_15ck127 FIND v(dout0_15) AT=2560.1n

* CHECK dout0_0 Vdout0_0ck132 = 0 time = 2660
.meas tran vdout0_0ck132 FIND v(dout0_0) AT=2660.1n

* CHECK dout0_1 Vdout0_1ck132 = 1.8 time = 2660
.meas tran vdout0_1ck132 FIND v(dout0_1) AT=2660.1n

* CHECK dout0_2 Vdout0_2ck132 = 0 time = 2660
.meas tran vdout0_2ck132 FIND v(dout0_2) AT=2660.1n

* CHECK dout0_3 Vdout0_3ck132 = 0 time = 2660
.meas tran vdout0_3ck132 FIND v(dout0_3) AT=2660.1n

* CHECK dout0_4 Vdout0_4ck132 = 1.8 time = 2660
.meas tran vdout0_4ck132 FIND v(dout0_4) AT=2660.1n

* CHECK dout0_5 Vdout0_5ck132 = 1.8 time = 2660
.meas tran vdout0_5ck132 FIND v(dout0_5) AT=2660.1n

* CHECK dout0_6 Vdout0_6ck132 = 1.8 time = 2660
.meas tran vdout0_6ck132 FIND v(dout0_6) AT=2660.1n

* CHECK dout0_7 Vdout0_7ck132 = 0 time = 2660
.meas tran vdout0_7ck132 FIND v(dout0_7) AT=2660.1n

* CHECK dout0_8 Vdout0_8ck132 = 0 time = 2660
.meas tran vdout0_8ck132 FIND v(dout0_8) AT=2660.1n

* CHECK dout0_9 Vdout0_9ck132 = 1.8 time = 2660
.meas tran vdout0_9ck132 FIND v(dout0_9) AT=2660.1n

* CHECK dout0_10 Vdout0_10ck132 = 0 time = 2660
.meas tran vdout0_10ck132 FIND v(dout0_10) AT=2660.1n

* CHECK dout0_11 Vdout0_11ck132 = 0 time = 2660
.meas tran vdout0_11ck132 FIND v(dout0_11) AT=2660.1n

* CHECK dout0_12 Vdout0_12ck132 = 0 time = 2660
.meas tran vdout0_12ck132 FIND v(dout0_12) AT=2660.1n

* CHECK dout0_13 Vdout0_13ck132 = 1.8 time = 2660
.meas tran vdout0_13ck132 FIND v(dout0_13) AT=2660.1n

* CHECK dout0_14 Vdout0_14ck132 = 0 time = 2660
.meas tran vdout0_14ck132 FIND v(dout0_14) AT=2660.1n

* CHECK dout0_15 Vdout0_15ck132 = 0 time = 2660
.meas tran vdout0_15ck132 FIND v(dout0_15) AT=2660.1n

* CHECK dout0_0 Vdout0_0ck134 = 0 time = 2700
.meas tran vdout0_0ck134 FIND v(dout0_0) AT=2700.1n

* CHECK dout0_1 Vdout0_1ck134 = 1.8 time = 2700
.meas tran vdout0_1ck134 FIND v(dout0_1) AT=2700.1n

* CHECK dout0_2 Vdout0_2ck134 = 0 time = 2700
.meas tran vdout0_2ck134 FIND v(dout0_2) AT=2700.1n

* CHECK dout0_3 Vdout0_3ck134 = 1.8 time = 2700
.meas tran vdout0_3ck134 FIND v(dout0_3) AT=2700.1n

* CHECK dout0_4 Vdout0_4ck134 = 0 time = 2700
.meas tran vdout0_4ck134 FIND v(dout0_4) AT=2700.1n

* CHECK dout0_5 Vdout0_5ck134 = 0 time = 2700
.meas tran vdout0_5ck134 FIND v(dout0_5) AT=2700.1n

* CHECK dout0_6 Vdout0_6ck134 = 1.8 time = 2700
.meas tran vdout0_6ck134 FIND v(dout0_6) AT=2700.1n

* CHECK dout0_7 Vdout0_7ck134 = 0 time = 2700
.meas tran vdout0_7ck134 FIND v(dout0_7) AT=2700.1n

* CHECK dout0_8 Vdout0_8ck134 = 1.8 time = 2700
.meas tran vdout0_8ck134 FIND v(dout0_8) AT=2700.1n

* CHECK dout0_9 Vdout0_9ck134 = 0 time = 2700
.meas tran vdout0_9ck134 FIND v(dout0_9) AT=2700.1n

* CHECK dout0_10 Vdout0_10ck134 = 0 time = 2700
.meas tran vdout0_10ck134 FIND v(dout0_10) AT=2700.1n

* CHECK dout0_11 Vdout0_11ck134 = 0 time = 2700
.meas tran vdout0_11ck134 FIND v(dout0_11) AT=2700.1n

* CHECK dout0_12 Vdout0_12ck134 = 1.8 time = 2700
.meas tran vdout0_12ck134 FIND v(dout0_12) AT=2700.1n

* CHECK dout0_13 Vdout0_13ck134 = 0 time = 2700
.meas tran vdout0_13ck134 FIND v(dout0_13) AT=2700.1n

* CHECK dout0_14 Vdout0_14ck134 = 0 time = 2700
.meas tran vdout0_14ck134 FIND v(dout0_14) AT=2700.1n

* CHECK dout0_15 Vdout0_15ck134 = 1.8 time = 2700
.meas tran vdout0_15ck134 FIND v(dout0_15) AT=2700.1n

* CHECK dout0_0 Vdout0_0ck140 = 1.8 time = 2820
.meas tran vdout0_0ck140 FIND v(dout0_0) AT=2820.1n

* CHECK dout0_1 Vdout0_1ck140 = 1.8 time = 2820
.meas tran vdout0_1ck140 FIND v(dout0_1) AT=2820.1n

* CHECK dout0_2 Vdout0_2ck140 = 1.8 time = 2820
.meas tran vdout0_2ck140 FIND v(dout0_2) AT=2820.1n

* CHECK dout0_3 Vdout0_3ck140 = 1.8 time = 2820
.meas tran vdout0_3ck140 FIND v(dout0_3) AT=2820.1n

* CHECK dout0_4 Vdout0_4ck140 = 0 time = 2820
.meas tran vdout0_4ck140 FIND v(dout0_4) AT=2820.1n

* CHECK dout0_5 Vdout0_5ck140 = 0 time = 2820
.meas tran vdout0_5ck140 FIND v(dout0_5) AT=2820.1n

* CHECK dout0_6 Vdout0_6ck140 = 0 time = 2820
.meas tran vdout0_6ck140 FIND v(dout0_6) AT=2820.1n

* CHECK dout0_7 Vdout0_7ck140 = 1.8 time = 2820
.meas tran vdout0_7ck140 FIND v(dout0_7) AT=2820.1n

* CHECK dout0_8 Vdout0_8ck140 = 1.8 time = 2820
.meas tran vdout0_8ck140 FIND v(dout0_8) AT=2820.1n

* CHECK dout0_9 Vdout0_9ck140 = 0 time = 2820
.meas tran vdout0_9ck140 FIND v(dout0_9) AT=2820.1n

* CHECK dout0_10 Vdout0_10ck140 = 1.8 time = 2820
.meas tran vdout0_10ck140 FIND v(dout0_10) AT=2820.1n

* CHECK dout0_11 Vdout0_11ck140 = 1.8 time = 2820
.meas tran vdout0_11ck140 FIND v(dout0_11) AT=2820.1n

* CHECK dout0_12 Vdout0_12ck140 = 0 time = 2820
.meas tran vdout0_12ck140 FIND v(dout0_12) AT=2820.1n

* CHECK dout0_13 Vdout0_13ck140 = 1.8 time = 2820
.meas tran vdout0_13ck140 FIND v(dout0_13) AT=2820.1n

* CHECK dout0_14 Vdout0_14ck140 = 0 time = 2820
.meas tran vdout0_14ck140 FIND v(dout0_14) AT=2820.1n

* CHECK dout0_15 Vdout0_15ck140 = 1.8 time = 2820
.meas tran vdout0_15ck140 FIND v(dout0_15) AT=2820.1n

* CHECK dout0_0 Vdout0_0ck145 = 0 time = 2920
.meas tran vdout0_0ck145 FIND v(dout0_0) AT=2920.1n

* CHECK dout0_1 Vdout0_1ck145 = 1.8 time = 2920
.meas tran vdout0_1ck145 FIND v(dout0_1) AT=2920.1n

* CHECK dout0_2 Vdout0_2ck145 = 1.8 time = 2920
.meas tran vdout0_2ck145 FIND v(dout0_2) AT=2920.1n

* CHECK dout0_3 Vdout0_3ck145 = 0 time = 2920
.meas tran vdout0_3ck145 FIND v(dout0_3) AT=2920.1n

* CHECK dout0_4 Vdout0_4ck145 = 1.8 time = 2920
.meas tran vdout0_4ck145 FIND v(dout0_4) AT=2920.1n

* CHECK dout0_5 Vdout0_5ck145 = 0 time = 2920
.meas tran vdout0_5ck145 FIND v(dout0_5) AT=2920.1n

* CHECK dout0_6 Vdout0_6ck145 = 0 time = 2920
.meas tran vdout0_6ck145 FIND v(dout0_6) AT=2920.1n

* CHECK dout0_7 Vdout0_7ck145 = 0 time = 2920
.meas tran vdout0_7ck145 FIND v(dout0_7) AT=2920.1n

* CHECK dout0_8 Vdout0_8ck145 = 0 time = 2920
.meas tran vdout0_8ck145 FIND v(dout0_8) AT=2920.1n

* CHECK dout0_9 Vdout0_9ck145 = 1.8 time = 2920
.meas tran vdout0_9ck145 FIND v(dout0_9) AT=2920.1n

* CHECK dout0_10 Vdout0_10ck145 = 1.8 time = 2920
.meas tran vdout0_10ck145 FIND v(dout0_10) AT=2920.1n

* CHECK dout0_11 Vdout0_11ck145 = 1.8 time = 2920
.meas tran vdout0_11ck145 FIND v(dout0_11) AT=2920.1n

* CHECK dout0_12 Vdout0_12ck145 = 0 time = 2920
.meas tran vdout0_12ck145 FIND v(dout0_12) AT=2920.1n

* CHECK dout0_13 Vdout0_13ck145 = 1.8 time = 2920
.meas tran vdout0_13ck145 FIND v(dout0_13) AT=2920.1n

* CHECK dout0_14 Vdout0_14ck145 = 0 time = 2920
.meas tran vdout0_14ck145 FIND v(dout0_14) AT=2920.1n

* CHECK dout0_15 Vdout0_15ck145 = 0 time = 2920
.meas tran vdout0_15ck145 FIND v(dout0_15) AT=2920.1n

* CHECK dout0_0 Vdout0_0ck147 = 1.8 time = 2960
.meas tran vdout0_0ck147 FIND v(dout0_0) AT=2960.1n

* CHECK dout0_1 Vdout0_1ck147 = 1.8 time = 2960
.meas tran vdout0_1ck147 FIND v(dout0_1) AT=2960.1n

* CHECK dout0_2 Vdout0_2ck147 = 0 time = 2960
.meas tran vdout0_2ck147 FIND v(dout0_2) AT=2960.1n

* CHECK dout0_3 Vdout0_3ck147 = 1.8 time = 2960
.meas tran vdout0_3ck147 FIND v(dout0_3) AT=2960.1n

* CHECK dout0_4 Vdout0_4ck147 = 1.8 time = 2960
.meas tran vdout0_4ck147 FIND v(dout0_4) AT=2960.1n

* CHECK dout0_5 Vdout0_5ck147 = 1.8 time = 2960
.meas tran vdout0_5ck147 FIND v(dout0_5) AT=2960.1n

* CHECK dout0_6 Vdout0_6ck147 = 0 time = 2960
.meas tran vdout0_6ck147 FIND v(dout0_6) AT=2960.1n

* CHECK dout0_7 Vdout0_7ck147 = 0 time = 2960
.meas tran vdout0_7ck147 FIND v(dout0_7) AT=2960.1n

* CHECK dout0_8 Vdout0_8ck147 = 0 time = 2960
.meas tran vdout0_8ck147 FIND v(dout0_8) AT=2960.1n

* CHECK dout0_9 Vdout0_9ck147 = 1.8 time = 2960
.meas tran vdout0_9ck147 FIND v(dout0_9) AT=2960.1n

* CHECK dout0_10 Vdout0_10ck147 = 0 time = 2960
.meas tran vdout0_10ck147 FIND v(dout0_10) AT=2960.1n

* CHECK dout0_11 Vdout0_11ck147 = 1.8 time = 2960
.meas tran vdout0_11ck147 FIND v(dout0_11) AT=2960.1n

* CHECK dout0_12 Vdout0_12ck147 = 1.8 time = 2960
.meas tran vdout0_12ck147 FIND v(dout0_12) AT=2960.1n

* CHECK dout0_13 Vdout0_13ck147 = 1.8 time = 2960
.meas tran vdout0_13ck147 FIND v(dout0_13) AT=2960.1n

* CHECK dout0_14 Vdout0_14ck147 = 0 time = 2960
.meas tran vdout0_14ck147 FIND v(dout0_14) AT=2960.1n

* CHECK dout0_15 Vdout0_15ck147 = 1.8 time = 2960
.meas tran vdout0_15ck147 FIND v(dout0_15) AT=2960.1n

* CHECK dout0_0 Vdout0_0ck148 = 0 time = 2980
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=2980.1n

* CHECK dout0_1 Vdout0_1ck148 = 0 time = 2980
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=2980.1n

* CHECK dout0_2 Vdout0_2ck148 = 0 time = 2980
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=2980.1n

* CHECK dout0_3 Vdout0_3ck148 = 0 time = 2980
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=2980.1n

* CHECK dout0_4 Vdout0_4ck148 = 0 time = 2980
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=2980.1n

* CHECK dout0_5 Vdout0_5ck148 = 1.8 time = 2980
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=2980.1n

* CHECK dout0_6 Vdout0_6ck148 = 0 time = 2980
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=2980.1n

* CHECK dout0_7 Vdout0_7ck148 = 0 time = 2980
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=2980.1n

* CHECK dout0_8 Vdout0_8ck148 = 0 time = 2980
.meas tran vdout0_8ck148 FIND v(dout0_8) AT=2980.1n

* CHECK dout0_9 Vdout0_9ck148 = 0 time = 2980
.meas tran vdout0_9ck148 FIND v(dout0_9) AT=2980.1n

* CHECK dout0_10 Vdout0_10ck148 = 1.8 time = 2980
.meas tran vdout0_10ck148 FIND v(dout0_10) AT=2980.1n

* CHECK dout0_11 Vdout0_11ck148 = 1.8 time = 2980
.meas tran vdout0_11ck148 FIND v(dout0_11) AT=2980.1n

* CHECK dout0_12 Vdout0_12ck148 = 1.8 time = 2980
.meas tran vdout0_12ck148 FIND v(dout0_12) AT=2980.1n

* CHECK dout0_13 Vdout0_13ck148 = 1.8 time = 2980
.meas tran vdout0_13ck148 FIND v(dout0_13) AT=2980.1n

* CHECK dout0_14 Vdout0_14ck148 = 1.8 time = 2980
.meas tran vdout0_14ck148 FIND v(dout0_14) AT=2980.1n

* CHECK dout0_15 Vdout0_15ck148 = 0 time = 2980
.meas tran vdout0_15ck148 FIND v(dout0_15) AT=2980.1n

* CHECK dout0_0 Vdout0_0ck150 = 1.8 time = 3020
.meas tran vdout0_0ck150 FIND v(dout0_0) AT=3020.1n

* CHECK dout0_1 Vdout0_1ck150 = 1.8 time = 3020
.meas tran vdout0_1ck150 FIND v(dout0_1) AT=3020.1n

* CHECK dout0_2 Vdout0_2ck150 = 0 time = 3020
.meas tran vdout0_2ck150 FIND v(dout0_2) AT=3020.1n

* CHECK dout0_3 Vdout0_3ck150 = 0 time = 3020
.meas tran vdout0_3ck150 FIND v(dout0_3) AT=3020.1n

* CHECK dout0_4 Vdout0_4ck150 = 0 time = 3020
.meas tran vdout0_4ck150 FIND v(dout0_4) AT=3020.1n

* CHECK dout0_5 Vdout0_5ck150 = 0 time = 3020
.meas tran vdout0_5ck150 FIND v(dout0_5) AT=3020.1n

* CHECK dout0_6 Vdout0_6ck150 = 0 time = 3020
.meas tran vdout0_6ck150 FIND v(dout0_6) AT=3020.1n

* CHECK dout0_7 Vdout0_7ck150 = 0 time = 3020
.meas tran vdout0_7ck150 FIND v(dout0_7) AT=3020.1n

* CHECK dout0_8 Vdout0_8ck150 = 0 time = 3020
.meas tran vdout0_8ck150 FIND v(dout0_8) AT=3020.1n

* CHECK dout0_9 Vdout0_9ck150 = 0 time = 3020
.meas tran vdout0_9ck150 FIND v(dout0_9) AT=3020.1n

* CHECK dout0_10 Vdout0_10ck150 = 1.8 time = 3020
.meas tran vdout0_10ck150 FIND v(dout0_10) AT=3020.1n

* CHECK dout0_11 Vdout0_11ck150 = 0 time = 3020
.meas tran vdout0_11ck150 FIND v(dout0_11) AT=3020.1n

* CHECK dout0_12 Vdout0_12ck150 = 1.8 time = 3020
.meas tran vdout0_12ck150 FIND v(dout0_12) AT=3020.1n

* CHECK dout0_13 Vdout0_13ck150 = 1.8 time = 3020
.meas tran vdout0_13ck150 FIND v(dout0_13) AT=3020.1n

* CHECK dout0_14 Vdout0_14ck150 = 1.8 time = 3020
.meas tran vdout0_14ck150 FIND v(dout0_14) AT=3020.1n

* CHECK dout0_15 Vdout0_15ck150 = 1.8 time = 3020
.meas tran vdout0_15ck150 FIND v(dout0_15) AT=3020.1n

* CHECK dout0_0 Vdout0_0ck151 = 0 time = 3040
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=3040.1n

* CHECK dout0_1 Vdout0_1ck151 = 1.8 time = 3040
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=3040.1n

* CHECK dout0_2 Vdout0_2ck151 = 1.8 time = 3040
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=3040.1n

* CHECK dout0_3 Vdout0_3ck151 = 0 time = 3040
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=3040.1n

* CHECK dout0_4 Vdout0_4ck151 = 1.8 time = 3040
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=3040.1n

* CHECK dout0_5 Vdout0_5ck151 = 0 time = 3040
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=3040.1n

* CHECK dout0_6 Vdout0_6ck151 = 0 time = 3040
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=3040.1n

* CHECK dout0_7 Vdout0_7ck151 = 0 time = 3040
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=3040.1n

* CHECK dout0_8 Vdout0_8ck151 = 0 time = 3040
.meas tran vdout0_8ck151 FIND v(dout0_8) AT=3040.1n

* CHECK dout0_9 Vdout0_9ck151 = 1.8 time = 3040
.meas tran vdout0_9ck151 FIND v(dout0_9) AT=3040.1n

* CHECK dout0_10 Vdout0_10ck151 = 1.8 time = 3040
.meas tran vdout0_10ck151 FIND v(dout0_10) AT=3040.1n

* CHECK dout0_11 Vdout0_11ck151 = 1.8 time = 3040
.meas tran vdout0_11ck151 FIND v(dout0_11) AT=3040.1n

* CHECK dout0_12 Vdout0_12ck151 = 0 time = 3040
.meas tran vdout0_12ck151 FIND v(dout0_12) AT=3040.1n

* CHECK dout0_13 Vdout0_13ck151 = 1.8 time = 3040
.meas tran vdout0_13ck151 FIND v(dout0_13) AT=3040.1n

* CHECK dout0_14 Vdout0_14ck151 = 0 time = 3040
.meas tran vdout0_14ck151 FIND v(dout0_14) AT=3040.1n

* CHECK dout0_15 Vdout0_15ck151 = 0 time = 3040
.meas tran vdout0_15ck151 FIND v(dout0_15) AT=3040.1n

* CHECK dout0_0 Vdout0_0ck152 = 0 time = 3060
.meas tran vdout0_0ck152 FIND v(dout0_0) AT=3060.1n

* CHECK dout0_1 Vdout0_1ck152 = 0 time = 3060
.meas tran vdout0_1ck152 FIND v(dout0_1) AT=3060.1n

* CHECK dout0_2 Vdout0_2ck152 = 0 time = 3060
.meas tran vdout0_2ck152 FIND v(dout0_2) AT=3060.1n

* CHECK dout0_3 Vdout0_3ck152 = 0 time = 3060
.meas tran vdout0_3ck152 FIND v(dout0_3) AT=3060.1n

* CHECK dout0_4 Vdout0_4ck152 = 0 time = 3060
.meas tran vdout0_4ck152 FIND v(dout0_4) AT=3060.1n

* CHECK dout0_5 Vdout0_5ck152 = 1.8 time = 3060
.meas tran vdout0_5ck152 FIND v(dout0_5) AT=3060.1n

* CHECK dout0_6 Vdout0_6ck152 = 0 time = 3060
.meas tran vdout0_6ck152 FIND v(dout0_6) AT=3060.1n

* CHECK dout0_7 Vdout0_7ck152 = 0 time = 3060
.meas tran vdout0_7ck152 FIND v(dout0_7) AT=3060.1n

* CHECK dout0_8 Vdout0_8ck152 = 0 time = 3060
.meas tran vdout0_8ck152 FIND v(dout0_8) AT=3060.1n

* CHECK dout0_9 Vdout0_9ck152 = 0 time = 3060
.meas tran vdout0_9ck152 FIND v(dout0_9) AT=3060.1n

* CHECK dout0_10 Vdout0_10ck152 = 1.8 time = 3060
.meas tran vdout0_10ck152 FIND v(dout0_10) AT=3060.1n

* CHECK dout0_11 Vdout0_11ck152 = 1.8 time = 3060
.meas tran vdout0_11ck152 FIND v(dout0_11) AT=3060.1n

* CHECK dout0_12 Vdout0_12ck152 = 1.8 time = 3060
.meas tran vdout0_12ck152 FIND v(dout0_12) AT=3060.1n

* CHECK dout0_13 Vdout0_13ck152 = 1.8 time = 3060
.meas tran vdout0_13ck152 FIND v(dout0_13) AT=3060.1n

* CHECK dout0_14 Vdout0_14ck152 = 1.8 time = 3060
.meas tran vdout0_14ck152 FIND v(dout0_14) AT=3060.1n

* CHECK dout0_15 Vdout0_15ck152 = 0 time = 3060
.meas tran vdout0_15ck152 FIND v(dout0_15) AT=3060.1n

* CHECK dout0_0 Vdout0_0ck164 = 0 time = 3300
.meas tran vdout0_0ck164 FIND v(dout0_0) AT=3300.1n

* CHECK dout0_1 Vdout0_1ck164 = 0 time = 3300
.meas tran vdout0_1ck164 FIND v(dout0_1) AT=3300.1n

* CHECK dout0_2 Vdout0_2ck164 = 0 time = 3300
.meas tran vdout0_2ck164 FIND v(dout0_2) AT=3300.1n

* CHECK dout0_3 Vdout0_3ck164 = 0 time = 3300
.meas tran vdout0_3ck164 FIND v(dout0_3) AT=3300.1n

* CHECK dout0_4 Vdout0_4ck164 = 0 time = 3300
.meas tran vdout0_4ck164 FIND v(dout0_4) AT=3300.1n

* CHECK dout0_5 Vdout0_5ck164 = 1.8 time = 3300
.meas tran vdout0_5ck164 FIND v(dout0_5) AT=3300.1n

* CHECK dout0_6 Vdout0_6ck164 = 0 time = 3300
.meas tran vdout0_6ck164 FIND v(dout0_6) AT=3300.1n

* CHECK dout0_7 Vdout0_7ck164 = 0 time = 3300
.meas tran vdout0_7ck164 FIND v(dout0_7) AT=3300.1n

* CHECK dout0_8 Vdout0_8ck164 = 0 time = 3300
.meas tran vdout0_8ck164 FIND v(dout0_8) AT=3300.1n

* CHECK dout0_9 Vdout0_9ck164 = 0 time = 3300
.meas tran vdout0_9ck164 FIND v(dout0_9) AT=3300.1n

* CHECK dout0_10 Vdout0_10ck164 = 1.8 time = 3300
.meas tran vdout0_10ck164 FIND v(dout0_10) AT=3300.1n

* CHECK dout0_11 Vdout0_11ck164 = 1.8 time = 3300
.meas tran vdout0_11ck164 FIND v(dout0_11) AT=3300.1n

* CHECK dout0_12 Vdout0_12ck164 = 1.8 time = 3300
.meas tran vdout0_12ck164 FIND v(dout0_12) AT=3300.1n

* CHECK dout0_13 Vdout0_13ck164 = 1.8 time = 3300
.meas tran vdout0_13ck164 FIND v(dout0_13) AT=3300.1n

* CHECK dout0_14 Vdout0_14ck164 = 1.8 time = 3300
.meas tran vdout0_14ck164 FIND v(dout0_14) AT=3300.1n

* CHECK dout0_15 Vdout0_15ck164 = 0 time = 3300
.meas tran vdout0_15ck164 FIND v(dout0_15) AT=3300.1n

* CHECK dout0_0 Vdout0_0ck166 = 0 time = 3340
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=3340.1n

* CHECK dout0_1 Vdout0_1ck166 = 0 time = 3340
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=3340.1n

* CHECK dout0_2 Vdout0_2ck166 = 0 time = 3340
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=3340.1n

* CHECK dout0_3 Vdout0_3ck166 = 0 time = 3340
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=3340.1n

* CHECK dout0_4 Vdout0_4ck166 = 0 time = 3340
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=3340.1n

* CHECK dout0_5 Vdout0_5ck166 = 1.8 time = 3340
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=3340.1n

* CHECK dout0_6 Vdout0_6ck166 = 0 time = 3340
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=3340.1n

* CHECK dout0_7 Vdout0_7ck166 = 0 time = 3340
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=3340.1n

* CHECK dout0_8 Vdout0_8ck166 = 0 time = 3340
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=3340.1n

* CHECK dout0_9 Vdout0_9ck166 = 0 time = 3340
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=3340.1n

* CHECK dout0_10 Vdout0_10ck166 = 1.8 time = 3340
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=3340.1n

* CHECK dout0_11 Vdout0_11ck166 = 1.8 time = 3340
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=3340.1n

* CHECK dout0_12 Vdout0_12ck166 = 1.8 time = 3340
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=3340.1n

* CHECK dout0_13 Vdout0_13ck166 = 1.8 time = 3340
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=3340.1n

* CHECK dout0_14 Vdout0_14ck166 = 1.8 time = 3340
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=3340.1n

* CHECK dout0_15 Vdout0_15ck166 = 0 time = 3340
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=3340.1n

* CHECK dout0_0 Vdout0_0ck167 = 1.8 time = 3360
.meas tran vdout0_0ck167 FIND v(dout0_0) AT=3360.1n

* CHECK dout0_1 Vdout0_1ck167 = 1.8 time = 3360
.meas tran vdout0_1ck167 FIND v(dout0_1) AT=3360.1n

* CHECK dout0_2 Vdout0_2ck167 = 1.8 time = 3360
.meas tran vdout0_2ck167 FIND v(dout0_2) AT=3360.1n

* CHECK dout0_3 Vdout0_3ck167 = 0 time = 3360
.meas tran vdout0_3ck167 FIND v(dout0_3) AT=3360.1n

* CHECK dout0_4 Vdout0_4ck167 = 0 time = 3360
.meas tran vdout0_4ck167 FIND v(dout0_4) AT=3360.1n

* CHECK dout0_5 Vdout0_5ck167 = 1.8 time = 3360
.meas tran vdout0_5ck167 FIND v(dout0_5) AT=3360.1n

* CHECK dout0_6 Vdout0_6ck167 = 1.8 time = 3360
.meas tran vdout0_6ck167 FIND v(dout0_6) AT=3360.1n

* CHECK dout0_7 Vdout0_7ck167 = 0 time = 3360
.meas tran vdout0_7ck167 FIND v(dout0_7) AT=3360.1n

* CHECK dout0_8 Vdout0_8ck167 = 0 time = 3360
.meas tran vdout0_8ck167 FIND v(dout0_8) AT=3360.1n

* CHECK dout0_9 Vdout0_9ck167 = 0 time = 3360
.meas tran vdout0_9ck167 FIND v(dout0_9) AT=3360.1n

* CHECK dout0_10 Vdout0_10ck167 = 0 time = 3360
.meas tran vdout0_10ck167 FIND v(dout0_10) AT=3360.1n

* CHECK dout0_11 Vdout0_11ck167 = 1.8 time = 3360
.meas tran vdout0_11ck167 FIND v(dout0_11) AT=3360.1n

* CHECK dout0_12 Vdout0_12ck167 = 0 time = 3360
.meas tran vdout0_12ck167 FIND v(dout0_12) AT=3360.1n

* CHECK dout0_13 Vdout0_13ck167 = 1.8 time = 3360
.meas tran vdout0_13ck167 FIND v(dout0_13) AT=3360.1n

* CHECK dout0_14 Vdout0_14ck167 = 1.8 time = 3360
.meas tran vdout0_14ck167 FIND v(dout0_14) AT=3360.1n

* CHECK dout0_15 Vdout0_15ck167 = 1.8 time = 3360
.meas tran vdout0_15ck167 FIND v(dout0_15) AT=3360.1n

* CHECK dout0_0 Vdout0_0ck168 = 1.8 time = 3380
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=3380.1n

* CHECK dout0_1 Vdout0_1ck168 = 0 time = 3380
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=3380.1n

* CHECK dout0_2 Vdout0_2ck168 = 1.8 time = 3380
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=3380.1n

* CHECK dout0_3 Vdout0_3ck168 = 0 time = 3380
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=3380.1n

* CHECK dout0_4 Vdout0_4ck168 = 0 time = 3380
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=3380.1n

* CHECK dout0_5 Vdout0_5ck168 = 0 time = 3380
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=3380.1n

* CHECK dout0_6 Vdout0_6ck168 = 0 time = 3380
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=3380.1n

* CHECK dout0_7 Vdout0_7ck168 = 0 time = 3380
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=3380.1n

* CHECK dout0_8 Vdout0_8ck168 = 1.8 time = 3380
.meas tran vdout0_8ck168 FIND v(dout0_8) AT=3380.1n

* CHECK dout0_9 Vdout0_9ck168 = 1.8 time = 3380
.meas tran vdout0_9ck168 FIND v(dout0_9) AT=3380.1n

* CHECK dout0_10 Vdout0_10ck168 = 0 time = 3380
.meas tran vdout0_10ck168 FIND v(dout0_10) AT=3380.1n

* CHECK dout0_11 Vdout0_11ck168 = 1.8 time = 3380
.meas tran vdout0_11ck168 FIND v(dout0_11) AT=3380.1n

* CHECK dout0_12 Vdout0_12ck168 = 1.8 time = 3380
.meas tran vdout0_12ck168 FIND v(dout0_12) AT=3380.1n

* CHECK dout0_13 Vdout0_13ck168 = 0 time = 3380
.meas tran vdout0_13ck168 FIND v(dout0_13) AT=3380.1n

* CHECK dout0_14 Vdout0_14ck168 = 0 time = 3380
.meas tran vdout0_14ck168 FIND v(dout0_14) AT=3380.1n

* CHECK dout0_15 Vdout0_15ck168 = 0 time = 3380
.meas tran vdout0_15ck168 FIND v(dout0_15) AT=3380.1n

* CHECK dout0_0 Vdout0_0ck170 = 0 time = 3420
.meas tran vdout0_0ck170 FIND v(dout0_0) AT=3420.1n

* CHECK dout0_1 Vdout0_1ck170 = 0 time = 3420
.meas tran vdout0_1ck170 FIND v(dout0_1) AT=3420.1n

* CHECK dout0_2 Vdout0_2ck170 = 0 time = 3420
.meas tran vdout0_2ck170 FIND v(dout0_2) AT=3420.1n

* CHECK dout0_3 Vdout0_3ck170 = 0 time = 3420
.meas tran vdout0_3ck170 FIND v(dout0_3) AT=3420.1n

* CHECK dout0_4 Vdout0_4ck170 = 0 time = 3420
.meas tran vdout0_4ck170 FIND v(dout0_4) AT=3420.1n

* CHECK dout0_5 Vdout0_5ck170 = 1.8 time = 3420
.meas tran vdout0_5ck170 FIND v(dout0_5) AT=3420.1n

* CHECK dout0_6 Vdout0_6ck170 = 0 time = 3420
.meas tran vdout0_6ck170 FIND v(dout0_6) AT=3420.1n

* CHECK dout0_7 Vdout0_7ck170 = 0 time = 3420
.meas tran vdout0_7ck170 FIND v(dout0_7) AT=3420.1n

* CHECK dout0_8 Vdout0_8ck170 = 0 time = 3420
.meas tran vdout0_8ck170 FIND v(dout0_8) AT=3420.1n

* CHECK dout0_9 Vdout0_9ck170 = 0 time = 3420
.meas tran vdout0_9ck170 FIND v(dout0_9) AT=3420.1n

* CHECK dout0_10 Vdout0_10ck170 = 1.8 time = 3420
.meas tran vdout0_10ck170 FIND v(dout0_10) AT=3420.1n

* CHECK dout0_11 Vdout0_11ck170 = 1.8 time = 3420
.meas tran vdout0_11ck170 FIND v(dout0_11) AT=3420.1n

* CHECK dout0_12 Vdout0_12ck170 = 1.8 time = 3420
.meas tran vdout0_12ck170 FIND v(dout0_12) AT=3420.1n

* CHECK dout0_13 Vdout0_13ck170 = 1.8 time = 3420
.meas tran vdout0_13ck170 FIND v(dout0_13) AT=3420.1n

* CHECK dout0_14 Vdout0_14ck170 = 1.8 time = 3420
.meas tran vdout0_14ck170 FIND v(dout0_14) AT=3420.1n

* CHECK dout0_15 Vdout0_15ck170 = 0 time = 3420
.meas tran vdout0_15ck170 FIND v(dout0_15) AT=3420.1n

* CHECK dout0_0 Vdout0_0ck171 = 1.8 time = 3440
.meas tran vdout0_0ck171 FIND v(dout0_0) AT=3440.1n

* CHECK dout0_1 Vdout0_1ck171 = 1.8 time = 3440
.meas tran vdout0_1ck171 FIND v(dout0_1) AT=3440.1n

* CHECK dout0_2 Vdout0_2ck171 = 1.8 time = 3440
.meas tran vdout0_2ck171 FIND v(dout0_2) AT=3440.1n

* CHECK dout0_3 Vdout0_3ck171 = 0 time = 3440
.meas tran vdout0_3ck171 FIND v(dout0_3) AT=3440.1n

* CHECK dout0_4 Vdout0_4ck171 = 0 time = 3440
.meas tran vdout0_4ck171 FIND v(dout0_4) AT=3440.1n

* CHECK dout0_5 Vdout0_5ck171 = 1.8 time = 3440
.meas tran vdout0_5ck171 FIND v(dout0_5) AT=3440.1n

* CHECK dout0_6 Vdout0_6ck171 = 1.8 time = 3440
.meas tran vdout0_6ck171 FIND v(dout0_6) AT=3440.1n

* CHECK dout0_7 Vdout0_7ck171 = 0 time = 3440
.meas tran vdout0_7ck171 FIND v(dout0_7) AT=3440.1n

* CHECK dout0_8 Vdout0_8ck171 = 0 time = 3440
.meas tran vdout0_8ck171 FIND v(dout0_8) AT=3440.1n

* CHECK dout0_9 Vdout0_9ck171 = 0 time = 3440
.meas tran vdout0_9ck171 FIND v(dout0_9) AT=3440.1n

* CHECK dout0_10 Vdout0_10ck171 = 0 time = 3440
.meas tran vdout0_10ck171 FIND v(dout0_10) AT=3440.1n

* CHECK dout0_11 Vdout0_11ck171 = 1.8 time = 3440
.meas tran vdout0_11ck171 FIND v(dout0_11) AT=3440.1n

* CHECK dout0_12 Vdout0_12ck171 = 0 time = 3440
.meas tran vdout0_12ck171 FIND v(dout0_12) AT=3440.1n

* CHECK dout0_13 Vdout0_13ck171 = 1.8 time = 3440
.meas tran vdout0_13ck171 FIND v(dout0_13) AT=3440.1n

* CHECK dout0_14 Vdout0_14ck171 = 1.8 time = 3440
.meas tran vdout0_14ck171 FIND v(dout0_14) AT=3440.1n

* CHECK dout0_15 Vdout0_15ck171 = 1.8 time = 3440
.meas tran vdout0_15ck171 FIND v(dout0_15) AT=3440.1n

* CHECK dout0_0 Vdout0_0ck172 = 0 time = 3460
.meas tran vdout0_0ck172 FIND v(dout0_0) AT=3460.1n

* CHECK dout0_1 Vdout0_1ck172 = 0 time = 3460
.meas tran vdout0_1ck172 FIND v(dout0_1) AT=3460.1n

* CHECK dout0_2 Vdout0_2ck172 = 0 time = 3460
.meas tran vdout0_2ck172 FIND v(dout0_2) AT=3460.1n

* CHECK dout0_3 Vdout0_3ck172 = 0 time = 3460
.meas tran vdout0_3ck172 FIND v(dout0_3) AT=3460.1n

* CHECK dout0_4 Vdout0_4ck172 = 0 time = 3460
.meas tran vdout0_4ck172 FIND v(dout0_4) AT=3460.1n

* CHECK dout0_5 Vdout0_5ck172 = 1.8 time = 3460
.meas tran vdout0_5ck172 FIND v(dout0_5) AT=3460.1n

* CHECK dout0_6 Vdout0_6ck172 = 0 time = 3460
.meas tran vdout0_6ck172 FIND v(dout0_6) AT=3460.1n

* CHECK dout0_7 Vdout0_7ck172 = 0 time = 3460
.meas tran vdout0_7ck172 FIND v(dout0_7) AT=3460.1n

* CHECK dout0_8 Vdout0_8ck172 = 0 time = 3460
.meas tran vdout0_8ck172 FIND v(dout0_8) AT=3460.1n

* CHECK dout0_9 Vdout0_9ck172 = 0 time = 3460
.meas tran vdout0_9ck172 FIND v(dout0_9) AT=3460.1n

* CHECK dout0_10 Vdout0_10ck172 = 1.8 time = 3460
.meas tran vdout0_10ck172 FIND v(dout0_10) AT=3460.1n

* CHECK dout0_11 Vdout0_11ck172 = 1.8 time = 3460
.meas tran vdout0_11ck172 FIND v(dout0_11) AT=3460.1n

* CHECK dout0_12 Vdout0_12ck172 = 1.8 time = 3460
.meas tran vdout0_12ck172 FIND v(dout0_12) AT=3460.1n

* CHECK dout0_13 Vdout0_13ck172 = 1.8 time = 3460
.meas tran vdout0_13ck172 FIND v(dout0_13) AT=3460.1n

* CHECK dout0_14 Vdout0_14ck172 = 1.8 time = 3460
.meas tran vdout0_14ck172 FIND v(dout0_14) AT=3460.1n

* CHECK dout0_15 Vdout0_15ck172 = 0 time = 3460
.meas tran vdout0_15ck172 FIND v(dout0_15) AT=3460.1n

* CHECK dout0_0 Vdout0_0ck174 = 1.8 time = 3500
.meas tran vdout0_0ck174 FIND v(dout0_0) AT=3500.1n

* CHECK dout0_1 Vdout0_1ck174 = 0 time = 3500
.meas tran vdout0_1ck174 FIND v(dout0_1) AT=3500.1n

* CHECK dout0_2 Vdout0_2ck174 = 1.8 time = 3500
.meas tran vdout0_2ck174 FIND v(dout0_2) AT=3500.1n

* CHECK dout0_3 Vdout0_3ck174 = 0 time = 3500
.meas tran vdout0_3ck174 FIND v(dout0_3) AT=3500.1n

* CHECK dout0_4 Vdout0_4ck174 = 0 time = 3500
.meas tran vdout0_4ck174 FIND v(dout0_4) AT=3500.1n

* CHECK dout0_5 Vdout0_5ck174 = 0 time = 3500
.meas tran vdout0_5ck174 FIND v(dout0_5) AT=3500.1n

* CHECK dout0_6 Vdout0_6ck174 = 0 time = 3500
.meas tran vdout0_6ck174 FIND v(dout0_6) AT=3500.1n

* CHECK dout0_7 Vdout0_7ck174 = 0 time = 3500
.meas tran vdout0_7ck174 FIND v(dout0_7) AT=3500.1n

* CHECK dout0_8 Vdout0_8ck174 = 1.8 time = 3500
.meas tran vdout0_8ck174 FIND v(dout0_8) AT=3500.1n

* CHECK dout0_9 Vdout0_9ck174 = 1.8 time = 3500
.meas tran vdout0_9ck174 FIND v(dout0_9) AT=3500.1n

* CHECK dout0_10 Vdout0_10ck174 = 0 time = 3500
.meas tran vdout0_10ck174 FIND v(dout0_10) AT=3500.1n

* CHECK dout0_11 Vdout0_11ck174 = 1.8 time = 3500
.meas tran vdout0_11ck174 FIND v(dout0_11) AT=3500.1n

* CHECK dout0_12 Vdout0_12ck174 = 1.8 time = 3500
.meas tran vdout0_12ck174 FIND v(dout0_12) AT=3500.1n

* CHECK dout0_13 Vdout0_13ck174 = 0 time = 3500
.meas tran vdout0_13ck174 FIND v(dout0_13) AT=3500.1n

* CHECK dout0_14 Vdout0_14ck174 = 0 time = 3500
.meas tran vdout0_14ck174 FIND v(dout0_14) AT=3500.1n

* CHECK dout0_15 Vdout0_15ck174 = 0 time = 3500
.meas tran vdout0_15ck174 FIND v(dout0_15) AT=3500.1n

* CHECK dout0_0 Vdout0_0ck175 = 0 time = 3520
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=3520.1n

* CHECK dout0_1 Vdout0_1ck175 = 0 time = 3520
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=3520.1n

* CHECK dout0_2 Vdout0_2ck175 = 0 time = 3520
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=3520.1n

* CHECK dout0_3 Vdout0_3ck175 = 0 time = 3520
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=3520.1n

* CHECK dout0_4 Vdout0_4ck175 = 0 time = 3520
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=3520.1n

* CHECK dout0_5 Vdout0_5ck175 = 1.8 time = 3520
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=3520.1n

* CHECK dout0_6 Vdout0_6ck175 = 0 time = 3520
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=3520.1n

* CHECK dout0_7 Vdout0_7ck175 = 0 time = 3520
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=3520.1n

* CHECK dout0_8 Vdout0_8ck175 = 0 time = 3520
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=3520.1n

* CHECK dout0_9 Vdout0_9ck175 = 0 time = 3520
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=3520.1n

* CHECK dout0_10 Vdout0_10ck175 = 1.8 time = 3520
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=3520.1n

* CHECK dout0_11 Vdout0_11ck175 = 1.8 time = 3520
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=3520.1n

* CHECK dout0_12 Vdout0_12ck175 = 1.8 time = 3520
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=3520.1n

* CHECK dout0_13 Vdout0_13ck175 = 1.8 time = 3520
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=3520.1n

* CHECK dout0_14 Vdout0_14ck175 = 1.8 time = 3520
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=3520.1n

* CHECK dout0_15 Vdout0_15ck175 = 0 time = 3520
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=3520.1n

* CHECK dout0_0 Vdout0_0ck177 = 1.8 time = 3560
.meas tran vdout0_0ck177 FIND v(dout0_0) AT=3560.1n

* CHECK dout0_1 Vdout0_1ck177 = 1.8 time = 3560
.meas tran vdout0_1ck177 FIND v(dout0_1) AT=3560.1n

* CHECK dout0_2 Vdout0_2ck177 = 0 time = 3560
.meas tran vdout0_2ck177 FIND v(dout0_2) AT=3560.1n

* CHECK dout0_3 Vdout0_3ck177 = 1.8 time = 3560
.meas tran vdout0_3ck177 FIND v(dout0_3) AT=3560.1n

* CHECK dout0_4 Vdout0_4ck177 = 0 time = 3560
.meas tran vdout0_4ck177 FIND v(dout0_4) AT=3560.1n

* CHECK dout0_5 Vdout0_5ck177 = 1.8 time = 3560
.meas tran vdout0_5ck177 FIND v(dout0_5) AT=3560.1n

* CHECK dout0_6 Vdout0_6ck177 = 1.8 time = 3560
.meas tran vdout0_6ck177 FIND v(dout0_6) AT=3560.1n

* CHECK dout0_7 Vdout0_7ck177 = 1.8 time = 3560
.meas tran vdout0_7ck177 FIND v(dout0_7) AT=3560.1n

* CHECK dout0_8 Vdout0_8ck177 = 1.8 time = 3560
.meas tran vdout0_8ck177 FIND v(dout0_8) AT=3560.1n

* CHECK dout0_9 Vdout0_9ck177 = 0 time = 3560
.meas tran vdout0_9ck177 FIND v(dout0_9) AT=3560.1n

* CHECK dout0_10 Vdout0_10ck177 = 0 time = 3560
.meas tran vdout0_10ck177 FIND v(dout0_10) AT=3560.1n

* CHECK dout0_11 Vdout0_11ck177 = 0 time = 3560
.meas tran vdout0_11ck177 FIND v(dout0_11) AT=3560.1n

* CHECK dout0_12 Vdout0_12ck177 = 1.8 time = 3560
.meas tran vdout0_12ck177 FIND v(dout0_12) AT=3560.1n

* CHECK dout0_13 Vdout0_13ck177 = 0 time = 3560
.meas tran vdout0_13ck177 FIND v(dout0_13) AT=3560.1n

* CHECK dout0_14 Vdout0_14ck177 = 0 time = 3560
.meas tran vdout0_14ck177 FIND v(dout0_14) AT=3560.1n

* CHECK dout0_15 Vdout0_15ck177 = 1.8 time = 3560
.meas tran vdout0_15ck177 FIND v(dout0_15) AT=3560.1n

* CHECK dout0_0 Vdout0_0ck178 = 1.8 time = 3580
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=3580.1n

* CHECK dout0_1 Vdout0_1ck178 = 1.8 time = 3580
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=3580.1n

* CHECK dout0_2 Vdout0_2ck178 = 1.8 time = 3580
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=3580.1n

* CHECK dout0_3 Vdout0_3ck178 = 0 time = 3580
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=3580.1n

* CHECK dout0_4 Vdout0_4ck178 = 0 time = 3580
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=3580.1n

* CHECK dout0_5 Vdout0_5ck178 = 1.8 time = 3580
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=3580.1n

* CHECK dout0_6 Vdout0_6ck178 = 1.8 time = 3580
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=3580.1n

* CHECK dout0_7 Vdout0_7ck178 = 0 time = 3580
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=3580.1n

* CHECK dout0_8 Vdout0_8ck178 = 0 time = 3580
.meas tran vdout0_8ck178 FIND v(dout0_8) AT=3580.1n

* CHECK dout0_9 Vdout0_9ck178 = 0 time = 3580
.meas tran vdout0_9ck178 FIND v(dout0_9) AT=3580.1n

* CHECK dout0_10 Vdout0_10ck178 = 0 time = 3580
.meas tran vdout0_10ck178 FIND v(dout0_10) AT=3580.1n

* CHECK dout0_11 Vdout0_11ck178 = 1.8 time = 3580
.meas tran vdout0_11ck178 FIND v(dout0_11) AT=3580.1n

* CHECK dout0_12 Vdout0_12ck178 = 0 time = 3580
.meas tran vdout0_12ck178 FIND v(dout0_12) AT=3580.1n

* CHECK dout0_13 Vdout0_13ck178 = 1.8 time = 3580
.meas tran vdout0_13ck178 FIND v(dout0_13) AT=3580.1n

* CHECK dout0_14 Vdout0_14ck178 = 1.8 time = 3580
.meas tran vdout0_14ck178 FIND v(dout0_14) AT=3580.1n

* CHECK dout0_15 Vdout0_15ck178 = 1.8 time = 3580
.meas tran vdout0_15ck178 FIND v(dout0_15) AT=3580.1n

* CHECK dout0_0 Vdout0_0ck181 = 0 time = 3640
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=3640.1n

* CHECK dout0_1 Vdout0_1ck181 = 0 time = 3640
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=3640.1n

* CHECK dout0_2 Vdout0_2ck181 = 0 time = 3640
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=3640.1n

* CHECK dout0_3 Vdout0_3ck181 = 0 time = 3640
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=3640.1n

* CHECK dout0_4 Vdout0_4ck181 = 0 time = 3640
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=3640.1n

* CHECK dout0_5 Vdout0_5ck181 = 1.8 time = 3640
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=3640.1n

* CHECK dout0_6 Vdout0_6ck181 = 0 time = 3640
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=3640.1n

* CHECK dout0_7 Vdout0_7ck181 = 0 time = 3640
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=3640.1n

* CHECK dout0_8 Vdout0_8ck181 = 0 time = 3640
.meas tran vdout0_8ck181 FIND v(dout0_8) AT=3640.1n

* CHECK dout0_9 Vdout0_9ck181 = 0 time = 3640
.meas tran vdout0_9ck181 FIND v(dout0_9) AT=3640.1n

* CHECK dout0_10 Vdout0_10ck181 = 1.8 time = 3640
.meas tran vdout0_10ck181 FIND v(dout0_10) AT=3640.1n

* CHECK dout0_11 Vdout0_11ck181 = 1.8 time = 3640
.meas tran vdout0_11ck181 FIND v(dout0_11) AT=3640.1n

* CHECK dout0_12 Vdout0_12ck181 = 1.8 time = 3640
.meas tran vdout0_12ck181 FIND v(dout0_12) AT=3640.1n

* CHECK dout0_13 Vdout0_13ck181 = 1.8 time = 3640
.meas tran vdout0_13ck181 FIND v(dout0_13) AT=3640.1n

* CHECK dout0_14 Vdout0_14ck181 = 1.8 time = 3640
.meas tran vdout0_14ck181 FIND v(dout0_14) AT=3640.1n

* CHECK dout0_15 Vdout0_15ck181 = 0 time = 3640
.meas tran vdout0_15ck181 FIND v(dout0_15) AT=3640.1n

* CHECK dout0_0 Vdout0_0ck183 = 1.8 time = 3680
.meas tran vdout0_0ck183 FIND v(dout0_0) AT=3680.1n

* CHECK dout0_1 Vdout0_1ck183 = 1.8 time = 3680
.meas tran vdout0_1ck183 FIND v(dout0_1) AT=3680.1n

* CHECK dout0_2 Vdout0_2ck183 = 0 time = 3680
.meas tran vdout0_2ck183 FIND v(dout0_2) AT=3680.1n

* CHECK dout0_3 Vdout0_3ck183 = 1.8 time = 3680
.meas tran vdout0_3ck183 FIND v(dout0_3) AT=3680.1n

* CHECK dout0_4 Vdout0_4ck183 = 0 time = 3680
.meas tran vdout0_4ck183 FIND v(dout0_4) AT=3680.1n

* CHECK dout0_5 Vdout0_5ck183 = 1.8 time = 3680
.meas tran vdout0_5ck183 FIND v(dout0_5) AT=3680.1n

* CHECK dout0_6 Vdout0_6ck183 = 1.8 time = 3680
.meas tran vdout0_6ck183 FIND v(dout0_6) AT=3680.1n

* CHECK dout0_7 Vdout0_7ck183 = 1.8 time = 3680
.meas tran vdout0_7ck183 FIND v(dout0_7) AT=3680.1n

* CHECK dout0_8 Vdout0_8ck183 = 1.8 time = 3680
.meas tran vdout0_8ck183 FIND v(dout0_8) AT=3680.1n

* CHECK dout0_9 Vdout0_9ck183 = 0 time = 3680
.meas tran vdout0_9ck183 FIND v(dout0_9) AT=3680.1n

* CHECK dout0_10 Vdout0_10ck183 = 0 time = 3680
.meas tran vdout0_10ck183 FIND v(dout0_10) AT=3680.1n

* CHECK dout0_11 Vdout0_11ck183 = 0 time = 3680
.meas tran vdout0_11ck183 FIND v(dout0_11) AT=3680.1n

* CHECK dout0_12 Vdout0_12ck183 = 1.8 time = 3680
.meas tran vdout0_12ck183 FIND v(dout0_12) AT=3680.1n

* CHECK dout0_13 Vdout0_13ck183 = 0 time = 3680
.meas tran vdout0_13ck183 FIND v(dout0_13) AT=3680.1n

* CHECK dout0_14 Vdout0_14ck183 = 0 time = 3680
.meas tran vdout0_14ck183 FIND v(dout0_14) AT=3680.1n

* CHECK dout0_15 Vdout0_15ck183 = 1.8 time = 3680
.meas tran vdout0_15ck183 FIND v(dout0_15) AT=3680.1n

* CHECK dout0_0 Vdout0_0ck184 = 0 time = 3700
.meas tran vdout0_0ck184 FIND v(dout0_0) AT=3700.1n

* CHECK dout0_1 Vdout0_1ck184 = 0 time = 3700
.meas tran vdout0_1ck184 FIND v(dout0_1) AT=3700.1n

* CHECK dout0_2 Vdout0_2ck184 = 0 time = 3700
.meas tran vdout0_2ck184 FIND v(dout0_2) AT=3700.1n

* CHECK dout0_3 Vdout0_3ck184 = 0 time = 3700
.meas tran vdout0_3ck184 FIND v(dout0_3) AT=3700.1n

* CHECK dout0_4 Vdout0_4ck184 = 0 time = 3700
.meas tran vdout0_4ck184 FIND v(dout0_4) AT=3700.1n

* CHECK dout0_5 Vdout0_5ck184 = 0 time = 3700
.meas tran vdout0_5ck184 FIND v(dout0_5) AT=3700.1n

* CHECK dout0_6 Vdout0_6ck184 = 0 time = 3700
.meas tran vdout0_6ck184 FIND v(dout0_6) AT=3700.1n

* CHECK dout0_7 Vdout0_7ck184 = 1.8 time = 3700
.meas tran vdout0_7ck184 FIND v(dout0_7) AT=3700.1n

* CHECK dout0_8 Vdout0_8ck184 = 1.8 time = 3700
.meas tran vdout0_8ck184 FIND v(dout0_8) AT=3700.1n

* CHECK dout0_9 Vdout0_9ck184 = 1.8 time = 3700
.meas tran vdout0_9ck184 FIND v(dout0_9) AT=3700.1n

* CHECK dout0_10 Vdout0_10ck184 = 1.8 time = 3700
.meas tran vdout0_10ck184 FIND v(dout0_10) AT=3700.1n

* CHECK dout0_11 Vdout0_11ck184 = 1.8 time = 3700
.meas tran vdout0_11ck184 FIND v(dout0_11) AT=3700.1n

* CHECK dout0_12 Vdout0_12ck184 = 1.8 time = 3700
.meas tran vdout0_12ck184 FIND v(dout0_12) AT=3700.1n

* CHECK dout0_13 Vdout0_13ck184 = 1.8 time = 3700
.meas tran vdout0_13ck184 FIND v(dout0_13) AT=3700.1n

* CHECK dout0_14 Vdout0_14ck184 = 0 time = 3700
.meas tran vdout0_14ck184 FIND v(dout0_14) AT=3700.1n

* CHECK dout0_15 Vdout0_15ck184 = 0 time = 3700
.meas tran vdout0_15ck184 FIND v(dout0_15) AT=3700.1n

* CHECK dout0_0 Vdout0_0ck185 = 0 time = 3720
.meas tran vdout0_0ck185 FIND v(dout0_0) AT=3720.1n

* CHECK dout0_1 Vdout0_1ck185 = 0 time = 3720
.meas tran vdout0_1ck185 FIND v(dout0_1) AT=3720.1n

* CHECK dout0_2 Vdout0_2ck185 = 1.8 time = 3720
.meas tran vdout0_2ck185 FIND v(dout0_2) AT=3720.1n

* CHECK dout0_3 Vdout0_3ck185 = 1.8 time = 3720
.meas tran vdout0_3ck185 FIND v(dout0_3) AT=3720.1n

* CHECK dout0_4 Vdout0_4ck185 = 1.8 time = 3720
.meas tran vdout0_4ck185 FIND v(dout0_4) AT=3720.1n

* CHECK dout0_5 Vdout0_5ck185 = 1.8 time = 3720
.meas tran vdout0_5ck185 FIND v(dout0_5) AT=3720.1n

* CHECK dout0_6 Vdout0_6ck185 = 1.8 time = 3720
.meas tran vdout0_6ck185 FIND v(dout0_6) AT=3720.1n

* CHECK dout0_7 Vdout0_7ck185 = 1.8 time = 3720
.meas tran vdout0_7ck185 FIND v(dout0_7) AT=3720.1n

* CHECK dout0_8 Vdout0_8ck185 = 1.8 time = 3720
.meas tran vdout0_8ck185 FIND v(dout0_8) AT=3720.1n

* CHECK dout0_9 Vdout0_9ck185 = 1.8 time = 3720
.meas tran vdout0_9ck185 FIND v(dout0_9) AT=3720.1n

* CHECK dout0_10 Vdout0_10ck185 = 0 time = 3720
.meas tran vdout0_10ck185 FIND v(dout0_10) AT=3720.1n

* CHECK dout0_11 Vdout0_11ck185 = 0 time = 3720
.meas tran vdout0_11ck185 FIND v(dout0_11) AT=3720.1n

* CHECK dout0_12 Vdout0_12ck185 = 0 time = 3720
.meas tran vdout0_12ck185 FIND v(dout0_12) AT=3720.1n

* CHECK dout0_13 Vdout0_13ck185 = 0 time = 3720
.meas tran vdout0_13ck185 FIND v(dout0_13) AT=3720.1n

* CHECK dout0_14 Vdout0_14ck185 = 1.8 time = 3720
.meas tran vdout0_14ck185 FIND v(dout0_14) AT=3720.1n

* CHECK dout0_15 Vdout0_15ck185 = 0 time = 3720
.meas tran vdout0_15ck185 FIND v(dout0_15) AT=3720.1n

* CHECK dout0_0 Vdout0_0ck187 = 0 time = 3760
.meas tran vdout0_0ck187 FIND v(dout0_0) AT=3760.1n

* CHECK dout0_1 Vdout0_1ck187 = 0 time = 3760
.meas tran vdout0_1ck187 FIND v(dout0_1) AT=3760.1n

* CHECK dout0_2 Vdout0_2ck187 = 0 time = 3760
.meas tran vdout0_2ck187 FIND v(dout0_2) AT=3760.1n

* CHECK dout0_3 Vdout0_3ck187 = 0 time = 3760
.meas tran vdout0_3ck187 FIND v(dout0_3) AT=3760.1n

* CHECK dout0_4 Vdout0_4ck187 = 0 time = 3760
.meas tran vdout0_4ck187 FIND v(dout0_4) AT=3760.1n

* CHECK dout0_5 Vdout0_5ck187 = 0 time = 3760
.meas tran vdout0_5ck187 FIND v(dout0_5) AT=3760.1n

* CHECK dout0_6 Vdout0_6ck187 = 0 time = 3760
.meas tran vdout0_6ck187 FIND v(dout0_6) AT=3760.1n

* CHECK dout0_7 Vdout0_7ck187 = 1.8 time = 3760
.meas tran vdout0_7ck187 FIND v(dout0_7) AT=3760.1n

* CHECK dout0_8 Vdout0_8ck187 = 1.8 time = 3760
.meas tran vdout0_8ck187 FIND v(dout0_8) AT=3760.1n

* CHECK dout0_9 Vdout0_9ck187 = 1.8 time = 3760
.meas tran vdout0_9ck187 FIND v(dout0_9) AT=3760.1n

* CHECK dout0_10 Vdout0_10ck187 = 1.8 time = 3760
.meas tran vdout0_10ck187 FIND v(dout0_10) AT=3760.1n

* CHECK dout0_11 Vdout0_11ck187 = 1.8 time = 3760
.meas tran vdout0_11ck187 FIND v(dout0_11) AT=3760.1n

* CHECK dout0_12 Vdout0_12ck187 = 1.8 time = 3760
.meas tran vdout0_12ck187 FIND v(dout0_12) AT=3760.1n

* CHECK dout0_13 Vdout0_13ck187 = 1.8 time = 3760
.meas tran vdout0_13ck187 FIND v(dout0_13) AT=3760.1n

* CHECK dout0_14 Vdout0_14ck187 = 0 time = 3760
.meas tran vdout0_14ck187 FIND v(dout0_14) AT=3760.1n

* CHECK dout0_15 Vdout0_15ck187 = 0 time = 3760
.meas tran vdout0_15ck187 FIND v(dout0_15) AT=3760.1n

* CHECK dout0_0 Vdout0_0ck188 = 0 time = 3780
.meas tran vdout0_0ck188 FIND v(dout0_0) AT=3780.1n

* CHECK dout0_1 Vdout0_1ck188 = 0 time = 3780
.meas tran vdout0_1ck188 FIND v(dout0_1) AT=3780.1n

* CHECK dout0_2 Vdout0_2ck188 = 0 time = 3780
.meas tran vdout0_2ck188 FIND v(dout0_2) AT=3780.1n

* CHECK dout0_3 Vdout0_3ck188 = 0 time = 3780
.meas tran vdout0_3ck188 FIND v(dout0_3) AT=3780.1n

* CHECK dout0_4 Vdout0_4ck188 = 0 time = 3780
.meas tran vdout0_4ck188 FIND v(dout0_4) AT=3780.1n

* CHECK dout0_5 Vdout0_5ck188 = 0 time = 3780
.meas tran vdout0_5ck188 FIND v(dout0_5) AT=3780.1n

* CHECK dout0_6 Vdout0_6ck188 = 0 time = 3780
.meas tran vdout0_6ck188 FIND v(dout0_6) AT=3780.1n

* CHECK dout0_7 Vdout0_7ck188 = 1.8 time = 3780
.meas tran vdout0_7ck188 FIND v(dout0_7) AT=3780.1n

* CHECK dout0_8 Vdout0_8ck188 = 1.8 time = 3780
.meas tran vdout0_8ck188 FIND v(dout0_8) AT=3780.1n

* CHECK dout0_9 Vdout0_9ck188 = 1.8 time = 3780
.meas tran vdout0_9ck188 FIND v(dout0_9) AT=3780.1n

* CHECK dout0_10 Vdout0_10ck188 = 1.8 time = 3780
.meas tran vdout0_10ck188 FIND v(dout0_10) AT=3780.1n

* CHECK dout0_11 Vdout0_11ck188 = 1.8 time = 3780
.meas tran vdout0_11ck188 FIND v(dout0_11) AT=3780.1n

* CHECK dout0_12 Vdout0_12ck188 = 1.8 time = 3780
.meas tran vdout0_12ck188 FIND v(dout0_12) AT=3780.1n

* CHECK dout0_13 Vdout0_13ck188 = 1.8 time = 3780
.meas tran vdout0_13ck188 FIND v(dout0_13) AT=3780.1n

* CHECK dout0_14 Vdout0_14ck188 = 0 time = 3780
.meas tran vdout0_14ck188 FIND v(dout0_14) AT=3780.1n

* CHECK dout0_15 Vdout0_15ck188 = 0 time = 3780
.meas tran vdout0_15ck188 FIND v(dout0_15) AT=3780.1n

* CHECK dout0_0 Vdout0_0ck189 = 1.8 time = 3800
.meas tran vdout0_0ck189 FIND v(dout0_0) AT=3800.1n

* CHECK dout0_1 Vdout0_1ck189 = 1.8 time = 3800
.meas tran vdout0_1ck189 FIND v(dout0_1) AT=3800.1n

* CHECK dout0_2 Vdout0_2ck189 = 1.8 time = 3800
.meas tran vdout0_2ck189 FIND v(dout0_2) AT=3800.1n

* CHECK dout0_3 Vdout0_3ck189 = 0 time = 3800
.meas tran vdout0_3ck189 FIND v(dout0_3) AT=3800.1n

* CHECK dout0_4 Vdout0_4ck189 = 0 time = 3800
.meas tran vdout0_4ck189 FIND v(dout0_4) AT=3800.1n

* CHECK dout0_5 Vdout0_5ck189 = 1.8 time = 3800
.meas tran vdout0_5ck189 FIND v(dout0_5) AT=3800.1n

* CHECK dout0_6 Vdout0_6ck189 = 1.8 time = 3800
.meas tran vdout0_6ck189 FIND v(dout0_6) AT=3800.1n

* CHECK dout0_7 Vdout0_7ck189 = 0 time = 3800
.meas tran vdout0_7ck189 FIND v(dout0_7) AT=3800.1n

* CHECK dout0_8 Vdout0_8ck189 = 0 time = 3800
.meas tran vdout0_8ck189 FIND v(dout0_8) AT=3800.1n

* CHECK dout0_9 Vdout0_9ck189 = 0 time = 3800
.meas tran vdout0_9ck189 FIND v(dout0_9) AT=3800.1n

* CHECK dout0_10 Vdout0_10ck189 = 0 time = 3800
.meas tran vdout0_10ck189 FIND v(dout0_10) AT=3800.1n

* CHECK dout0_11 Vdout0_11ck189 = 1.8 time = 3800
.meas tran vdout0_11ck189 FIND v(dout0_11) AT=3800.1n

* CHECK dout0_12 Vdout0_12ck189 = 0 time = 3800
.meas tran vdout0_12ck189 FIND v(dout0_12) AT=3800.1n

* CHECK dout0_13 Vdout0_13ck189 = 1.8 time = 3800
.meas tran vdout0_13ck189 FIND v(dout0_13) AT=3800.1n

* CHECK dout0_14 Vdout0_14ck189 = 1.8 time = 3800
.meas tran vdout0_14ck189 FIND v(dout0_14) AT=3800.1n

* CHECK dout0_15 Vdout0_15ck189 = 1.8 time = 3800
.meas tran vdout0_15ck189 FIND v(dout0_15) AT=3800.1n

* CHECK dout0_0 Vdout0_0ck190 = 0 time = 3820
.meas tran vdout0_0ck190 FIND v(dout0_0) AT=3820.1n

* CHECK dout0_1 Vdout0_1ck190 = 0 time = 3820
.meas tran vdout0_1ck190 FIND v(dout0_1) AT=3820.1n

* CHECK dout0_2 Vdout0_2ck190 = 1.8 time = 3820
.meas tran vdout0_2ck190 FIND v(dout0_2) AT=3820.1n

* CHECK dout0_3 Vdout0_3ck190 = 1.8 time = 3820
.meas tran vdout0_3ck190 FIND v(dout0_3) AT=3820.1n

* CHECK dout0_4 Vdout0_4ck190 = 1.8 time = 3820
.meas tran vdout0_4ck190 FIND v(dout0_4) AT=3820.1n

* CHECK dout0_5 Vdout0_5ck190 = 1.8 time = 3820
.meas tran vdout0_5ck190 FIND v(dout0_5) AT=3820.1n

* CHECK dout0_6 Vdout0_6ck190 = 1.8 time = 3820
.meas tran vdout0_6ck190 FIND v(dout0_6) AT=3820.1n

* CHECK dout0_7 Vdout0_7ck190 = 1.8 time = 3820
.meas tran vdout0_7ck190 FIND v(dout0_7) AT=3820.1n

* CHECK dout0_8 Vdout0_8ck190 = 1.8 time = 3820
.meas tran vdout0_8ck190 FIND v(dout0_8) AT=3820.1n

* CHECK dout0_9 Vdout0_9ck190 = 1.8 time = 3820
.meas tran vdout0_9ck190 FIND v(dout0_9) AT=3820.1n

* CHECK dout0_10 Vdout0_10ck190 = 0 time = 3820
.meas tran vdout0_10ck190 FIND v(dout0_10) AT=3820.1n

* CHECK dout0_11 Vdout0_11ck190 = 0 time = 3820
.meas tran vdout0_11ck190 FIND v(dout0_11) AT=3820.1n

* CHECK dout0_12 Vdout0_12ck190 = 0 time = 3820
.meas tran vdout0_12ck190 FIND v(dout0_12) AT=3820.1n

* CHECK dout0_13 Vdout0_13ck190 = 0 time = 3820
.meas tran vdout0_13ck190 FIND v(dout0_13) AT=3820.1n

* CHECK dout0_14 Vdout0_14ck190 = 1.8 time = 3820
.meas tran vdout0_14ck190 FIND v(dout0_14) AT=3820.1n

* CHECK dout0_15 Vdout0_15ck190 = 0 time = 3820
.meas tran vdout0_15ck190 FIND v(dout0_15) AT=3820.1n

* CHECK dout0_0 Vdout0_0ck192 = 0 time = 3860
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=3860.1n

* CHECK dout0_1 Vdout0_1ck192 = 0 time = 3860
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=3860.1n

* CHECK dout0_2 Vdout0_2ck192 = 1.8 time = 3860
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=3860.1n

* CHECK dout0_3 Vdout0_3ck192 = 1.8 time = 3860
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=3860.1n

* CHECK dout0_4 Vdout0_4ck192 = 1.8 time = 3860
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=3860.1n

* CHECK dout0_5 Vdout0_5ck192 = 1.8 time = 3860
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=3860.1n

* CHECK dout0_6 Vdout0_6ck192 = 1.8 time = 3860
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=3860.1n

* CHECK dout0_7 Vdout0_7ck192 = 1.8 time = 3860
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=3860.1n

* CHECK dout0_8 Vdout0_8ck192 = 1.8 time = 3860
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=3860.1n

* CHECK dout0_9 Vdout0_9ck192 = 1.8 time = 3860
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=3860.1n

* CHECK dout0_10 Vdout0_10ck192 = 0 time = 3860
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=3860.1n

* CHECK dout0_11 Vdout0_11ck192 = 0 time = 3860
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=3860.1n

* CHECK dout0_12 Vdout0_12ck192 = 0 time = 3860
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=3860.1n

* CHECK dout0_13 Vdout0_13ck192 = 0 time = 3860
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=3860.1n

* CHECK dout0_14 Vdout0_14ck192 = 1.8 time = 3860
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=3860.1n

* CHECK dout0_15 Vdout0_15ck192 = 0 time = 3860
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=3860.1n

* CHECK dout0_0 Vdout0_0ck196 = 0 time = 3940
.meas tran vdout0_0ck196 FIND v(dout0_0) AT=3940.1n

* CHECK dout0_1 Vdout0_1ck196 = 0 time = 3940
.meas tran vdout0_1ck196 FIND v(dout0_1) AT=3940.1n

* CHECK dout0_2 Vdout0_2ck196 = 0 time = 3940
.meas tran vdout0_2ck196 FIND v(dout0_2) AT=3940.1n

* CHECK dout0_3 Vdout0_3ck196 = 0 time = 3940
.meas tran vdout0_3ck196 FIND v(dout0_3) AT=3940.1n

* CHECK dout0_4 Vdout0_4ck196 = 0 time = 3940
.meas tran vdout0_4ck196 FIND v(dout0_4) AT=3940.1n

* CHECK dout0_5 Vdout0_5ck196 = 0 time = 3940
.meas tran vdout0_5ck196 FIND v(dout0_5) AT=3940.1n

* CHECK dout0_6 Vdout0_6ck196 = 0 time = 3940
.meas tran vdout0_6ck196 FIND v(dout0_6) AT=3940.1n

* CHECK dout0_7 Vdout0_7ck196 = 1.8 time = 3940
.meas tran vdout0_7ck196 FIND v(dout0_7) AT=3940.1n

* CHECK dout0_8 Vdout0_8ck196 = 1.8 time = 3940
.meas tran vdout0_8ck196 FIND v(dout0_8) AT=3940.1n

* CHECK dout0_9 Vdout0_9ck196 = 1.8 time = 3940
.meas tran vdout0_9ck196 FIND v(dout0_9) AT=3940.1n

* CHECK dout0_10 Vdout0_10ck196 = 1.8 time = 3940
.meas tran vdout0_10ck196 FIND v(dout0_10) AT=3940.1n

* CHECK dout0_11 Vdout0_11ck196 = 1.8 time = 3940
.meas tran vdout0_11ck196 FIND v(dout0_11) AT=3940.1n

* CHECK dout0_12 Vdout0_12ck196 = 1.8 time = 3940
.meas tran vdout0_12ck196 FIND v(dout0_12) AT=3940.1n

* CHECK dout0_13 Vdout0_13ck196 = 1.8 time = 3940
.meas tran vdout0_13ck196 FIND v(dout0_13) AT=3940.1n

* CHECK dout0_14 Vdout0_14ck196 = 0 time = 3940
.meas tran vdout0_14ck196 FIND v(dout0_14) AT=3940.1n

* CHECK dout0_15 Vdout0_15ck196 = 0 time = 3940
.meas tran vdout0_15ck196 FIND v(dout0_15) AT=3940.1n

* CHECK dout0_0 Vdout0_0ck197 = 0 time = 3960
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=3960.1n

* CHECK dout0_1 Vdout0_1ck197 = 0 time = 3960
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=3960.1n

* CHECK dout0_2 Vdout0_2ck197 = 0 time = 3960
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=3960.1n

* CHECK dout0_3 Vdout0_3ck197 = 0 time = 3960
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=3960.1n

* CHECK dout0_4 Vdout0_4ck197 = 0 time = 3960
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=3960.1n

* CHECK dout0_5 Vdout0_5ck197 = 1.8 time = 3960
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=3960.1n

* CHECK dout0_6 Vdout0_6ck197 = 0 time = 3960
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=3960.1n

* CHECK dout0_7 Vdout0_7ck197 = 1.8 time = 3960
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=3960.1n

* CHECK dout0_8 Vdout0_8ck197 = 1.8 time = 3960
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=3960.1n

* CHECK dout0_9 Vdout0_9ck197 = 1.8 time = 3960
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=3960.1n

* CHECK dout0_10 Vdout0_10ck197 = 0 time = 3960
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=3960.1n

* CHECK dout0_11 Vdout0_11ck197 = 0 time = 3960
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=3960.1n

* CHECK dout0_12 Vdout0_12ck197 = 0 time = 3960
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=3960.1n

* CHECK dout0_13 Vdout0_13ck197 = 0 time = 3960
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=3960.1n

* CHECK dout0_14 Vdout0_14ck197 = 0 time = 3960
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=3960.1n

* CHECK dout0_15 Vdout0_15ck197 = 0 time = 3960
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=3960.1n

* CHECK dout0_0 Vdout0_0ck199 = 0 time = 4000
.meas tran vdout0_0ck199 FIND v(dout0_0) AT=4000.1n

* CHECK dout0_1 Vdout0_1ck199 = 0 time = 4000
.meas tran vdout0_1ck199 FIND v(dout0_1) AT=4000.1n

* CHECK dout0_2 Vdout0_2ck199 = 0 time = 4000
.meas tran vdout0_2ck199 FIND v(dout0_2) AT=4000.1n

* CHECK dout0_3 Vdout0_3ck199 = 0 time = 4000
.meas tran vdout0_3ck199 FIND v(dout0_3) AT=4000.1n

* CHECK dout0_4 Vdout0_4ck199 = 0 time = 4000
.meas tran vdout0_4ck199 FIND v(dout0_4) AT=4000.1n

* CHECK dout0_5 Vdout0_5ck199 = 0 time = 4000
.meas tran vdout0_5ck199 FIND v(dout0_5) AT=4000.1n

* CHECK dout0_6 Vdout0_6ck199 = 0 time = 4000
.meas tran vdout0_6ck199 FIND v(dout0_6) AT=4000.1n

* CHECK dout0_7 Vdout0_7ck199 = 1.8 time = 4000
.meas tran vdout0_7ck199 FIND v(dout0_7) AT=4000.1n

* CHECK dout0_8 Vdout0_8ck199 = 1.8 time = 4000
.meas tran vdout0_8ck199 FIND v(dout0_8) AT=4000.1n

* CHECK dout0_9 Vdout0_9ck199 = 1.8 time = 4000
.meas tran vdout0_9ck199 FIND v(dout0_9) AT=4000.1n

* CHECK dout0_10 Vdout0_10ck199 = 1.8 time = 4000
.meas tran vdout0_10ck199 FIND v(dout0_10) AT=4000.1n

* CHECK dout0_11 Vdout0_11ck199 = 1.8 time = 4000
.meas tran vdout0_11ck199 FIND v(dout0_11) AT=4000.1n

* CHECK dout0_12 Vdout0_12ck199 = 1.8 time = 4000
.meas tran vdout0_12ck199 FIND v(dout0_12) AT=4000.1n

* CHECK dout0_13 Vdout0_13ck199 = 1.8 time = 4000
.meas tran vdout0_13ck199 FIND v(dout0_13) AT=4000.1n

* CHECK dout0_14 Vdout0_14ck199 = 0 time = 4000
.meas tran vdout0_14ck199 FIND v(dout0_14) AT=4000.1n

* CHECK dout0_15 Vdout0_15ck199 = 0 time = 4000
.meas tran vdout0_15ck199 FIND v(dout0_15) AT=4000.1n

* CHECK dout0_0 Vdout0_0ck200 = 0 time = 4020
.meas tran vdout0_0ck200 FIND v(dout0_0) AT=4020.1n

* CHECK dout0_1 Vdout0_1ck200 = 0 time = 4020
.meas tran vdout0_1ck200 FIND v(dout0_1) AT=4020.1n

* CHECK dout0_2 Vdout0_2ck200 = 1.8 time = 4020
.meas tran vdout0_2ck200 FIND v(dout0_2) AT=4020.1n

* CHECK dout0_3 Vdout0_3ck200 = 1.8 time = 4020
.meas tran vdout0_3ck200 FIND v(dout0_3) AT=4020.1n

* CHECK dout0_4 Vdout0_4ck200 = 1.8 time = 4020
.meas tran vdout0_4ck200 FIND v(dout0_4) AT=4020.1n

* CHECK dout0_5 Vdout0_5ck200 = 1.8 time = 4020
.meas tran vdout0_5ck200 FIND v(dout0_5) AT=4020.1n

* CHECK dout0_6 Vdout0_6ck200 = 1.8 time = 4020
.meas tran vdout0_6ck200 FIND v(dout0_6) AT=4020.1n

* CHECK dout0_7 Vdout0_7ck200 = 1.8 time = 4020
.meas tran vdout0_7ck200 FIND v(dout0_7) AT=4020.1n

* CHECK dout0_8 Vdout0_8ck200 = 1.8 time = 4020
.meas tran vdout0_8ck200 FIND v(dout0_8) AT=4020.1n

* CHECK dout0_9 Vdout0_9ck200 = 1.8 time = 4020
.meas tran vdout0_9ck200 FIND v(dout0_9) AT=4020.1n

* CHECK dout0_10 Vdout0_10ck200 = 0 time = 4020
.meas tran vdout0_10ck200 FIND v(dout0_10) AT=4020.1n

* CHECK dout0_11 Vdout0_11ck200 = 0 time = 4020
.meas tran vdout0_11ck200 FIND v(dout0_11) AT=4020.1n

* CHECK dout0_12 Vdout0_12ck200 = 0 time = 4020
.meas tran vdout0_12ck200 FIND v(dout0_12) AT=4020.1n

* CHECK dout0_13 Vdout0_13ck200 = 0 time = 4020
.meas tran vdout0_13ck200 FIND v(dout0_13) AT=4020.1n

* CHECK dout0_14 Vdout0_14ck200 = 1.8 time = 4020
.meas tran vdout0_14ck200 FIND v(dout0_14) AT=4020.1n

* CHECK dout0_15 Vdout0_15ck200 = 0 time = 4020
.meas tran vdout0_15ck200 FIND v(dout0_15) AT=4020.1n

* CHECK dout0_0 Vdout0_0ck202 = 0 time = 4060
.meas tran vdout0_0ck202 FIND v(dout0_0) AT=4060.1n

* CHECK dout0_1 Vdout0_1ck202 = 0 time = 4060
.meas tran vdout0_1ck202 FIND v(dout0_1) AT=4060.1n

* CHECK dout0_2 Vdout0_2ck202 = 0 time = 4060
.meas tran vdout0_2ck202 FIND v(dout0_2) AT=4060.1n

* CHECK dout0_3 Vdout0_3ck202 = 1.8 time = 4060
.meas tran vdout0_3ck202 FIND v(dout0_3) AT=4060.1n

* CHECK dout0_4 Vdout0_4ck202 = 1.8 time = 4060
.meas tran vdout0_4ck202 FIND v(dout0_4) AT=4060.1n

* CHECK dout0_5 Vdout0_5ck202 = 1.8 time = 4060
.meas tran vdout0_5ck202 FIND v(dout0_5) AT=4060.1n

* CHECK dout0_6 Vdout0_6ck202 = 1.8 time = 4060
.meas tran vdout0_6ck202 FIND v(dout0_6) AT=4060.1n

* CHECK dout0_7 Vdout0_7ck202 = 1.8 time = 4060
.meas tran vdout0_7ck202 FIND v(dout0_7) AT=4060.1n

* CHECK dout0_8 Vdout0_8ck202 = 1.8 time = 4060
.meas tran vdout0_8ck202 FIND v(dout0_8) AT=4060.1n

* CHECK dout0_9 Vdout0_9ck202 = 1.8 time = 4060
.meas tran vdout0_9ck202 FIND v(dout0_9) AT=4060.1n

* CHECK dout0_10 Vdout0_10ck202 = 1.8 time = 4060
.meas tran vdout0_10ck202 FIND v(dout0_10) AT=4060.1n

* CHECK dout0_11 Vdout0_11ck202 = 1.8 time = 4060
.meas tran vdout0_11ck202 FIND v(dout0_11) AT=4060.1n

* CHECK dout0_12 Vdout0_12ck202 = 0 time = 4060
.meas tran vdout0_12ck202 FIND v(dout0_12) AT=4060.1n

* CHECK dout0_13 Vdout0_13ck202 = 1.8 time = 4060
.meas tran vdout0_13ck202 FIND v(dout0_13) AT=4060.1n

* CHECK dout0_14 Vdout0_14ck202 = 0 time = 4060
.meas tran vdout0_14ck202 FIND v(dout0_14) AT=4060.1n

* CHECK dout0_15 Vdout0_15ck202 = 1.8 time = 4060
.meas tran vdout0_15ck202 FIND v(dout0_15) AT=4060.1n

* CHECK dout0_0 Vdout0_0ck203 = 0 time = 4080
.meas tran vdout0_0ck203 FIND v(dout0_0) AT=4080.1n

* CHECK dout0_1 Vdout0_1ck203 = 0 time = 4080
.meas tran vdout0_1ck203 FIND v(dout0_1) AT=4080.1n

* CHECK dout0_2 Vdout0_2ck203 = 0 time = 4080
.meas tran vdout0_2ck203 FIND v(dout0_2) AT=4080.1n

* CHECK dout0_3 Vdout0_3ck203 = 0 time = 4080
.meas tran vdout0_3ck203 FIND v(dout0_3) AT=4080.1n

* CHECK dout0_4 Vdout0_4ck203 = 0 time = 4080
.meas tran vdout0_4ck203 FIND v(dout0_4) AT=4080.1n

* CHECK dout0_5 Vdout0_5ck203 = 0 time = 4080
.meas tran vdout0_5ck203 FIND v(dout0_5) AT=4080.1n

* CHECK dout0_6 Vdout0_6ck203 = 0 time = 4080
.meas tran vdout0_6ck203 FIND v(dout0_6) AT=4080.1n

* CHECK dout0_7 Vdout0_7ck203 = 1.8 time = 4080
.meas tran vdout0_7ck203 FIND v(dout0_7) AT=4080.1n

* CHECK dout0_8 Vdout0_8ck203 = 1.8 time = 4080
.meas tran vdout0_8ck203 FIND v(dout0_8) AT=4080.1n

* CHECK dout0_9 Vdout0_9ck203 = 1.8 time = 4080
.meas tran vdout0_9ck203 FIND v(dout0_9) AT=4080.1n

* CHECK dout0_10 Vdout0_10ck203 = 1.8 time = 4080
.meas tran vdout0_10ck203 FIND v(dout0_10) AT=4080.1n

* CHECK dout0_11 Vdout0_11ck203 = 1.8 time = 4080
.meas tran vdout0_11ck203 FIND v(dout0_11) AT=4080.1n

* CHECK dout0_12 Vdout0_12ck203 = 1.8 time = 4080
.meas tran vdout0_12ck203 FIND v(dout0_12) AT=4080.1n

* CHECK dout0_13 Vdout0_13ck203 = 1.8 time = 4080
.meas tran vdout0_13ck203 FIND v(dout0_13) AT=4080.1n

* CHECK dout0_14 Vdout0_14ck203 = 0 time = 4080
.meas tran vdout0_14ck203 FIND v(dout0_14) AT=4080.1n

* CHECK dout0_15 Vdout0_15ck203 = 0 time = 4080
.meas tran vdout0_15ck203 FIND v(dout0_15) AT=4080.1n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
