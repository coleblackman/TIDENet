* Functional test stimulus file for 20ns period

* TT process corner
.include "/home/mm4uz/Documents/openram/vsdsram_sky130/OpenRAM/technology/sky130A/models/tt.sp"
.include "pool1_rm_sram_16_384_sky130A.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xpool1_rm_sram_16_384_sky130A din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 a0_8 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 vdd gnd pool1_rm_sram_16_384_sky130A

* SRAM output loads
CD00 dout0_0  0 39.2968f
CD01 dout0_1  0 39.2968f
CD02 dout0_2  0 39.2968f
CD03 dout0_3  0 39.2968f
CD04 dout0_4  0 39.2968f
CD05 dout0_5  0 39.2968f
CD06 dout0_6  0 39.2968f
CD07 dout0_7  0 39.2968f
CD08 dout0_8  0 39.2968f
CD09 dout0_9  0 39.2968f
CD010 dout0_10  0 39.2968f
CD011 dout0_11  0 39.2968f
CD012 dout0_12  0 39.2968f
CD013 dout0_13  0 39.2968f
CD014 dout0_14  0 39.2968f
CD015 dout0_15  0 39.2968f

* Important signals for debug
* bl:	xpool1_rm_sram_16_384_sky130a.xbank0.bl_0_0
* br:	xpool1_rm_sram_16_384_sky130a.xbank0.br_0_0
* s_en:	xpool1_rm_sram_16_384_sky130a.s_en
* q:	xpool1_rm_sram_16_384_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xpool1_rm_sram_16_384_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 20ns)
*	Writing 1011001010010011  to  address 000000010 (from port 0) during cycle 1 (20ns - 40ns)
*	Writing 0011011011001000  to  address 000000011 (from port 0) during cycle 2 (40ns - 60ns)
*	Writing 0011110000101000  to  address 000000010 (from port 0) during cycle 3 (60ns - 80ns)
*	Reading 0011011011001000 from address 000000011 (from port 0) during cycle 4 (80ns - 100ns)
*	Reading 0011011011001000 from address 000000011 (from port 0) during cycle 6 (120ns - 140ns)
*	Reading 0011011011001000 from address 000000011 (from port 0) during cycle 7 (140ns - 160ns)
*	Writing 1010010001100000  to  address 101111011 (from port 0) during cycle 8 (160ns - 180ns)
*	Writing 1011110111110001  to  address 101111110 (from port 0) during cycle 9 (180ns - 200ns)
*	Writing 1111110010110100  to  address 000000010 (from port 0) during cycle 10 (200ns - 220ns)
*	Reading 1011110111110001 from address 101111110 (from port 0) during cycle 11 (220ns - 240ns)
*	Writing 0010001111100011  to  address 101111011 (from port 0) during cycle 13 (260ns - 280ns)
*	Reading 0011011011001000 from address 000000011 (from port 0) during cycle 14 (280ns - 300ns)
*	Reading 1011110111110001 from address 101111110 (from port 0) during cycle 15 (300ns - 320ns)
*	Reading 1111110010110100 from address 000000010 (from port 0) during cycle 16 (320ns - 340ns)
*	Reading 0010001111100011 from address 101111011 (from port 0) during cycle 17 (340ns - 360ns)
*	Writing 1100001011110011  to  address 000000000 (from port 0) during cycle 19 (380ns - 400ns)
*	Reading 1111110010110100 from address 000000010 (from port 0) during cycle 20 (400ns - 420ns)
*	Reading 1111110010110100 from address 000000010 (from port 0) during cycle 21 (420ns - 440ns)
*	Reading 1111110010110100 from address 000000010 (from port 0) during cycle 22 (440ns - 460ns)
*	Writing 0001101101111010  to  address 000000010 (from port 0) during cycle 23 (460ns - 480ns)
*	Writing 0000001100011010  to  address 000000001 (from port 0) during cycle 24 (480ns - 500ns)
*	Reading 1100001011110011 from address 000000000 (from port 0) during cycle 25 (500ns - 520ns)
*	Reading 0000001100011010 from address 000000001 (from port 0) during cycle 26 (520ns - 540ns)
*	Reading 0000001100011010 from address 000000001 (from port 0) during cycle 28 (560ns - 580ns)
*	Reading 0011011011001000 from address 000000011 (from port 0) during cycle 29 (580ns - 600ns)
*	Writing 0000100011111011  to  address 000000001 (from port 0) during cycle 30 (600ns - 620ns)
*	Reading 0011011011001000 from address 000000011 (from port 0) during cycle 31 (620ns - 640ns)
*	Reading 0011011011001000 from address 000000011 (from port 0) during cycle 32 (640ns - 660ns)
*	Reading 0011011011001000 from address 000000011 (from port 0) during cycle 33 (660ns - 680ns)
*	Reading 0010001111100011 from address 101111011 (from port 0) during cycle 34 (680ns - 700ns)
*	Writing 1010101100011011  to  address 101111101 (from port 0) during cycle 35 (700ns - 720ns)
*	Reading 1010101100011011 from address 101111101 (from port 0) during cycle 37 (740ns - 760ns)
*	Reading 0010001111100011 from address 101111011 (from port 0) during cycle 38 (760ns - 780ns)
*	Writing 0110001110101111  to  address 101111101 (from port 0) during cycle 39 (780ns - 800ns)
*	Reading 0011011011001000 from address 000000011 (from port 0) during cycle 40 (800ns - 820ns)
*	Reading 1011110111110001 from address 101111110 (from port 0) during cycle 41 (820ns - 840ns)
*	Reading 1011110111110001 from address 101111110 (from port 0) during cycle 43 (860ns - 880ns)
*	Writing 0100101100100111  to  address 000000010 (from port 0) during cycle 46 (920ns - 940ns)
*	Reading 0011011011001000 from address 000000011 (from port 0) during cycle 47 (940ns - 960ns)
*	Reading 0110001110101111 from address 101111101 (from port 0) during cycle 48 (960ns - 980ns)
*	Reading 0100101100100111 from address 000000010 (from port 0) during cycle 50 (1000ns - 1020ns)
*	Reading 0010001111100011 from address 101111011 (from port 0) during cycle 51 (1020ns - 1040ns)
*	Writing 1001101011010111  to  address 000000011 (from port 0) during cycle 53 (1060ns - 1080ns)
*	Writing 0111001110011011  to  address 000000000 (from port 0) during cycle 54 (1080ns - 1100ns)
*	Writing 0111011111000010  to  address 000000011 (from port 0) during cycle 55 (1100ns - 1120ns)
*	Reading 1011110111110001 from address 101111110 (from port 0) during cycle 56 (1120ns - 1140ns)
*	Reading 0010001111100011 from address 101111011 (from port 0) during cycle 57 (1140ns - 1160ns)
*	Writing 1000001111010100  to  address 101111100 (from port 0) during cycle 58 (1160ns - 1180ns)
*	Writing 1101101101010011  to  address 000000010 (from port 0) during cycle 62 (1240ns - 1260ns)
*	Reading 0010001111100011 from address 101111011 (from port 0) during cycle 63 (1260ns - 1280ns)
*	Reading 0000100011111011 from address 000000001 (from port 0) during cycle 64 (1280ns - 1300ns)
*	Reading 1101101101010011 from address 000000010 (from port 0) during cycle 65 (1300ns - 1320ns)
*	Reading 0111011111000010 from address 000000011 (from port 0) during cycle 66 (1320ns - 1340ns)
*	Reading 1011110111110001 from address 101111110 (from port 0) during cycle 68 (1360ns - 1380ns)
*	Reading 1011110111110001 from address 101111110 (from port 0) during cycle 70 (1400ns - 1420ns)
*	Reading 0111011111000010 from address 000000011 (from port 0) during cycle 72 (1440ns - 1460ns)
*	Reading 0111001110011011 from address 000000000 (from port 0) during cycle 74 (1480ns - 1500ns)
*	Reading 1011110111110001 from address 101111110 (from port 0) during cycle 75 (1500ns - 1520ns)
*	Reading 0010001111100011 from address 101111011 (from port 0) during cycle 77 (1540ns - 1560ns)
*	Reading 1000001111010100 from address 101111100 (from port 0) during cycle 78 (1560ns - 1580ns)
*	Reading 0111001110011011 from address 000000000 (from port 0) during cycle 79 (1580ns - 1600ns)
*	Reading 1101101101010011 from address 000000010 (from port 0) during cycle 81 (1620ns - 1640ns)
*	Writing 0100011011011000  to  address 000000001 (from port 0) during cycle 83 (1660ns - 1680ns)
*	Reading 1000001111010100 from address 101111100 (from port 0) during cycle 84 (1680ns - 1700ns)
*	Reading 0100011011011000 from address 000000001 (from port 0) during cycle 85 (1700ns - 1720ns)
*	Reading 0111011111000010 from address 000000011 (from port 0) during cycle 86 (1720ns - 1740ns)
*	Reading 0100011011011000 from address 000000001 (from port 0) during cycle 87 (1740ns - 1760ns)
*	Writing 1000011110101100  to  address 000000000 (from port 0) during cycle 88 (1760ns - 1780ns)
*	Reading 0100011011011000 from address 000000001 (from port 0) during cycle 89 (1780ns - 1800ns)
*	Reading 1011110111110001 from address 101111110 (from port 0) during cycle 90 (1800ns - 1820ns)
*	Reading 0111011111000010 from address 000000011 (from port 0) during cycle 91 (1820ns - 1840ns)
*	Reading 0100011011011000 from address 000000001 (from port 0) during cycle 92 (1840ns - 1860ns)
*	Reading 1101101101010011 from address 000000010 (from port 0) during cycle 95 (1900ns - 1920ns)
*	Writing 0101111010110001  to  address 101111101 (from port 0) during cycle 96 (1920ns - 1940ns)
*	Reading 1101101101010011 from address 000000010 (from port 0) during cycle 97 (1940ns - 1960ns)
*	Reading 0111011111000010 from address 000000011 (from port 0) during cycle 98 (1960ns - 1980ns)
*	Reading 1101101101010011 from address 000000010 (from port 0) during cycle 99 (1980ns - 2000ns)
*	Reading 0010001111100011 from address 101111011 (from port 0) during cycle 101 (2020ns - 2040ns)
*	Writing 1011111110011010  to  address 000000010 (from port 0) during cycle 102 (2040ns - 2060ns)
*	Writing 0100011111000111  to  address 101111011 (from port 0) during cycle 103 (2060ns - 2080ns)
*	Reading 0101111010110001 from address 101111101 (from port 0) during cycle 104 (2080ns - 2100ns)
*	Writing 0110111101111001  to  address 000000010 (from port 0) during cycle 106 (2120ns - 2140ns)
*	Reading 0110111101111001 from address 000000010 (from port 0) during cycle 107 (2140ns - 2160ns)
*	Reading 1000011110101100 from address 000000000 (from port 0) during cycle 108 (2160ns - 2180ns)
*	Reading 1000011110101100 from address 000000000 (from port 0) during cycle 110 (2200ns - 2220ns)
*	Writing 0010110010100100  to  address 101111101 (from port 0) during cycle 111 (2220ns - 2240ns)
*	Reading 0100011011011000 from address 000000001 (from port 0) during cycle 112 (2240ns - 2260ns)
*	Reading 0111011111000010 from address 000000011 (from port 0) during cycle 113 (2260ns - 2280ns)
*	Writing 0001100110000110  to  address 101111110 (from port 0) during cycle 117 (2340ns - 2360ns)
*	Reading 1000001111010100 from address 101111100 (from port 0) during cycle 118 (2360ns - 2380ns)
*	Writing 1000100001101010  to  address 000000011 (from port 0) during cycle 119 (2380ns - 2400ns)
*	Reading 0110111101111001 from address 000000010 (from port 0) during cycle 120 (2400ns - 2420ns)
*	Reading 0001100110000110 from address 101111110 (from port 0) during cycle 121 (2420ns - 2440ns)
*	Writing 0101101101100001  to  address 000000001 (from port 0) during cycle 122 (2440ns - 2460ns)
*	Reading 1000001111010100 from address 101111100 (from port 0) during cycle 123 (2460ns - 2480ns)
*	Reading 0110111101111001 from address 000000010 (from port 0) during cycle 124 (2480ns - 2500ns)
*	Reading 0101101101100001 from address 000000001 (from port 0) during cycle 125 (2500ns - 2520ns)
*	Reading 0001100110000110 from address 101111110 (from port 0) during cycle 126 (2520ns - 2540ns)
*	Reading 0100011111000111 from address 101111011 (from port 0) during cycle 128 (2560ns - 2580ns)
*	Reading 0100011111000111 from address 101111011 (from port 0) during cycle 129 (2580ns - 2600ns)
*	Reading 0010110010100100 from address 101111101 (from port 0) during cycle 130 (2600ns - 2620ns)
*	Writing 0100110110100000  to  address 000000001 (from port 0) during cycle 132 (2640ns - 2660ns)
*	Writing 1000011010110100  to  address 101111100 (from port 0) during cycle 133 (2660ns - 2680ns)
*	Reading 1000100001101010 from address 000000011 (from port 0) during cycle 134 (2680ns - 2700ns)
*	Reading 1000100001101010 from address 000000011 (from port 0) during cycle 135 (2700ns - 2720ns)
*	Writing 0011000001010001  to  address 101111110 (from port 0) during cycle 136 (2720ns - 2740ns)
*	Writing 0001011010100000  to  address 000000001 (from port 0) during cycle 138 (2760ns - 2780ns)
*	Writing 0010001100001110  to  address 101111110 (from port 0) during cycle 139 (2780ns - 2800ns)
*	Reading 0010001100001110 from address 101111110 (from port 0) during cycle 140 (2800ns - 2820ns)
*	Writing 0000011011010011  to  address 000000010 (from port 0) during cycle 141 (2820ns - 2840ns)
*	Reading 0000011011010011 from address 000000010 (from port 0) during cycle 142 (2840ns - 2860ns)
*	Reading 0010110010100100 from address 101111101 (from port 0) during cycle 143 (2860ns - 2880ns)
*	Reading 1000100001101010 from address 000000011 (from port 0) during cycle 144 (2880ns - 2900ns)
*	Reading 1000100001101010 from address 000000011 (from port 0) during cycle 145 (2900ns - 2920ns)
*	Reading 1000011110101100 from address 000000000 (from port 0) during cycle 146 (2920ns - 2940ns)
*	Writing 0100110000010001  to  address 000000000 (from port 0) during cycle 147 (2940ns - 2960ns)
*	Reading 1000100001101010 from address 000000011 (from port 0) during cycle 148 (2960ns - 2980ns)
*	Reading 1000011010110100 from address 101111100 (from port 0) during cycle 149 (2980ns - 3000ns)
*	Reading 0010110010100100 from address 101111101 (from port 0) during cycle 152 (3040ns - 3060ns)
*	Reading 0010110010100100 from address 101111101 (from port 0) during cycle 153 (3060ns - 3080ns)
*	Writing 0000111011011000  to  address 000000010 (from port 0) during cycle 156 (3120ns - 3140ns)
*	Writing 0110001000100011  to  address 000000001 (from port 0) during cycle 157 (3140ns - 3160ns)
*	Reading 0010110010100100 from address 101111101 (from port 0) during cycle 158 (3160ns - 3180ns)
*	Reading 0010110010100100 from address 101111101 (from port 0) during cycle 160 (3200ns - 3220ns)
*	Reading 0110001000100011 from address 000000001 (from port 0) during cycle 161 (3220ns - 3240ns)
*	Reading 0110001000100011 from address 000000001 (from port 0) during cycle 162 (3240ns - 3260ns)
*	Writing 1011000001100100  to  address 000000000 (from port 0) during cycle 163 (3260ns - 3280ns)
*	Writing 1101010110000111  to  address 101111011 (from port 0) during cycle 165 (3300ns - 3320ns)
*	Reading 0010001100001110 from address 101111110 (from port 0) during cycle 166 (3320ns - 3340ns)
*	Reading 0010110010100100 from address 101111101 (from port 0) during cycle 168 (3360ns - 3380ns)
*	Reading 1000100001101010 from address 000000011 (from port 0) during cycle 169 (3380ns - 3400ns)
*	Writing 0000010000000101  to  address 101111011 (from port 0) during cycle 170 (3400ns - 3420ns)
*	Reading 1011000001100100 from address 000000000 (from port 0) during cycle 172 (3440ns - 3460ns)
*	Writing 1110111010001000  to  address 101111101 (from port 0) during cycle 174 (3480ns - 3500ns)
*	Reading 1000100001101010 from address 000000011 (from port 0) during cycle 175 (3500ns - 3520ns)
*	Reading 0110001000100011 from address 000000001 (from port 0) during cycle 176 (3520ns - 3540ns)
*	Writing 1100100010100011  to  address 000000001 (from port 0) during cycle 177 (3540ns - 3560ns)
*	Reading 1000011010110100 from address 101111100 (from port 0) during cycle 178 (3560ns - 3580ns)
*	Writing 0001000110100110  to  address 101111101 (from port 0) during cycle 179 (3580ns - 3600ns)
*	Reading 0000111011011000 from address 000000010 (from port 0) during cycle 180 (3600ns - 3620ns)
*	Reading 0001000110100110 from address 101111101 (from port 0) during cycle 181 (3620ns - 3640ns)
*	Reading 0000111011011000 from address 000000010 (from port 0) during cycle 183 (3660ns - 3680ns)
*	Reading 1011000001100100 from address 000000000 (from port 0) during cycle 184 (3680ns - 3700ns)
*	Reading 0001000110100110 from address 101111101 (from port 0) during cycle 185 (3700ns - 3720ns)
*	Reading 0010001100001110 from address 101111110 (from port 0) during cycle 186 (3720ns - 3740ns)
*	Reading 0001000110100110 from address 101111101 (from port 0) during cycle 187 (3740ns - 3760ns)
*	Reading 0000010000000101 from address 101111011 (from port 0) during cycle 188 (3760ns - 3780ns)
*	Writing 1010110000110001  to  address 000000000 (from port 0) during cycle 191 (3820ns - 3840ns)
*	Reading 1000011010110100 from address 101111100 (from port 0) during cycle 194 (3880ns - 3900ns)
*	Writing 1100010010101000  to  address 101111100 (from port 0) during cycle 195 (3900ns - 3920ns)
*	Reading 1000100001101010 from address 000000011 (from port 0) during cycle 197 (3940ns - 3960ns)
*	Writing 0101001010000010  to  address 000000001 (from port 0) during cycle 198 (3960ns - 3980ns)
*	Writing 1011100111011010  to  address 101111011 (from port 0) during cycle 199 (3980ns - 4000ns)
*	Writing 0010001100100000  to  address 101111101 (from port 0) during cycle 200 (4000ns - 4020ns)
*	Writing 0001000010001001  to  address 000000011 (from port 0) during cycle 202 (4040ns - 4060ns)
*	Reading 0010001100001110 from address 101111110 (from port 0) during cycle 204 (4080ns - 4100ns)
*	Idle during cycle 205 (4100ns - 4120ns)

* Generation of data and address signals
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 0), (3500, 0), (3520, 0), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 1), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 1), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 1), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 0), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 0), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 0), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 1), (2780, 0), (2800, 0), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 0), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 1), (440, 1), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 1), (400, 1), (420, 1), (440, 1), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 1), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 1), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 1), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 1), (280, 1), (300, 0), (320, 0), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 0), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 0), (1320, 1), (1340, 1), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 1), (1460, 1), (1480, 0), (1500, 0), (1520, 0), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 1), (1680, 0), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 1), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 0), (1920, 1), (1940, 0), (1960, 1), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 1), (2400, 0), (2420, 0), (2440, 1), (2460, 0), (2480, 0), (2500, 1), (2520, 0), (2540, 0), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 0), (2680, 1), (2700, 1), (2720, 0), (2740, 0), (2760, 1), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 0), (2940, 0), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 1), (3320, 0), (3340, 0), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 0), (3580, 1), (3600, 0), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 0), (4100, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 0), (400, 1), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 1), (600, 0), (620, 1), (640, 1), (660, 1), (680, 1), (700, 0), (720, 0), (740, 0), (760, 1), (780, 0), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 0), (980, 0), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 0), (1100, 1), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 1), (1280, 0), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 1), (1640, 1), (1660, 0), (1680, 0), (1700, 0), (1720, 1), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 0), (1860, 0), (1880, 0), (1900, 1), (1920, 0), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 0), (2100, 0), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 0), (2380, 1), (2400, 1), (2420, 1), (2440, 0), (2460, 0), (2480, 1), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 1), (2900, 1), (2920, 0), (2940, 0), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 1), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 0), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 1), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 1), (3620, 0), (3640, 0), (3660, 1), (3680, 0), (3700, 0), (3720, 1), (3740, 0), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 1), (3960, 0), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 0), (220, 1), (240, 1), (260, 0), (280, 0), (300, 1), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 1), (720, 1), (740, 1), (760, 0), (780, 1), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 0), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 1), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 1), (2440, 0), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 0), (2580, 0), (2600, 1), (2620, 1), (2640, 0), (2660, 1), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 0), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 0), (220, 1), (240, 1), (260, 1), (280, 0), (300, 1), (320, 0), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 1), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 1), (2440, 0), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 0), (2660, 1), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 0), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 0), (220, 1), (240, 1), (260, 1), (280, 0), (300, 1), (320, 0), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 1), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 1), (2440, 0), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 0), (2660, 1), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 0), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Va0_4  a0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 0), (220, 1), (240, 1), (260, 1), (280, 0), (300, 1), (320, 0), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 1), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 1), (2440, 0), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 0), (2660, 1), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 0), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Va0_5  a0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 0), (220, 1), (240, 1), (260, 1), (280, 0), (300, 1), (320, 0), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 1), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 1), (2440, 0), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 0), (2660, 1), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 0), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Va0_6  a0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 0), (220, 1), (240, 1), (260, 1), (280, 0), (300, 1), (320, 0), (340, 1), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 0), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 0), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 1), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 0), (2060, 1), (2080, 1), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 1), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 1), (2360, 1), (2380, 0), (2400, 0), (2420, 1), (2440, 0), (2460, 1), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 0), (2660, 1), (2680, 0), (2700, 0), (2720, 1), (2740, 1), (2760, 0), (2780, 1), (2800, 1), (2820, 0), (2840, 0), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 0), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 1), (3580, 1), (3600, 0), (3620, 1), (3640, 1), (3660, 0), (3680, 0), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
Va0_8  a0_8  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 0.0v 818.95n 0.0v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )

 * Generation of control signals
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 1), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 1), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 1), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 1), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 1), (860, 0), (880, 1), (900, 1), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 0), (1020, 0), (1040, 1), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 0), (1380, 1), (1400, 0), (1420, 1), (1440, 0), (1460, 1), (1480, 0), (1500, 0), (1520, 1), (1540, 0), (1560, 0), (1580, 0), (1600, 1), (1620, 0), (1640, 1), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 1), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 1), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 1), (3020, 1), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 0), (3180, 1), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 0), (3320, 0), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 0), (3460, 1), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 1), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 0), (3840, 1), (3860, 1), (3880, 0), (3900, 0), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 0), (4060, 1), (4080, 0), (4100, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 1.8v )
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 1), (100, 1), (120, 1), (140, 1), (160, 0), (180, 0), (200, 0), (220, 1), (240, 1), (260, 0), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 0), (400, 1), (420, 1), (440, 1), (460, 0), (480, 0), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 0), (620, 1), (640, 1), (660, 1), (680, 1), (700, 0), (720, 1), (740, 1), (760, 1), (780, 0), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 0), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 0), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 0), (2060, 0), (2080, 1), (2100, 1), (2120, 0), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 0), (2360, 1), (2380, 0), (2400, 1), (2420, 1), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 0), (2740, 1), (2760, 0), (2780, 0), (2800, 1), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 0), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 0), (3140, 0), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 1), (3300, 0), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 0), (3420, 1), (3440, 1), (3460, 1), (3480, 0), (3500, 1), (3520, 1), (3540, 0), (3560, 1), (3580, 0), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 0), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 0.0v 718.95n 0.0v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* PULSE: period=20
Vclk0 clk0 0 PULSE (0 1.8 19.95n 0.1n 0.1n 9.899999999999999n 20n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0 time = 100
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=100.1n

* CHECK dout0_1 Vdout0_1ck4 = 0 time = 100
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=100.1n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 100
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=100.1n

* CHECK dout0_3 Vdout0_3ck4 = 1.8 time = 100
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=100.1n

* CHECK dout0_4 Vdout0_4ck4 = 0 time = 100
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=100.1n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 100
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=100.1n

* CHECK dout0_6 Vdout0_6ck4 = 1.8 time = 100
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=100.1n

* CHECK dout0_7 Vdout0_7ck4 = 1.8 time = 100
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=100.1n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 100
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=100.1n

* CHECK dout0_9 Vdout0_9ck4 = 1.8 time = 100
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=100.1n

* CHECK dout0_10 Vdout0_10ck4 = 1.8 time = 100
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=100.1n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 100
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=100.1n

* CHECK dout0_12 Vdout0_12ck4 = 1.8 time = 100
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=100.1n

* CHECK dout0_13 Vdout0_13ck4 = 1.8 time = 100
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=100.1n

* CHECK dout0_14 Vdout0_14ck4 = 0 time = 100
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=100.1n

* CHECK dout0_15 Vdout0_15ck4 = 0 time = 100
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=100.1n

* CHECK dout0_0 Vdout0_0ck6 = 0 time = 140
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=140.1n

* CHECK dout0_1 Vdout0_1ck6 = 0 time = 140
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=140.1n

* CHECK dout0_2 Vdout0_2ck6 = 0 time = 140
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=140.1n

* CHECK dout0_3 Vdout0_3ck6 = 1.8 time = 140
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=140.1n

* CHECK dout0_4 Vdout0_4ck6 = 0 time = 140
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=140.1n

* CHECK dout0_5 Vdout0_5ck6 = 0 time = 140
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=140.1n

* CHECK dout0_6 Vdout0_6ck6 = 1.8 time = 140
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=140.1n

* CHECK dout0_7 Vdout0_7ck6 = 1.8 time = 140
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=140.1n

* CHECK dout0_8 Vdout0_8ck6 = 0 time = 140
.meas tran vdout0_8ck6 FIND v(dout0_8) AT=140.1n

* CHECK dout0_9 Vdout0_9ck6 = 1.8 time = 140
.meas tran vdout0_9ck6 FIND v(dout0_9) AT=140.1n

* CHECK dout0_10 Vdout0_10ck6 = 1.8 time = 140
.meas tran vdout0_10ck6 FIND v(dout0_10) AT=140.1n

* CHECK dout0_11 Vdout0_11ck6 = 0 time = 140
.meas tran vdout0_11ck6 FIND v(dout0_11) AT=140.1n

* CHECK dout0_12 Vdout0_12ck6 = 1.8 time = 140
.meas tran vdout0_12ck6 FIND v(dout0_12) AT=140.1n

* CHECK dout0_13 Vdout0_13ck6 = 1.8 time = 140
.meas tran vdout0_13ck6 FIND v(dout0_13) AT=140.1n

* CHECK dout0_14 Vdout0_14ck6 = 0 time = 140
.meas tran vdout0_14ck6 FIND v(dout0_14) AT=140.1n

* CHECK dout0_15 Vdout0_15ck6 = 0 time = 140
.meas tran vdout0_15ck6 FIND v(dout0_15) AT=140.1n

* CHECK dout0_0 Vdout0_0ck7 = 0 time = 160
.meas tran vdout0_0ck7 FIND v(dout0_0) AT=160.1n

* CHECK dout0_1 Vdout0_1ck7 = 0 time = 160
.meas tran vdout0_1ck7 FIND v(dout0_1) AT=160.1n

* CHECK dout0_2 Vdout0_2ck7 = 0 time = 160
.meas tran vdout0_2ck7 FIND v(dout0_2) AT=160.1n

* CHECK dout0_3 Vdout0_3ck7 = 1.8 time = 160
.meas tran vdout0_3ck7 FIND v(dout0_3) AT=160.1n

* CHECK dout0_4 Vdout0_4ck7 = 0 time = 160
.meas tran vdout0_4ck7 FIND v(dout0_4) AT=160.1n

* CHECK dout0_5 Vdout0_5ck7 = 0 time = 160
.meas tran vdout0_5ck7 FIND v(dout0_5) AT=160.1n

* CHECK dout0_6 Vdout0_6ck7 = 1.8 time = 160
.meas tran vdout0_6ck7 FIND v(dout0_6) AT=160.1n

* CHECK dout0_7 Vdout0_7ck7 = 1.8 time = 160
.meas tran vdout0_7ck7 FIND v(dout0_7) AT=160.1n

* CHECK dout0_8 Vdout0_8ck7 = 0 time = 160
.meas tran vdout0_8ck7 FIND v(dout0_8) AT=160.1n

* CHECK dout0_9 Vdout0_9ck7 = 1.8 time = 160
.meas tran vdout0_9ck7 FIND v(dout0_9) AT=160.1n

* CHECK dout0_10 Vdout0_10ck7 = 1.8 time = 160
.meas tran vdout0_10ck7 FIND v(dout0_10) AT=160.1n

* CHECK dout0_11 Vdout0_11ck7 = 0 time = 160
.meas tran vdout0_11ck7 FIND v(dout0_11) AT=160.1n

* CHECK dout0_12 Vdout0_12ck7 = 1.8 time = 160
.meas tran vdout0_12ck7 FIND v(dout0_12) AT=160.1n

* CHECK dout0_13 Vdout0_13ck7 = 1.8 time = 160
.meas tran vdout0_13ck7 FIND v(dout0_13) AT=160.1n

* CHECK dout0_14 Vdout0_14ck7 = 0 time = 160
.meas tran vdout0_14ck7 FIND v(dout0_14) AT=160.1n

* CHECK dout0_15 Vdout0_15ck7 = 0 time = 160
.meas tran vdout0_15ck7 FIND v(dout0_15) AT=160.1n

* CHECK dout0_0 Vdout0_0ck11 = 1.8 time = 240
.meas tran vdout0_0ck11 FIND v(dout0_0) AT=240.1n

* CHECK dout0_1 Vdout0_1ck11 = 0 time = 240
.meas tran vdout0_1ck11 FIND v(dout0_1) AT=240.1n

* CHECK dout0_2 Vdout0_2ck11 = 0 time = 240
.meas tran vdout0_2ck11 FIND v(dout0_2) AT=240.1n

* CHECK dout0_3 Vdout0_3ck11 = 0 time = 240
.meas tran vdout0_3ck11 FIND v(dout0_3) AT=240.1n

* CHECK dout0_4 Vdout0_4ck11 = 1.8 time = 240
.meas tran vdout0_4ck11 FIND v(dout0_4) AT=240.1n

* CHECK dout0_5 Vdout0_5ck11 = 1.8 time = 240
.meas tran vdout0_5ck11 FIND v(dout0_5) AT=240.1n

* CHECK dout0_6 Vdout0_6ck11 = 1.8 time = 240
.meas tran vdout0_6ck11 FIND v(dout0_6) AT=240.1n

* CHECK dout0_7 Vdout0_7ck11 = 1.8 time = 240
.meas tran vdout0_7ck11 FIND v(dout0_7) AT=240.1n

* CHECK dout0_8 Vdout0_8ck11 = 1.8 time = 240
.meas tran vdout0_8ck11 FIND v(dout0_8) AT=240.1n

* CHECK dout0_9 Vdout0_9ck11 = 0 time = 240
.meas tran vdout0_9ck11 FIND v(dout0_9) AT=240.1n

* CHECK dout0_10 Vdout0_10ck11 = 1.8 time = 240
.meas tran vdout0_10ck11 FIND v(dout0_10) AT=240.1n

* CHECK dout0_11 Vdout0_11ck11 = 1.8 time = 240
.meas tran vdout0_11ck11 FIND v(dout0_11) AT=240.1n

* CHECK dout0_12 Vdout0_12ck11 = 1.8 time = 240
.meas tran vdout0_12ck11 FIND v(dout0_12) AT=240.1n

* CHECK dout0_13 Vdout0_13ck11 = 1.8 time = 240
.meas tran vdout0_13ck11 FIND v(dout0_13) AT=240.1n

* CHECK dout0_14 Vdout0_14ck11 = 0 time = 240
.meas tran vdout0_14ck11 FIND v(dout0_14) AT=240.1n

* CHECK dout0_15 Vdout0_15ck11 = 1.8 time = 240
.meas tran vdout0_15ck11 FIND v(dout0_15) AT=240.1n

* CHECK dout0_0 Vdout0_0ck14 = 0 time = 300
.meas tran vdout0_0ck14 FIND v(dout0_0) AT=300.1n

* CHECK dout0_1 Vdout0_1ck14 = 0 time = 300
.meas tran vdout0_1ck14 FIND v(dout0_1) AT=300.1n

* CHECK dout0_2 Vdout0_2ck14 = 0 time = 300
.meas tran vdout0_2ck14 FIND v(dout0_2) AT=300.1n

* CHECK dout0_3 Vdout0_3ck14 = 1.8 time = 300
.meas tran vdout0_3ck14 FIND v(dout0_3) AT=300.1n

* CHECK dout0_4 Vdout0_4ck14 = 0 time = 300
.meas tran vdout0_4ck14 FIND v(dout0_4) AT=300.1n

* CHECK dout0_5 Vdout0_5ck14 = 0 time = 300
.meas tran vdout0_5ck14 FIND v(dout0_5) AT=300.1n

* CHECK dout0_6 Vdout0_6ck14 = 1.8 time = 300
.meas tran vdout0_6ck14 FIND v(dout0_6) AT=300.1n

* CHECK dout0_7 Vdout0_7ck14 = 1.8 time = 300
.meas tran vdout0_7ck14 FIND v(dout0_7) AT=300.1n

* CHECK dout0_8 Vdout0_8ck14 = 0 time = 300
.meas tran vdout0_8ck14 FIND v(dout0_8) AT=300.1n

* CHECK dout0_9 Vdout0_9ck14 = 1.8 time = 300
.meas tran vdout0_9ck14 FIND v(dout0_9) AT=300.1n

* CHECK dout0_10 Vdout0_10ck14 = 1.8 time = 300
.meas tran vdout0_10ck14 FIND v(dout0_10) AT=300.1n

* CHECK dout0_11 Vdout0_11ck14 = 0 time = 300
.meas tran vdout0_11ck14 FIND v(dout0_11) AT=300.1n

* CHECK dout0_12 Vdout0_12ck14 = 1.8 time = 300
.meas tran vdout0_12ck14 FIND v(dout0_12) AT=300.1n

* CHECK dout0_13 Vdout0_13ck14 = 1.8 time = 300
.meas tran vdout0_13ck14 FIND v(dout0_13) AT=300.1n

* CHECK dout0_14 Vdout0_14ck14 = 0 time = 300
.meas tran vdout0_14ck14 FIND v(dout0_14) AT=300.1n

* CHECK dout0_15 Vdout0_15ck14 = 0 time = 300
.meas tran vdout0_15ck14 FIND v(dout0_15) AT=300.1n

* CHECK dout0_0 Vdout0_0ck15 = 1.8 time = 320
.meas tran vdout0_0ck15 FIND v(dout0_0) AT=320.1n

* CHECK dout0_1 Vdout0_1ck15 = 0 time = 320
.meas tran vdout0_1ck15 FIND v(dout0_1) AT=320.1n

* CHECK dout0_2 Vdout0_2ck15 = 0 time = 320
.meas tran vdout0_2ck15 FIND v(dout0_2) AT=320.1n

* CHECK dout0_3 Vdout0_3ck15 = 0 time = 320
.meas tran vdout0_3ck15 FIND v(dout0_3) AT=320.1n

* CHECK dout0_4 Vdout0_4ck15 = 1.8 time = 320
.meas tran vdout0_4ck15 FIND v(dout0_4) AT=320.1n

* CHECK dout0_5 Vdout0_5ck15 = 1.8 time = 320
.meas tran vdout0_5ck15 FIND v(dout0_5) AT=320.1n

* CHECK dout0_6 Vdout0_6ck15 = 1.8 time = 320
.meas tran vdout0_6ck15 FIND v(dout0_6) AT=320.1n

* CHECK dout0_7 Vdout0_7ck15 = 1.8 time = 320
.meas tran vdout0_7ck15 FIND v(dout0_7) AT=320.1n

* CHECK dout0_8 Vdout0_8ck15 = 1.8 time = 320
.meas tran vdout0_8ck15 FIND v(dout0_8) AT=320.1n

* CHECK dout0_9 Vdout0_9ck15 = 0 time = 320
.meas tran vdout0_9ck15 FIND v(dout0_9) AT=320.1n

* CHECK dout0_10 Vdout0_10ck15 = 1.8 time = 320
.meas tran vdout0_10ck15 FIND v(dout0_10) AT=320.1n

* CHECK dout0_11 Vdout0_11ck15 = 1.8 time = 320
.meas tran vdout0_11ck15 FIND v(dout0_11) AT=320.1n

* CHECK dout0_12 Vdout0_12ck15 = 1.8 time = 320
.meas tran vdout0_12ck15 FIND v(dout0_12) AT=320.1n

* CHECK dout0_13 Vdout0_13ck15 = 1.8 time = 320
.meas tran vdout0_13ck15 FIND v(dout0_13) AT=320.1n

* CHECK dout0_14 Vdout0_14ck15 = 0 time = 320
.meas tran vdout0_14ck15 FIND v(dout0_14) AT=320.1n

* CHECK dout0_15 Vdout0_15ck15 = 1.8 time = 320
.meas tran vdout0_15ck15 FIND v(dout0_15) AT=320.1n

* CHECK dout0_0 Vdout0_0ck16 = 0 time = 340
.meas tran vdout0_0ck16 FIND v(dout0_0) AT=340.1n

* CHECK dout0_1 Vdout0_1ck16 = 0 time = 340
.meas tran vdout0_1ck16 FIND v(dout0_1) AT=340.1n

* CHECK dout0_2 Vdout0_2ck16 = 1.8 time = 340
.meas tran vdout0_2ck16 FIND v(dout0_2) AT=340.1n

* CHECK dout0_3 Vdout0_3ck16 = 0 time = 340
.meas tran vdout0_3ck16 FIND v(dout0_3) AT=340.1n

* CHECK dout0_4 Vdout0_4ck16 = 1.8 time = 340
.meas tran vdout0_4ck16 FIND v(dout0_4) AT=340.1n

* CHECK dout0_5 Vdout0_5ck16 = 1.8 time = 340
.meas tran vdout0_5ck16 FIND v(dout0_5) AT=340.1n

* CHECK dout0_6 Vdout0_6ck16 = 0 time = 340
.meas tran vdout0_6ck16 FIND v(dout0_6) AT=340.1n

* CHECK dout0_7 Vdout0_7ck16 = 1.8 time = 340
.meas tran vdout0_7ck16 FIND v(dout0_7) AT=340.1n

* CHECK dout0_8 Vdout0_8ck16 = 0 time = 340
.meas tran vdout0_8ck16 FIND v(dout0_8) AT=340.1n

* CHECK dout0_9 Vdout0_9ck16 = 0 time = 340
.meas tran vdout0_9ck16 FIND v(dout0_9) AT=340.1n

* CHECK dout0_10 Vdout0_10ck16 = 1.8 time = 340
.meas tran vdout0_10ck16 FIND v(dout0_10) AT=340.1n

* CHECK dout0_11 Vdout0_11ck16 = 1.8 time = 340
.meas tran vdout0_11ck16 FIND v(dout0_11) AT=340.1n

* CHECK dout0_12 Vdout0_12ck16 = 1.8 time = 340
.meas tran vdout0_12ck16 FIND v(dout0_12) AT=340.1n

* CHECK dout0_13 Vdout0_13ck16 = 1.8 time = 340
.meas tran vdout0_13ck16 FIND v(dout0_13) AT=340.1n

* CHECK dout0_14 Vdout0_14ck16 = 1.8 time = 340
.meas tran vdout0_14ck16 FIND v(dout0_14) AT=340.1n

* CHECK dout0_15 Vdout0_15ck16 = 1.8 time = 340
.meas tran vdout0_15ck16 FIND v(dout0_15) AT=340.1n

* CHECK dout0_0 Vdout0_0ck17 = 1.8 time = 360
.meas tran vdout0_0ck17 FIND v(dout0_0) AT=360.1n

* CHECK dout0_1 Vdout0_1ck17 = 1.8 time = 360
.meas tran vdout0_1ck17 FIND v(dout0_1) AT=360.1n

* CHECK dout0_2 Vdout0_2ck17 = 0 time = 360
.meas tran vdout0_2ck17 FIND v(dout0_2) AT=360.1n

* CHECK dout0_3 Vdout0_3ck17 = 0 time = 360
.meas tran vdout0_3ck17 FIND v(dout0_3) AT=360.1n

* CHECK dout0_4 Vdout0_4ck17 = 0 time = 360
.meas tran vdout0_4ck17 FIND v(dout0_4) AT=360.1n

* CHECK dout0_5 Vdout0_5ck17 = 1.8 time = 360
.meas tran vdout0_5ck17 FIND v(dout0_5) AT=360.1n

* CHECK dout0_6 Vdout0_6ck17 = 1.8 time = 360
.meas tran vdout0_6ck17 FIND v(dout0_6) AT=360.1n

* CHECK dout0_7 Vdout0_7ck17 = 1.8 time = 360
.meas tran vdout0_7ck17 FIND v(dout0_7) AT=360.1n

* CHECK dout0_8 Vdout0_8ck17 = 1.8 time = 360
.meas tran vdout0_8ck17 FIND v(dout0_8) AT=360.1n

* CHECK dout0_9 Vdout0_9ck17 = 1.8 time = 360
.meas tran vdout0_9ck17 FIND v(dout0_9) AT=360.1n

* CHECK dout0_10 Vdout0_10ck17 = 0 time = 360
.meas tran vdout0_10ck17 FIND v(dout0_10) AT=360.1n

* CHECK dout0_11 Vdout0_11ck17 = 0 time = 360
.meas tran vdout0_11ck17 FIND v(dout0_11) AT=360.1n

* CHECK dout0_12 Vdout0_12ck17 = 0 time = 360
.meas tran vdout0_12ck17 FIND v(dout0_12) AT=360.1n

* CHECK dout0_13 Vdout0_13ck17 = 1.8 time = 360
.meas tran vdout0_13ck17 FIND v(dout0_13) AT=360.1n

* CHECK dout0_14 Vdout0_14ck17 = 0 time = 360
.meas tran vdout0_14ck17 FIND v(dout0_14) AT=360.1n

* CHECK dout0_15 Vdout0_15ck17 = 0 time = 360
.meas tran vdout0_15ck17 FIND v(dout0_15) AT=360.1n

* CHECK dout0_0 Vdout0_0ck20 = 0 time = 420
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=420.1n

* CHECK dout0_1 Vdout0_1ck20 = 0 time = 420
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=420.1n

* CHECK dout0_2 Vdout0_2ck20 = 1.8 time = 420
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=420.1n

* CHECK dout0_3 Vdout0_3ck20 = 0 time = 420
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=420.1n

* CHECK dout0_4 Vdout0_4ck20 = 1.8 time = 420
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=420.1n

* CHECK dout0_5 Vdout0_5ck20 = 1.8 time = 420
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=420.1n

* CHECK dout0_6 Vdout0_6ck20 = 0 time = 420
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=420.1n

* CHECK dout0_7 Vdout0_7ck20 = 1.8 time = 420
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=420.1n

* CHECK dout0_8 Vdout0_8ck20 = 0 time = 420
.meas tran vdout0_8ck20 FIND v(dout0_8) AT=420.1n

* CHECK dout0_9 Vdout0_9ck20 = 0 time = 420
.meas tran vdout0_9ck20 FIND v(dout0_9) AT=420.1n

* CHECK dout0_10 Vdout0_10ck20 = 1.8 time = 420
.meas tran vdout0_10ck20 FIND v(dout0_10) AT=420.1n

* CHECK dout0_11 Vdout0_11ck20 = 1.8 time = 420
.meas tran vdout0_11ck20 FIND v(dout0_11) AT=420.1n

* CHECK dout0_12 Vdout0_12ck20 = 1.8 time = 420
.meas tran vdout0_12ck20 FIND v(dout0_12) AT=420.1n

* CHECK dout0_13 Vdout0_13ck20 = 1.8 time = 420
.meas tran vdout0_13ck20 FIND v(dout0_13) AT=420.1n

* CHECK dout0_14 Vdout0_14ck20 = 1.8 time = 420
.meas tran vdout0_14ck20 FIND v(dout0_14) AT=420.1n

* CHECK dout0_15 Vdout0_15ck20 = 1.8 time = 420
.meas tran vdout0_15ck20 FIND v(dout0_15) AT=420.1n

* CHECK dout0_0 Vdout0_0ck21 = 0 time = 440
.meas tran vdout0_0ck21 FIND v(dout0_0) AT=440.1n

* CHECK dout0_1 Vdout0_1ck21 = 0 time = 440
.meas tran vdout0_1ck21 FIND v(dout0_1) AT=440.1n

* CHECK dout0_2 Vdout0_2ck21 = 1.8 time = 440
.meas tran vdout0_2ck21 FIND v(dout0_2) AT=440.1n

* CHECK dout0_3 Vdout0_3ck21 = 0 time = 440
.meas tran vdout0_3ck21 FIND v(dout0_3) AT=440.1n

* CHECK dout0_4 Vdout0_4ck21 = 1.8 time = 440
.meas tran vdout0_4ck21 FIND v(dout0_4) AT=440.1n

* CHECK dout0_5 Vdout0_5ck21 = 1.8 time = 440
.meas tran vdout0_5ck21 FIND v(dout0_5) AT=440.1n

* CHECK dout0_6 Vdout0_6ck21 = 0 time = 440
.meas tran vdout0_6ck21 FIND v(dout0_6) AT=440.1n

* CHECK dout0_7 Vdout0_7ck21 = 1.8 time = 440
.meas tran vdout0_7ck21 FIND v(dout0_7) AT=440.1n

* CHECK dout0_8 Vdout0_8ck21 = 0 time = 440
.meas tran vdout0_8ck21 FIND v(dout0_8) AT=440.1n

* CHECK dout0_9 Vdout0_9ck21 = 0 time = 440
.meas tran vdout0_9ck21 FIND v(dout0_9) AT=440.1n

* CHECK dout0_10 Vdout0_10ck21 = 1.8 time = 440
.meas tran vdout0_10ck21 FIND v(dout0_10) AT=440.1n

* CHECK dout0_11 Vdout0_11ck21 = 1.8 time = 440
.meas tran vdout0_11ck21 FIND v(dout0_11) AT=440.1n

* CHECK dout0_12 Vdout0_12ck21 = 1.8 time = 440
.meas tran vdout0_12ck21 FIND v(dout0_12) AT=440.1n

* CHECK dout0_13 Vdout0_13ck21 = 1.8 time = 440
.meas tran vdout0_13ck21 FIND v(dout0_13) AT=440.1n

* CHECK dout0_14 Vdout0_14ck21 = 1.8 time = 440
.meas tran vdout0_14ck21 FIND v(dout0_14) AT=440.1n

* CHECK dout0_15 Vdout0_15ck21 = 1.8 time = 440
.meas tran vdout0_15ck21 FIND v(dout0_15) AT=440.1n

* CHECK dout0_0 Vdout0_0ck22 = 0 time = 460
.meas tran vdout0_0ck22 FIND v(dout0_0) AT=460.1n

* CHECK dout0_1 Vdout0_1ck22 = 0 time = 460
.meas tran vdout0_1ck22 FIND v(dout0_1) AT=460.1n

* CHECK dout0_2 Vdout0_2ck22 = 1.8 time = 460
.meas tran vdout0_2ck22 FIND v(dout0_2) AT=460.1n

* CHECK dout0_3 Vdout0_3ck22 = 0 time = 460
.meas tran vdout0_3ck22 FIND v(dout0_3) AT=460.1n

* CHECK dout0_4 Vdout0_4ck22 = 1.8 time = 460
.meas tran vdout0_4ck22 FIND v(dout0_4) AT=460.1n

* CHECK dout0_5 Vdout0_5ck22 = 1.8 time = 460
.meas tran vdout0_5ck22 FIND v(dout0_5) AT=460.1n

* CHECK dout0_6 Vdout0_6ck22 = 0 time = 460
.meas tran vdout0_6ck22 FIND v(dout0_6) AT=460.1n

* CHECK dout0_7 Vdout0_7ck22 = 1.8 time = 460
.meas tran vdout0_7ck22 FIND v(dout0_7) AT=460.1n

* CHECK dout0_8 Vdout0_8ck22 = 0 time = 460
.meas tran vdout0_8ck22 FIND v(dout0_8) AT=460.1n

* CHECK dout0_9 Vdout0_9ck22 = 0 time = 460
.meas tran vdout0_9ck22 FIND v(dout0_9) AT=460.1n

* CHECK dout0_10 Vdout0_10ck22 = 1.8 time = 460
.meas tran vdout0_10ck22 FIND v(dout0_10) AT=460.1n

* CHECK dout0_11 Vdout0_11ck22 = 1.8 time = 460
.meas tran vdout0_11ck22 FIND v(dout0_11) AT=460.1n

* CHECK dout0_12 Vdout0_12ck22 = 1.8 time = 460
.meas tran vdout0_12ck22 FIND v(dout0_12) AT=460.1n

* CHECK dout0_13 Vdout0_13ck22 = 1.8 time = 460
.meas tran vdout0_13ck22 FIND v(dout0_13) AT=460.1n

* CHECK dout0_14 Vdout0_14ck22 = 1.8 time = 460
.meas tran vdout0_14ck22 FIND v(dout0_14) AT=460.1n

* CHECK dout0_15 Vdout0_15ck22 = 1.8 time = 460
.meas tran vdout0_15ck22 FIND v(dout0_15) AT=460.1n

* CHECK dout0_0 Vdout0_0ck25 = 1.8 time = 520
.meas tran vdout0_0ck25 FIND v(dout0_0) AT=520.1n

* CHECK dout0_1 Vdout0_1ck25 = 1.8 time = 520
.meas tran vdout0_1ck25 FIND v(dout0_1) AT=520.1n

* CHECK dout0_2 Vdout0_2ck25 = 0 time = 520
.meas tran vdout0_2ck25 FIND v(dout0_2) AT=520.1n

* CHECK dout0_3 Vdout0_3ck25 = 0 time = 520
.meas tran vdout0_3ck25 FIND v(dout0_3) AT=520.1n

* CHECK dout0_4 Vdout0_4ck25 = 1.8 time = 520
.meas tran vdout0_4ck25 FIND v(dout0_4) AT=520.1n

* CHECK dout0_5 Vdout0_5ck25 = 1.8 time = 520
.meas tran vdout0_5ck25 FIND v(dout0_5) AT=520.1n

* CHECK dout0_6 Vdout0_6ck25 = 1.8 time = 520
.meas tran vdout0_6ck25 FIND v(dout0_6) AT=520.1n

* CHECK dout0_7 Vdout0_7ck25 = 1.8 time = 520
.meas tran vdout0_7ck25 FIND v(dout0_7) AT=520.1n

* CHECK dout0_8 Vdout0_8ck25 = 0 time = 520
.meas tran vdout0_8ck25 FIND v(dout0_8) AT=520.1n

* CHECK dout0_9 Vdout0_9ck25 = 1.8 time = 520
.meas tran vdout0_9ck25 FIND v(dout0_9) AT=520.1n

* CHECK dout0_10 Vdout0_10ck25 = 0 time = 520
.meas tran vdout0_10ck25 FIND v(dout0_10) AT=520.1n

* CHECK dout0_11 Vdout0_11ck25 = 0 time = 520
.meas tran vdout0_11ck25 FIND v(dout0_11) AT=520.1n

* CHECK dout0_12 Vdout0_12ck25 = 0 time = 520
.meas tran vdout0_12ck25 FIND v(dout0_12) AT=520.1n

* CHECK dout0_13 Vdout0_13ck25 = 0 time = 520
.meas tran vdout0_13ck25 FIND v(dout0_13) AT=520.1n

* CHECK dout0_14 Vdout0_14ck25 = 1.8 time = 520
.meas tran vdout0_14ck25 FIND v(dout0_14) AT=520.1n

* CHECK dout0_15 Vdout0_15ck25 = 1.8 time = 520
.meas tran vdout0_15ck25 FIND v(dout0_15) AT=520.1n

* CHECK dout0_0 Vdout0_0ck26 = 0 time = 540
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=540.1n

* CHECK dout0_1 Vdout0_1ck26 = 1.8 time = 540
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=540.1n

* CHECK dout0_2 Vdout0_2ck26 = 0 time = 540
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=540.1n

* CHECK dout0_3 Vdout0_3ck26 = 1.8 time = 540
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=540.1n

* CHECK dout0_4 Vdout0_4ck26 = 1.8 time = 540
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=540.1n

* CHECK dout0_5 Vdout0_5ck26 = 0 time = 540
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=540.1n

* CHECK dout0_6 Vdout0_6ck26 = 0 time = 540
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=540.1n

* CHECK dout0_7 Vdout0_7ck26 = 0 time = 540
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=540.1n

* CHECK dout0_8 Vdout0_8ck26 = 1.8 time = 540
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=540.1n

* CHECK dout0_9 Vdout0_9ck26 = 1.8 time = 540
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=540.1n

* CHECK dout0_10 Vdout0_10ck26 = 0 time = 540
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=540.1n

* CHECK dout0_11 Vdout0_11ck26 = 0 time = 540
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=540.1n

* CHECK dout0_12 Vdout0_12ck26 = 0 time = 540
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=540.1n

* CHECK dout0_13 Vdout0_13ck26 = 0 time = 540
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=540.1n

* CHECK dout0_14 Vdout0_14ck26 = 0 time = 540
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=540.1n

* CHECK dout0_15 Vdout0_15ck26 = 0 time = 540
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=540.1n

* CHECK dout0_0 Vdout0_0ck28 = 0 time = 580
.meas tran vdout0_0ck28 FIND v(dout0_0) AT=580.1n

* CHECK dout0_1 Vdout0_1ck28 = 1.8 time = 580
.meas tran vdout0_1ck28 FIND v(dout0_1) AT=580.1n

* CHECK dout0_2 Vdout0_2ck28 = 0 time = 580
.meas tran vdout0_2ck28 FIND v(dout0_2) AT=580.1n

* CHECK dout0_3 Vdout0_3ck28 = 1.8 time = 580
.meas tran vdout0_3ck28 FIND v(dout0_3) AT=580.1n

* CHECK dout0_4 Vdout0_4ck28 = 1.8 time = 580
.meas tran vdout0_4ck28 FIND v(dout0_4) AT=580.1n

* CHECK dout0_5 Vdout0_5ck28 = 0 time = 580
.meas tran vdout0_5ck28 FIND v(dout0_5) AT=580.1n

* CHECK dout0_6 Vdout0_6ck28 = 0 time = 580
.meas tran vdout0_6ck28 FIND v(dout0_6) AT=580.1n

* CHECK dout0_7 Vdout0_7ck28 = 0 time = 580
.meas tran vdout0_7ck28 FIND v(dout0_7) AT=580.1n

* CHECK dout0_8 Vdout0_8ck28 = 1.8 time = 580
.meas tran vdout0_8ck28 FIND v(dout0_8) AT=580.1n

* CHECK dout0_9 Vdout0_9ck28 = 1.8 time = 580
.meas tran vdout0_9ck28 FIND v(dout0_9) AT=580.1n

* CHECK dout0_10 Vdout0_10ck28 = 0 time = 580
.meas tran vdout0_10ck28 FIND v(dout0_10) AT=580.1n

* CHECK dout0_11 Vdout0_11ck28 = 0 time = 580
.meas tran vdout0_11ck28 FIND v(dout0_11) AT=580.1n

* CHECK dout0_12 Vdout0_12ck28 = 0 time = 580
.meas tran vdout0_12ck28 FIND v(dout0_12) AT=580.1n

* CHECK dout0_13 Vdout0_13ck28 = 0 time = 580
.meas tran vdout0_13ck28 FIND v(dout0_13) AT=580.1n

* CHECK dout0_14 Vdout0_14ck28 = 0 time = 580
.meas tran vdout0_14ck28 FIND v(dout0_14) AT=580.1n

* CHECK dout0_15 Vdout0_15ck28 = 0 time = 580
.meas tran vdout0_15ck28 FIND v(dout0_15) AT=580.1n

* CHECK dout0_0 Vdout0_0ck29 = 0 time = 600
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=600.1n

* CHECK dout0_1 Vdout0_1ck29 = 0 time = 600
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=600.1n

* CHECK dout0_2 Vdout0_2ck29 = 0 time = 600
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=600.1n

* CHECK dout0_3 Vdout0_3ck29 = 1.8 time = 600
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=600.1n

* CHECK dout0_4 Vdout0_4ck29 = 0 time = 600
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=600.1n

* CHECK dout0_5 Vdout0_5ck29 = 0 time = 600
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=600.1n

* CHECK dout0_6 Vdout0_6ck29 = 1.8 time = 600
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=600.1n

* CHECK dout0_7 Vdout0_7ck29 = 1.8 time = 600
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=600.1n

* CHECK dout0_8 Vdout0_8ck29 = 0 time = 600
.meas tran vdout0_8ck29 FIND v(dout0_8) AT=600.1n

* CHECK dout0_9 Vdout0_9ck29 = 1.8 time = 600
.meas tran vdout0_9ck29 FIND v(dout0_9) AT=600.1n

* CHECK dout0_10 Vdout0_10ck29 = 1.8 time = 600
.meas tran vdout0_10ck29 FIND v(dout0_10) AT=600.1n

* CHECK dout0_11 Vdout0_11ck29 = 0 time = 600
.meas tran vdout0_11ck29 FIND v(dout0_11) AT=600.1n

* CHECK dout0_12 Vdout0_12ck29 = 1.8 time = 600
.meas tran vdout0_12ck29 FIND v(dout0_12) AT=600.1n

* CHECK dout0_13 Vdout0_13ck29 = 1.8 time = 600
.meas tran vdout0_13ck29 FIND v(dout0_13) AT=600.1n

* CHECK dout0_14 Vdout0_14ck29 = 0 time = 600
.meas tran vdout0_14ck29 FIND v(dout0_14) AT=600.1n

* CHECK dout0_15 Vdout0_15ck29 = 0 time = 600
.meas tran vdout0_15ck29 FIND v(dout0_15) AT=600.1n

* CHECK dout0_0 Vdout0_0ck31 = 0 time = 640
.meas tran vdout0_0ck31 FIND v(dout0_0) AT=640.1n

* CHECK dout0_1 Vdout0_1ck31 = 0 time = 640
.meas tran vdout0_1ck31 FIND v(dout0_1) AT=640.1n

* CHECK dout0_2 Vdout0_2ck31 = 0 time = 640
.meas tran vdout0_2ck31 FIND v(dout0_2) AT=640.1n

* CHECK dout0_3 Vdout0_3ck31 = 1.8 time = 640
.meas tran vdout0_3ck31 FIND v(dout0_3) AT=640.1n

* CHECK dout0_4 Vdout0_4ck31 = 0 time = 640
.meas tran vdout0_4ck31 FIND v(dout0_4) AT=640.1n

* CHECK dout0_5 Vdout0_5ck31 = 0 time = 640
.meas tran vdout0_5ck31 FIND v(dout0_5) AT=640.1n

* CHECK dout0_6 Vdout0_6ck31 = 1.8 time = 640
.meas tran vdout0_6ck31 FIND v(dout0_6) AT=640.1n

* CHECK dout0_7 Vdout0_7ck31 = 1.8 time = 640
.meas tran vdout0_7ck31 FIND v(dout0_7) AT=640.1n

* CHECK dout0_8 Vdout0_8ck31 = 0 time = 640
.meas tran vdout0_8ck31 FIND v(dout0_8) AT=640.1n

* CHECK dout0_9 Vdout0_9ck31 = 1.8 time = 640
.meas tran vdout0_9ck31 FIND v(dout0_9) AT=640.1n

* CHECK dout0_10 Vdout0_10ck31 = 1.8 time = 640
.meas tran vdout0_10ck31 FIND v(dout0_10) AT=640.1n

* CHECK dout0_11 Vdout0_11ck31 = 0 time = 640
.meas tran vdout0_11ck31 FIND v(dout0_11) AT=640.1n

* CHECK dout0_12 Vdout0_12ck31 = 1.8 time = 640
.meas tran vdout0_12ck31 FIND v(dout0_12) AT=640.1n

* CHECK dout0_13 Vdout0_13ck31 = 1.8 time = 640
.meas tran vdout0_13ck31 FIND v(dout0_13) AT=640.1n

* CHECK dout0_14 Vdout0_14ck31 = 0 time = 640
.meas tran vdout0_14ck31 FIND v(dout0_14) AT=640.1n

* CHECK dout0_15 Vdout0_15ck31 = 0 time = 640
.meas tran vdout0_15ck31 FIND v(dout0_15) AT=640.1n

* CHECK dout0_0 Vdout0_0ck32 = 0 time = 660
.meas tran vdout0_0ck32 FIND v(dout0_0) AT=660.1n

* CHECK dout0_1 Vdout0_1ck32 = 0 time = 660
.meas tran vdout0_1ck32 FIND v(dout0_1) AT=660.1n

* CHECK dout0_2 Vdout0_2ck32 = 0 time = 660
.meas tran vdout0_2ck32 FIND v(dout0_2) AT=660.1n

* CHECK dout0_3 Vdout0_3ck32 = 1.8 time = 660
.meas tran vdout0_3ck32 FIND v(dout0_3) AT=660.1n

* CHECK dout0_4 Vdout0_4ck32 = 0 time = 660
.meas tran vdout0_4ck32 FIND v(dout0_4) AT=660.1n

* CHECK dout0_5 Vdout0_5ck32 = 0 time = 660
.meas tran vdout0_5ck32 FIND v(dout0_5) AT=660.1n

* CHECK dout0_6 Vdout0_6ck32 = 1.8 time = 660
.meas tran vdout0_6ck32 FIND v(dout0_6) AT=660.1n

* CHECK dout0_7 Vdout0_7ck32 = 1.8 time = 660
.meas tran vdout0_7ck32 FIND v(dout0_7) AT=660.1n

* CHECK dout0_8 Vdout0_8ck32 = 0 time = 660
.meas tran vdout0_8ck32 FIND v(dout0_8) AT=660.1n

* CHECK dout0_9 Vdout0_9ck32 = 1.8 time = 660
.meas tran vdout0_9ck32 FIND v(dout0_9) AT=660.1n

* CHECK dout0_10 Vdout0_10ck32 = 1.8 time = 660
.meas tran vdout0_10ck32 FIND v(dout0_10) AT=660.1n

* CHECK dout0_11 Vdout0_11ck32 = 0 time = 660
.meas tran vdout0_11ck32 FIND v(dout0_11) AT=660.1n

* CHECK dout0_12 Vdout0_12ck32 = 1.8 time = 660
.meas tran vdout0_12ck32 FIND v(dout0_12) AT=660.1n

* CHECK dout0_13 Vdout0_13ck32 = 1.8 time = 660
.meas tran vdout0_13ck32 FIND v(dout0_13) AT=660.1n

* CHECK dout0_14 Vdout0_14ck32 = 0 time = 660
.meas tran vdout0_14ck32 FIND v(dout0_14) AT=660.1n

* CHECK dout0_15 Vdout0_15ck32 = 0 time = 660
.meas tran vdout0_15ck32 FIND v(dout0_15) AT=660.1n

* CHECK dout0_0 Vdout0_0ck33 = 0 time = 680
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=680.1n

* CHECK dout0_1 Vdout0_1ck33 = 0 time = 680
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=680.1n

* CHECK dout0_2 Vdout0_2ck33 = 0 time = 680
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=680.1n

* CHECK dout0_3 Vdout0_3ck33 = 1.8 time = 680
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=680.1n

* CHECK dout0_4 Vdout0_4ck33 = 0 time = 680
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=680.1n

* CHECK dout0_5 Vdout0_5ck33 = 0 time = 680
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=680.1n

* CHECK dout0_6 Vdout0_6ck33 = 1.8 time = 680
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=680.1n

* CHECK dout0_7 Vdout0_7ck33 = 1.8 time = 680
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=680.1n

* CHECK dout0_8 Vdout0_8ck33 = 0 time = 680
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=680.1n

* CHECK dout0_9 Vdout0_9ck33 = 1.8 time = 680
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=680.1n

* CHECK dout0_10 Vdout0_10ck33 = 1.8 time = 680
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=680.1n

* CHECK dout0_11 Vdout0_11ck33 = 0 time = 680
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=680.1n

* CHECK dout0_12 Vdout0_12ck33 = 1.8 time = 680
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=680.1n

* CHECK dout0_13 Vdout0_13ck33 = 1.8 time = 680
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=680.1n

* CHECK dout0_14 Vdout0_14ck33 = 0 time = 680
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=680.1n

* CHECK dout0_15 Vdout0_15ck33 = 0 time = 680
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=680.1n

* CHECK dout0_0 Vdout0_0ck34 = 1.8 time = 700
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=700.1n

* CHECK dout0_1 Vdout0_1ck34 = 1.8 time = 700
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=700.1n

* CHECK dout0_2 Vdout0_2ck34 = 0 time = 700
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=700.1n

* CHECK dout0_3 Vdout0_3ck34 = 0 time = 700
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=700.1n

* CHECK dout0_4 Vdout0_4ck34 = 0 time = 700
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=700.1n

* CHECK dout0_5 Vdout0_5ck34 = 1.8 time = 700
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=700.1n

* CHECK dout0_6 Vdout0_6ck34 = 1.8 time = 700
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=700.1n

* CHECK dout0_7 Vdout0_7ck34 = 1.8 time = 700
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=700.1n

* CHECK dout0_8 Vdout0_8ck34 = 1.8 time = 700
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=700.1n

* CHECK dout0_9 Vdout0_9ck34 = 1.8 time = 700
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=700.1n

* CHECK dout0_10 Vdout0_10ck34 = 0 time = 700
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=700.1n

* CHECK dout0_11 Vdout0_11ck34 = 0 time = 700
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=700.1n

* CHECK dout0_12 Vdout0_12ck34 = 0 time = 700
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=700.1n

* CHECK dout0_13 Vdout0_13ck34 = 1.8 time = 700
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=700.1n

* CHECK dout0_14 Vdout0_14ck34 = 0 time = 700
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=700.1n

* CHECK dout0_15 Vdout0_15ck34 = 0 time = 700
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=700.1n

* CHECK dout0_0 Vdout0_0ck37 = 1.8 time = 760
.meas tran vdout0_0ck37 FIND v(dout0_0) AT=760.1n

* CHECK dout0_1 Vdout0_1ck37 = 1.8 time = 760
.meas tran vdout0_1ck37 FIND v(dout0_1) AT=760.1n

* CHECK dout0_2 Vdout0_2ck37 = 0 time = 760
.meas tran vdout0_2ck37 FIND v(dout0_2) AT=760.1n

* CHECK dout0_3 Vdout0_3ck37 = 1.8 time = 760
.meas tran vdout0_3ck37 FIND v(dout0_3) AT=760.1n

* CHECK dout0_4 Vdout0_4ck37 = 1.8 time = 760
.meas tran vdout0_4ck37 FIND v(dout0_4) AT=760.1n

* CHECK dout0_5 Vdout0_5ck37 = 0 time = 760
.meas tran vdout0_5ck37 FIND v(dout0_5) AT=760.1n

* CHECK dout0_6 Vdout0_6ck37 = 0 time = 760
.meas tran vdout0_6ck37 FIND v(dout0_6) AT=760.1n

* CHECK dout0_7 Vdout0_7ck37 = 0 time = 760
.meas tran vdout0_7ck37 FIND v(dout0_7) AT=760.1n

* CHECK dout0_8 Vdout0_8ck37 = 1.8 time = 760
.meas tran vdout0_8ck37 FIND v(dout0_8) AT=760.1n

* CHECK dout0_9 Vdout0_9ck37 = 1.8 time = 760
.meas tran vdout0_9ck37 FIND v(dout0_9) AT=760.1n

* CHECK dout0_10 Vdout0_10ck37 = 0 time = 760
.meas tran vdout0_10ck37 FIND v(dout0_10) AT=760.1n

* CHECK dout0_11 Vdout0_11ck37 = 1.8 time = 760
.meas tran vdout0_11ck37 FIND v(dout0_11) AT=760.1n

* CHECK dout0_12 Vdout0_12ck37 = 0 time = 760
.meas tran vdout0_12ck37 FIND v(dout0_12) AT=760.1n

* CHECK dout0_13 Vdout0_13ck37 = 1.8 time = 760
.meas tran vdout0_13ck37 FIND v(dout0_13) AT=760.1n

* CHECK dout0_14 Vdout0_14ck37 = 0 time = 760
.meas tran vdout0_14ck37 FIND v(dout0_14) AT=760.1n

* CHECK dout0_15 Vdout0_15ck37 = 1.8 time = 760
.meas tran vdout0_15ck37 FIND v(dout0_15) AT=760.1n

* CHECK dout0_0 Vdout0_0ck38 = 1.8 time = 780
.meas tran vdout0_0ck38 FIND v(dout0_0) AT=780.1n

* CHECK dout0_1 Vdout0_1ck38 = 1.8 time = 780
.meas tran vdout0_1ck38 FIND v(dout0_1) AT=780.1n

* CHECK dout0_2 Vdout0_2ck38 = 0 time = 780
.meas tran vdout0_2ck38 FIND v(dout0_2) AT=780.1n

* CHECK dout0_3 Vdout0_3ck38 = 0 time = 780
.meas tran vdout0_3ck38 FIND v(dout0_3) AT=780.1n

* CHECK dout0_4 Vdout0_4ck38 = 0 time = 780
.meas tran vdout0_4ck38 FIND v(dout0_4) AT=780.1n

* CHECK dout0_5 Vdout0_5ck38 = 1.8 time = 780
.meas tran vdout0_5ck38 FIND v(dout0_5) AT=780.1n

* CHECK dout0_6 Vdout0_6ck38 = 1.8 time = 780
.meas tran vdout0_6ck38 FIND v(dout0_6) AT=780.1n

* CHECK dout0_7 Vdout0_7ck38 = 1.8 time = 780
.meas tran vdout0_7ck38 FIND v(dout0_7) AT=780.1n

* CHECK dout0_8 Vdout0_8ck38 = 1.8 time = 780
.meas tran vdout0_8ck38 FIND v(dout0_8) AT=780.1n

* CHECK dout0_9 Vdout0_9ck38 = 1.8 time = 780
.meas tran vdout0_9ck38 FIND v(dout0_9) AT=780.1n

* CHECK dout0_10 Vdout0_10ck38 = 0 time = 780
.meas tran vdout0_10ck38 FIND v(dout0_10) AT=780.1n

* CHECK dout0_11 Vdout0_11ck38 = 0 time = 780
.meas tran vdout0_11ck38 FIND v(dout0_11) AT=780.1n

* CHECK dout0_12 Vdout0_12ck38 = 0 time = 780
.meas tran vdout0_12ck38 FIND v(dout0_12) AT=780.1n

* CHECK dout0_13 Vdout0_13ck38 = 1.8 time = 780
.meas tran vdout0_13ck38 FIND v(dout0_13) AT=780.1n

* CHECK dout0_14 Vdout0_14ck38 = 0 time = 780
.meas tran vdout0_14ck38 FIND v(dout0_14) AT=780.1n

* CHECK dout0_15 Vdout0_15ck38 = 0 time = 780
.meas tran vdout0_15ck38 FIND v(dout0_15) AT=780.1n

* CHECK dout0_0 Vdout0_0ck40 = 0 time = 820
.meas tran vdout0_0ck40 FIND v(dout0_0) AT=820.1n

* CHECK dout0_1 Vdout0_1ck40 = 0 time = 820
.meas tran vdout0_1ck40 FIND v(dout0_1) AT=820.1n

* CHECK dout0_2 Vdout0_2ck40 = 0 time = 820
.meas tran vdout0_2ck40 FIND v(dout0_2) AT=820.1n

* CHECK dout0_3 Vdout0_3ck40 = 1.8 time = 820
.meas tran vdout0_3ck40 FIND v(dout0_3) AT=820.1n

* CHECK dout0_4 Vdout0_4ck40 = 0 time = 820
.meas tran vdout0_4ck40 FIND v(dout0_4) AT=820.1n

* CHECK dout0_5 Vdout0_5ck40 = 0 time = 820
.meas tran vdout0_5ck40 FIND v(dout0_5) AT=820.1n

* CHECK dout0_6 Vdout0_6ck40 = 1.8 time = 820
.meas tran vdout0_6ck40 FIND v(dout0_6) AT=820.1n

* CHECK dout0_7 Vdout0_7ck40 = 1.8 time = 820
.meas tran vdout0_7ck40 FIND v(dout0_7) AT=820.1n

* CHECK dout0_8 Vdout0_8ck40 = 0 time = 820
.meas tran vdout0_8ck40 FIND v(dout0_8) AT=820.1n

* CHECK dout0_9 Vdout0_9ck40 = 1.8 time = 820
.meas tran vdout0_9ck40 FIND v(dout0_9) AT=820.1n

* CHECK dout0_10 Vdout0_10ck40 = 1.8 time = 820
.meas tran vdout0_10ck40 FIND v(dout0_10) AT=820.1n

* CHECK dout0_11 Vdout0_11ck40 = 0 time = 820
.meas tran vdout0_11ck40 FIND v(dout0_11) AT=820.1n

* CHECK dout0_12 Vdout0_12ck40 = 1.8 time = 820
.meas tran vdout0_12ck40 FIND v(dout0_12) AT=820.1n

* CHECK dout0_13 Vdout0_13ck40 = 1.8 time = 820
.meas tran vdout0_13ck40 FIND v(dout0_13) AT=820.1n

* CHECK dout0_14 Vdout0_14ck40 = 0 time = 820
.meas tran vdout0_14ck40 FIND v(dout0_14) AT=820.1n

* CHECK dout0_15 Vdout0_15ck40 = 0 time = 820
.meas tran vdout0_15ck40 FIND v(dout0_15) AT=820.1n

* CHECK dout0_0 Vdout0_0ck41 = 1.8 time = 840
.meas tran vdout0_0ck41 FIND v(dout0_0) AT=840.1n

* CHECK dout0_1 Vdout0_1ck41 = 0 time = 840
.meas tran vdout0_1ck41 FIND v(dout0_1) AT=840.1n

* CHECK dout0_2 Vdout0_2ck41 = 0 time = 840
.meas tran vdout0_2ck41 FIND v(dout0_2) AT=840.1n

* CHECK dout0_3 Vdout0_3ck41 = 0 time = 840
.meas tran vdout0_3ck41 FIND v(dout0_3) AT=840.1n

* CHECK dout0_4 Vdout0_4ck41 = 1.8 time = 840
.meas tran vdout0_4ck41 FIND v(dout0_4) AT=840.1n

* CHECK dout0_5 Vdout0_5ck41 = 1.8 time = 840
.meas tran vdout0_5ck41 FIND v(dout0_5) AT=840.1n

* CHECK dout0_6 Vdout0_6ck41 = 1.8 time = 840
.meas tran vdout0_6ck41 FIND v(dout0_6) AT=840.1n

* CHECK dout0_7 Vdout0_7ck41 = 1.8 time = 840
.meas tran vdout0_7ck41 FIND v(dout0_7) AT=840.1n

* CHECK dout0_8 Vdout0_8ck41 = 1.8 time = 840
.meas tran vdout0_8ck41 FIND v(dout0_8) AT=840.1n

* CHECK dout0_9 Vdout0_9ck41 = 0 time = 840
.meas tran vdout0_9ck41 FIND v(dout0_9) AT=840.1n

* CHECK dout0_10 Vdout0_10ck41 = 1.8 time = 840
.meas tran vdout0_10ck41 FIND v(dout0_10) AT=840.1n

* CHECK dout0_11 Vdout0_11ck41 = 1.8 time = 840
.meas tran vdout0_11ck41 FIND v(dout0_11) AT=840.1n

* CHECK dout0_12 Vdout0_12ck41 = 1.8 time = 840
.meas tran vdout0_12ck41 FIND v(dout0_12) AT=840.1n

* CHECK dout0_13 Vdout0_13ck41 = 1.8 time = 840
.meas tran vdout0_13ck41 FIND v(dout0_13) AT=840.1n

* CHECK dout0_14 Vdout0_14ck41 = 0 time = 840
.meas tran vdout0_14ck41 FIND v(dout0_14) AT=840.1n

* CHECK dout0_15 Vdout0_15ck41 = 1.8 time = 840
.meas tran vdout0_15ck41 FIND v(dout0_15) AT=840.1n

* CHECK dout0_0 Vdout0_0ck43 = 1.8 time = 880
.meas tran vdout0_0ck43 FIND v(dout0_0) AT=880.1n

* CHECK dout0_1 Vdout0_1ck43 = 0 time = 880
.meas tran vdout0_1ck43 FIND v(dout0_1) AT=880.1n

* CHECK dout0_2 Vdout0_2ck43 = 0 time = 880
.meas tran vdout0_2ck43 FIND v(dout0_2) AT=880.1n

* CHECK dout0_3 Vdout0_3ck43 = 0 time = 880
.meas tran vdout0_3ck43 FIND v(dout0_3) AT=880.1n

* CHECK dout0_4 Vdout0_4ck43 = 1.8 time = 880
.meas tran vdout0_4ck43 FIND v(dout0_4) AT=880.1n

* CHECK dout0_5 Vdout0_5ck43 = 1.8 time = 880
.meas tran vdout0_5ck43 FIND v(dout0_5) AT=880.1n

* CHECK dout0_6 Vdout0_6ck43 = 1.8 time = 880
.meas tran vdout0_6ck43 FIND v(dout0_6) AT=880.1n

* CHECK dout0_7 Vdout0_7ck43 = 1.8 time = 880
.meas tran vdout0_7ck43 FIND v(dout0_7) AT=880.1n

* CHECK dout0_8 Vdout0_8ck43 = 1.8 time = 880
.meas tran vdout0_8ck43 FIND v(dout0_8) AT=880.1n

* CHECK dout0_9 Vdout0_9ck43 = 0 time = 880
.meas tran vdout0_9ck43 FIND v(dout0_9) AT=880.1n

* CHECK dout0_10 Vdout0_10ck43 = 1.8 time = 880
.meas tran vdout0_10ck43 FIND v(dout0_10) AT=880.1n

* CHECK dout0_11 Vdout0_11ck43 = 1.8 time = 880
.meas tran vdout0_11ck43 FIND v(dout0_11) AT=880.1n

* CHECK dout0_12 Vdout0_12ck43 = 1.8 time = 880
.meas tran vdout0_12ck43 FIND v(dout0_12) AT=880.1n

* CHECK dout0_13 Vdout0_13ck43 = 1.8 time = 880
.meas tran vdout0_13ck43 FIND v(dout0_13) AT=880.1n

* CHECK dout0_14 Vdout0_14ck43 = 0 time = 880
.meas tran vdout0_14ck43 FIND v(dout0_14) AT=880.1n

* CHECK dout0_15 Vdout0_15ck43 = 1.8 time = 880
.meas tran vdout0_15ck43 FIND v(dout0_15) AT=880.1n

* CHECK dout0_0 Vdout0_0ck47 = 0 time = 960
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=960.1n

* CHECK dout0_1 Vdout0_1ck47 = 0 time = 960
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=960.1n

* CHECK dout0_2 Vdout0_2ck47 = 0 time = 960
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=960.1n

* CHECK dout0_3 Vdout0_3ck47 = 1.8 time = 960
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=960.1n

* CHECK dout0_4 Vdout0_4ck47 = 0 time = 960
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=960.1n

* CHECK dout0_5 Vdout0_5ck47 = 0 time = 960
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=960.1n

* CHECK dout0_6 Vdout0_6ck47 = 1.8 time = 960
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=960.1n

* CHECK dout0_7 Vdout0_7ck47 = 1.8 time = 960
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=960.1n

* CHECK dout0_8 Vdout0_8ck47 = 0 time = 960
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=960.1n

* CHECK dout0_9 Vdout0_9ck47 = 1.8 time = 960
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=960.1n

* CHECK dout0_10 Vdout0_10ck47 = 1.8 time = 960
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=960.1n

* CHECK dout0_11 Vdout0_11ck47 = 0 time = 960
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=960.1n

* CHECK dout0_12 Vdout0_12ck47 = 1.8 time = 960
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=960.1n

* CHECK dout0_13 Vdout0_13ck47 = 1.8 time = 960
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=960.1n

* CHECK dout0_14 Vdout0_14ck47 = 0 time = 960
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=960.1n

* CHECK dout0_15 Vdout0_15ck47 = 0 time = 960
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=960.1n

* CHECK dout0_0 Vdout0_0ck48 = 1.8 time = 980
.meas tran vdout0_0ck48 FIND v(dout0_0) AT=980.1n

* CHECK dout0_1 Vdout0_1ck48 = 1.8 time = 980
.meas tran vdout0_1ck48 FIND v(dout0_1) AT=980.1n

* CHECK dout0_2 Vdout0_2ck48 = 1.8 time = 980
.meas tran vdout0_2ck48 FIND v(dout0_2) AT=980.1n

* CHECK dout0_3 Vdout0_3ck48 = 1.8 time = 980
.meas tran vdout0_3ck48 FIND v(dout0_3) AT=980.1n

* CHECK dout0_4 Vdout0_4ck48 = 0 time = 980
.meas tran vdout0_4ck48 FIND v(dout0_4) AT=980.1n

* CHECK dout0_5 Vdout0_5ck48 = 1.8 time = 980
.meas tran vdout0_5ck48 FIND v(dout0_5) AT=980.1n

* CHECK dout0_6 Vdout0_6ck48 = 0 time = 980
.meas tran vdout0_6ck48 FIND v(dout0_6) AT=980.1n

* CHECK dout0_7 Vdout0_7ck48 = 1.8 time = 980
.meas tran vdout0_7ck48 FIND v(dout0_7) AT=980.1n

* CHECK dout0_8 Vdout0_8ck48 = 1.8 time = 980
.meas tran vdout0_8ck48 FIND v(dout0_8) AT=980.1n

* CHECK dout0_9 Vdout0_9ck48 = 1.8 time = 980
.meas tran vdout0_9ck48 FIND v(dout0_9) AT=980.1n

* CHECK dout0_10 Vdout0_10ck48 = 0 time = 980
.meas tran vdout0_10ck48 FIND v(dout0_10) AT=980.1n

* CHECK dout0_11 Vdout0_11ck48 = 0 time = 980
.meas tran vdout0_11ck48 FIND v(dout0_11) AT=980.1n

* CHECK dout0_12 Vdout0_12ck48 = 0 time = 980
.meas tran vdout0_12ck48 FIND v(dout0_12) AT=980.1n

* CHECK dout0_13 Vdout0_13ck48 = 1.8 time = 980
.meas tran vdout0_13ck48 FIND v(dout0_13) AT=980.1n

* CHECK dout0_14 Vdout0_14ck48 = 1.8 time = 980
.meas tran vdout0_14ck48 FIND v(dout0_14) AT=980.1n

* CHECK dout0_15 Vdout0_15ck48 = 0 time = 980
.meas tran vdout0_15ck48 FIND v(dout0_15) AT=980.1n

* CHECK dout0_0 Vdout0_0ck50 = 1.8 time = 1020
.meas tran vdout0_0ck50 FIND v(dout0_0) AT=1020.1n

* CHECK dout0_1 Vdout0_1ck50 = 1.8 time = 1020
.meas tran vdout0_1ck50 FIND v(dout0_1) AT=1020.1n

* CHECK dout0_2 Vdout0_2ck50 = 1.8 time = 1020
.meas tran vdout0_2ck50 FIND v(dout0_2) AT=1020.1n

* CHECK dout0_3 Vdout0_3ck50 = 0 time = 1020
.meas tran vdout0_3ck50 FIND v(dout0_3) AT=1020.1n

* CHECK dout0_4 Vdout0_4ck50 = 0 time = 1020
.meas tran vdout0_4ck50 FIND v(dout0_4) AT=1020.1n

* CHECK dout0_5 Vdout0_5ck50 = 1.8 time = 1020
.meas tran vdout0_5ck50 FIND v(dout0_5) AT=1020.1n

* CHECK dout0_6 Vdout0_6ck50 = 0 time = 1020
.meas tran vdout0_6ck50 FIND v(dout0_6) AT=1020.1n

* CHECK dout0_7 Vdout0_7ck50 = 0 time = 1020
.meas tran vdout0_7ck50 FIND v(dout0_7) AT=1020.1n

* CHECK dout0_8 Vdout0_8ck50 = 1.8 time = 1020
.meas tran vdout0_8ck50 FIND v(dout0_8) AT=1020.1n

* CHECK dout0_9 Vdout0_9ck50 = 1.8 time = 1020
.meas tran vdout0_9ck50 FIND v(dout0_9) AT=1020.1n

* CHECK dout0_10 Vdout0_10ck50 = 0 time = 1020
.meas tran vdout0_10ck50 FIND v(dout0_10) AT=1020.1n

* CHECK dout0_11 Vdout0_11ck50 = 1.8 time = 1020
.meas tran vdout0_11ck50 FIND v(dout0_11) AT=1020.1n

* CHECK dout0_12 Vdout0_12ck50 = 0 time = 1020
.meas tran vdout0_12ck50 FIND v(dout0_12) AT=1020.1n

* CHECK dout0_13 Vdout0_13ck50 = 0 time = 1020
.meas tran vdout0_13ck50 FIND v(dout0_13) AT=1020.1n

* CHECK dout0_14 Vdout0_14ck50 = 1.8 time = 1020
.meas tran vdout0_14ck50 FIND v(dout0_14) AT=1020.1n

* CHECK dout0_15 Vdout0_15ck50 = 0 time = 1020
.meas tran vdout0_15ck50 FIND v(dout0_15) AT=1020.1n

* CHECK dout0_0 Vdout0_0ck51 = 1.8 time = 1040
.meas tran vdout0_0ck51 FIND v(dout0_0) AT=1040.1n

* CHECK dout0_1 Vdout0_1ck51 = 1.8 time = 1040
.meas tran vdout0_1ck51 FIND v(dout0_1) AT=1040.1n

* CHECK dout0_2 Vdout0_2ck51 = 0 time = 1040
.meas tran vdout0_2ck51 FIND v(dout0_2) AT=1040.1n

* CHECK dout0_3 Vdout0_3ck51 = 0 time = 1040
.meas tran vdout0_3ck51 FIND v(dout0_3) AT=1040.1n

* CHECK dout0_4 Vdout0_4ck51 = 0 time = 1040
.meas tran vdout0_4ck51 FIND v(dout0_4) AT=1040.1n

* CHECK dout0_5 Vdout0_5ck51 = 1.8 time = 1040
.meas tran vdout0_5ck51 FIND v(dout0_5) AT=1040.1n

* CHECK dout0_6 Vdout0_6ck51 = 1.8 time = 1040
.meas tran vdout0_6ck51 FIND v(dout0_6) AT=1040.1n

* CHECK dout0_7 Vdout0_7ck51 = 1.8 time = 1040
.meas tran vdout0_7ck51 FIND v(dout0_7) AT=1040.1n

* CHECK dout0_8 Vdout0_8ck51 = 1.8 time = 1040
.meas tran vdout0_8ck51 FIND v(dout0_8) AT=1040.1n

* CHECK dout0_9 Vdout0_9ck51 = 1.8 time = 1040
.meas tran vdout0_9ck51 FIND v(dout0_9) AT=1040.1n

* CHECK dout0_10 Vdout0_10ck51 = 0 time = 1040
.meas tran vdout0_10ck51 FIND v(dout0_10) AT=1040.1n

* CHECK dout0_11 Vdout0_11ck51 = 0 time = 1040
.meas tran vdout0_11ck51 FIND v(dout0_11) AT=1040.1n

* CHECK dout0_12 Vdout0_12ck51 = 0 time = 1040
.meas tran vdout0_12ck51 FIND v(dout0_12) AT=1040.1n

* CHECK dout0_13 Vdout0_13ck51 = 1.8 time = 1040
.meas tran vdout0_13ck51 FIND v(dout0_13) AT=1040.1n

* CHECK dout0_14 Vdout0_14ck51 = 0 time = 1040
.meas tran vdout0_14ck51 FIND v(dout0_14) AT=1040.1n

* CHECK dout0_15 Vdout0_15ck51 = 0 time = 1040
.meas tran vdout0_15ck51 FIND v(dout0_15) AT=1040.1n

* CHECK dout0_0 Vdout0_0ck56 = 1.8 time = 1140
.meas tran vdout0_0ck56 FIND v(dout0_0) AT=1140.1n

* CHECK dout0_1 Vdout0_1ck56 = 0 time = 1140
.meas tran vdout0_1ck56 FIND v(dout0_1) AT=1140.1n

* CHECK dout0_2 Vdout0_2ck56 = 0 time = 1140
.meas tran vdout0_2ck56 FIND v(dout0_2) AT=1140.1n

* CHECK dout0_3 Vdout0_3ck56 = 0 time = 1140
.meas tran vdout0_3ck56 FIND v(dout0_3) AT=1140.1n

* CHECK dout0_4 Vdout0_4ck56 = 1.8 time = 1140
.meas tran vdout0_4ck56 FIND v(dout0_4) AT=1140.1n

* CHECK dout0_5 Vdout0_5ck56 = 1.8 time = 1140
.meas tran vdout0_5ck56 FIND v(dout0_5) AT=1140.1n

* CHECK dout0_6 Vdout0_6ck56 = 1.8 time = 1140
.meas tran vdout0_6ck56 FIND v(dout0_6) AT=1140.1n

* CHECK dout0_7 Vdout0_7ck56 = 1.8 time = 1140
.meas tran vdout0_7ck56 FIND v(dout0_7) AT=1140.1n

* CHECK dout0_8 Vdout0_8ck56 = 1.8 time = 1140
.meas tran vdout0_8ck56 FIND v(dout0_8) AT=1140.1n

* CHECK dout0_9 Vdout0_9ck56 = 0 time = 1140
.meas tran vdout0_9ck56 FIND v(dout0_9) AT=1140.1n

* CHECK dout0_10 Vdout0_10ck56 = 1.8 time = 1140
.meas tran vdout0_10ck56 FIND v(dout0_10) AT=1140.1n

* CHECK dout0_11 Vdout0_11ck56 = 1.8 time = 1140
.meas tran vdout0_11ck56 FIND v(dout0_11) AT=1140.1n

* CHECK dout0_12 Vdout0_12ck56 = 1.8 time = 1140
.meas tran vdout0_12ck56 FIND v(dout0_12) AT=1140.1n

* CHECK dout0_13 Vdout0_13ck56 = 1.8 time = 1140
.meas tran vdout0_13ck56 FIND v(dout0_13) AT=1140.1n

* CHECK dout0_14 Vdout0_14ck56 = 0 time = 1140
.meas tran vdout0_14ck56 FIND v(dout0_14) AT=1140.1n

* CHECK dout0_15 Vdout0_15ck56 = 1.8 time = 1140
.meas tran vdout0_15ck56 FIND v(dout0_15) AT=1140.1n

* CHECK dout0_0 Vdout0_0ck57 = 1.8 time = 1160
.meas tran vdout0_0ck57 FIND v(dout0_0) AT=1160.1n

* CHECK dout0_1 Vdout0_1ck57 = 1.8 time = 1160
.meas tran vdout0_1ck57 FIND v(dout0_1) AT=1160.1n

* CHECK dout0_2 Vdout0_2ck57 = 0 time = 1160
.meas tran vdout0_2ck57 FIND v(dout0_2) AT=1160.1n

* CHECK dout0_3 Vdout0_3ck57 = 0 time = 1160
.meas tran vdout0_3ck57 FIND v(dout0_3) AT=1160.1n

* CHECK dout0_4 Vdout0_4ck57 = 0 time = 1160
.meas tran vdout0_4ck57 FIND v(dout0_4) AT=1160.1n

* CHECK dout0_5 Vdout0_5ck57 = 1.8 time = 1160
.meas tran vdout0_5ck57 FIND v(dout0_5) AT=1160.1n

* CHECK dout0_6 Vdout0_6ck57 = 1.8 time = 1160
.meas tran vdout0_6ck57 FIND v(dout0_6) AT=1160.1n

* CHECK dout0_7 Vdout0_7ck57 = 1.8 time = 1160
.meas tran vdout0_7ck57 FIND v(dout0_7) AT=1160.1n

* CHECK dout0_8 Vdout0_8ck57 = 1.8 time = 1160
.meas tran vdout0_8ck57 FIND v(dout0_8) AT=1160.1n

* CHECK dout0_9 Vdout0_9ck57 = 1.8 time = 1160
.meas tran vdout0_9ck57 FIND v(dout0_9) AT=1160.1n

* CHECK dout0_10 Vdout0_10ck57 = 0 time = 1160
.meas tran vdout0_10ck57 FIND v(dout0_10) AT=1160.1n

* CHECK dout0_11 Vdout0_11ck57 = 0 time = 1160
.meas tran vdout0_11ck57 FIND v(dout0_11) AT=1160.1n

* CHECK dout0_12 Vdout0_12ck57 = 0 time = 1160
.meas tran vdout0_12ck57 FIND v(dout0_12) AT=1160.1n

* CHECK dout0_13 Vdout0_13ck57 = 1.8 time = 1160
.meas tran vdout0_13ck57 FIND v(dout0_13) AT=1160.1n

* CHECK dout0_14 Vdout0_14ck57 = 0 time = 1160
.meas tran vdout0_14ck57 FIND v(dout0_14) AT=1160.1n

* CHECK dout0_15 Vdout0_15ck57 = 0 time = 1160
.meas tran vdout0_15ck57 FIND v(dout0_15) AT=1160.1n

* CHECK dout0_0 Vdout0_0ck63 = 1.8 time = 1280
.meas tran vdout0_0ck63 FIND v(dout0_0) AT=1280.1n

* CHECK dout0_1 Vdout0_1ck63 = 1.8 time = 1280
.meas tran vdout0_1ck63 FIND v(dout0_1) AT=1280.1n

* CHECK dout0_2 Vdout0_2ck63 = 0 time = 1280
.meas tran vdout0_2ck63 FIND v(dout0_2) AT=1280.1n

* CHECK dout0_3 Vdout0_3ck63 = 0 time = 1280
.meas tran vdout0_3ck63 FIND v(dout0_3) AT=1280.1n

* CHECK dout0_4 Vdout0_4ck63 = 0 time = 1280
.meas tran vdout0_4ck63 FIND v(dout0_4) AT=1280.1n

* CHECK dout0_5 Vdout0_5ck63 = 1.8 time = 1280
.meas tran vdout0_5ck63 FIND v(dout0_5) AT=1280.1n

* CHECK dout0_6 Vdout0_6ck63 = 1.8 time = 1280
.meas tran vdout0_6ck63 FIND v(dout0_6) AT=1280.1n

* CHECK dout0_7 Vdout0_7ck63 = 1.8 time = 1280
.meas tran vdout0_7ck63 FIND v(dout0_7) AT=1280.1n

* CHECK dout0_8 Vdout0_8ck63 = 1.8 time = 1280
.meas tran vdout0_8ck63 FIND v(dout0_8) AT=1280.1n

* CHECK dout0_9 Vdout0_9ck63 = 1.8 time = 1280
.meas tran vdout0_9ck63 FIND v(dout0_9) AT=1280.1n

* CHECK dout0_10 Vdout0_10ck63 = 0 time = 1280
.meas tran vdout0_10ck63 FIND v(dout0_10) AT=1280.1n

* CHECK dout0_11 Vdout0_11ck63 = 0 time = 1280
.meas tran vdout0_11ck63 FIND v(dout0_11) AT=1280.1n

* CHECK dout0_12 Vdout0_12ck63 = 0 time = 1280
.meas tran vdout0_12ck63 FIND v(dout0_12) AT=1280.1n

* CHECK dout0_13 Vdout0_13ck63 = 1.8 time = 1280
.meas tran vdout0_13ck63 FIND v(dout0_13) AT=1280.1n

* CHECK dout0_14 Vdout0_14ck63 = 0 time = 1280
.meas tran vdout0_14ck63 FIND v(dout0_14) AT=1280.1n

* CHECK dout0_15 Vdout0_15ck63 = 0 time = 1280
.meas tran vdout0_15ck63 FIND v(dout0_15) AT=1280.1n

* CHECK dout0_0 Vdout0_0ck64 = 1.8 time = 1300
.meas tran vdout0_0ck64 FIND v(dout0_0) AT=1300.1n

* CHECK dout0_1 Vdout0_1ck64 = 1.8 time = 1300
.meas tran vdout0_1ck64 FIND v(dout0_1) AT=1300.1n

* CHECK dout0_2 Vdout0_2ck64 = 0 time = 1300
.meas tran vdout0_2ck64 FIND v(dout0_2) AT=1300.1n

* CHECK dout0_3 Vdout0_3ck64 = 1.8 time = 1300
.meas tran vdout0_3ck64 FIND v(dout0_3) AT=1300.1n

* CHECK dout0_4 Vdout0_4ck64 = 1.8 time = 1300
.meas tran vdout0_4ck64 FIND v(dout0_4) AT=1300.1n

* CHECK dout0_5 Vdout0_5ck64 = 1.8 time = 1300
.meas tran vdout0_5ck64 FIND v(dout0_5) AT=1300.1n

* CHECK dout0_6 Vdout0_6ck64 = 1.8 time = 1300
.meas tran vdout0_6ck64 FIND v(dout0_6) AT=1300.1n

* CHECK dout0_7 Vdout0_7ck64 = 1.8 time = 1300
.meas tran vdout0_7ck64 FIND v(dout0_7) AT=1300.1n

* CHECK dout0_8 Vdout0_8ck64 = 0 time = 1300
.meas tran vdout0_8ck64 FIND v(dout0_8) AT=1300.1n

* CHECK dout0_9 Vdout0_9ck64 = 0 time = 1300
.meas tran vdout0_9ck64 FIND v(dout0_9) AT=1300.1n

* CHECK dout0_10 Vdout0_10ck64 = 0 time = 1300
.meas tran vdout0_10ck64 FIND v(dout0_10) AT=1300.1n

* CHECK dout0_11 Vdout0_11ck64 = 1.8 time = 1300
.meas tran vdout0_11ck64 FIND v(dout0_11) AT=1300.1n

* CHECK dout0_12 Vdout0_12ck64 = 0 time = 1300
.meas tran vdout0_12ck64 FIND v(dout0_12) AT=1300.1n

* CHECK dout0_13 Vdout0_13ck64 = 0 time = 1300
.meas tran vdout0_13ck64 FIND v(dout0_13) AT=1300.1n

* CHECK dout0_14 Vdout0_14ck64 = 0 time = 1300
.meas tran vdout0_14ck64 FIND v(dout0_14) AT=1300.1n

* CHECK dout0_15 Vdout0_15ck64 = 0 time = 1300
.meas tran vdout0_15ck64 FIND v(dout0_15) AT=1300.1n

* CHECK dout0_0 Vdout0_0ck65 = 1.8 time = 1320
.meas tran vdout0_0ck65 FIND v(dout0_0) AT=1320.1n

* CHECK dout0_1 Vdout0_1ck65 = 1.8 time = 1320
.meas tran vdout0_1ck65 FIND v(dout0_1) AT=1320.1n

* CHECK dout0_2 Vdout0_2ck65 = 0 time = 1320
.meas tran vdout0_2ck65 FIND v(dout0_2) AT=1320.1n

* CHECK dout0_3 Vdout0_3ck65 = 0 time = 1320
.meas tran vdout0_3ck65 FIND v(dout0_3) AT=1320.1n

* CHECK dout0_4 Vdout0_4ck65 = 1.8 time = 1320
.meas tran vdout0_4ck65 FIND v(dout0_4) AT=1320.1n

* CHECK dout0_5 Vdout0_5ck65 = 0 time = 1320
.meas tran vdout0_5ck65 FIND v(dout0_5) AT=1320.1n

* CHECK dout0_6 Vdout0_6ck65 = 1.8 time = 1320
.meas tran vdout0_6ck65 FIND v(dout0_6) AT=1320.1n

* CHECK dout0_7 Vdout0_7ck65 = 0 time = 1320
.meas tran vdout0_7ck65 FIND v(dout0_7) AT=1320.1n

* CHECK dout0_8 Vdout0_8ck65 = 1.8 time = 1320
.meas tran vdout0_8ck65 FIND v(dout0_8) AT=1320.1n

* CHECK dout0_9 Vdout0_9ck65 = 1.8 time = 1320
.meas tran vdout0_9ck65 FIND v(dout0_9) AT=1320.1n

* CHECK dout0_10 Vdout0_10ck65 = 0 time = 1320
.meas tran vdout0_10ck65 FIND v(dout0_10) AT=1320.1n

* CHECK dout0_11 Vdout0_11ck65 = 1.8 time = 1320
.meas tran vdout0_11ck65 FIND v(dout0_11) AT=1320.1n

* CHECK dout0_12 Vdout0_12ck65 = 1.8 time = 1320
.meas tran vdout0_12ck65 FIND v(dout0_12) AT=1320.1n

* CHECK dout0_13 Vdout0_13ck65 = 0 time = 1320
.meas tran vdout0_13ck65 FIND v(dout0_13) AT=1320.1n

* CHECK dout0_14 Vdout0_14ck65 = 1.8 time = 1320
.meas tran vdout0_14ck65 FIND v(dout0_14) AT=1320.1n

* CHECK dout0_15 Vdout0_15ck65 = 1.8 time = 1320
.meas tran vdout0_15ck65 FIND v(dout0_15) AT=1320.1n

* CHECK dout0_0 Vdout0_0ck66 = 0 time = 1340
.meas tran vdout0_0ck66 FIND v(dout0_0) AT=1340.1n

* CHECK dout0_1 Vdout0_1ck66 = 1.8 time = 1340
.meas tran vdout0_1ck66 FIND v(dout0_1) AT=1340.1n

* CHECK dout0_2 Vdout0_2ck66 = 0 time = 1340
.meas tran vdout0_2ck66 FIND v(dout0_2) AT=1340.1n

* CHECK dout0_3 Vdout0_3ck66 = 0 time = 1340
.meas tran vdout0_3ck66 FIND v(dout0_3) AT=1340.1n

* CHECK dout0_4 Vdout0_4ck66 = 0 time = 1340
.meas tran vdout0_4ck66 FIND v(dout0_4) AT=1340.1n

* CHECK dout0_5 Vdout0_5ck66 = 0 time = 1340
.meas tran vdout0_5ck66 FIND v(dout0_5) AT=1340.1n

* CHECK dout0_6 Vdout0_6ck66 = 1.8 time = 1340
.meas tran vdout0_6ck66 FIND v(dout0_6) AT=1340.1n

* CHECK dout0_7 Vdout0_7ck66 = 1.8 time = 1340
.meas tran vdout0_7ck66 FIND v(dout0_7) AT=1340.1n

* CHECK dout0_8 Vdout0_8ck66 = 1.8 time = 1340
.meas tran vdout0_8ck66 FIND v(dout0_8) AT=1340.1n

* CHECK dout0_9 Vdout0_9ck66 = 1.8 time = 1340
.meas tran vdout0_9ck66 FIND v(dout0_9) AT=1340.1n

* CHECK dout0_10 Vdout0_10ck66 = 1.8 time = 1340
.meas tran vdout0_10ck66 FIND v(dout0_10) AT=1340.1n

* CHECK dout0_11 Vdout0_11ck66 = 0 time = 1340
.meas tran vdout0_11ck66 FIND v(dout0_11) AT=1340.1n

* CHECK dout0_12 Vdout0_12ck66 = 1.8 time = 1340
.meas tran vdout0_12ck66 FIND v(dout0_12) AT=1340.1n

* CHECK dout0_13 Vdout0_13ck66 = 1.8 time = 1340
.meas tran vdout0_13ck66 FIND v(dout0_13) AT=1340.1n

* CHECK dout0_14 Vdout0_14ck66 = 1.8 time = 1340
.meas tran vdout0_14ck66 FIND v(dout0_14) AT=1340.1n

* CHECK dout0_15 Vdout0_15ck66 = 0 time = 1340
.meas tran vdout0_15ck66 FIND v(dout0_15) AT=1340.1n

* CHECK dout0_0 Vdout0_0ck68 = 1.8 time = 1380
.meas tran vdout0_0ck68 FIND v(dout0_0) AT=1380.1n

* CHECK dout0_1 Vdout0_1ck68 = 0 time = 1380
.meas tran vdout0_1ck68 FIND v(dout0_1) AT=1380.1n

* CHECK dout0_2 Vdout0_2ck68 = 0 time = 1380
.meas tran vdout0_2ck68 FIND v(dout0_2) AT=1380.1n

* CHECK dout0_3 Vdout0_3ck68 = 0 time = 1380
.meas tran vdout0_3ck68 FIND v(dout0_3) AT=1380.1n

* CHECK dout0_4 Vdout0_4ck68 = 1.8 time = 1380
.meas tran vdout0_4ck68 FIND v(dout0_4) AT=1380.1n

* CHECK dout0_5 Vdout0_5ck68 = 1.8 time = 1380
.meas tran vdout0_5ck68 FIND v(dout0_5) AT=1380.1n

* CHECK dout0_6 Vdout0_6ck68 = 1.8 time = 1380
.meas tran vdout0_6ck68 FIND v(dout0_6) AT=1380.1n

* CHECK dout0_7 Vdout0_7ck68 = 1.8 time = 1380
.meas tran vdout0_7ck68 FIND v(dout0_7) AT=1380.1n

* CHECK dout0_8 Vdout0_8ck68 = 1.8 time = 1380
.meas tran vdout0_8ck68 FIND v(dout0_8) AT=1380.1n

* CHECK dout0_9 Vdout0_9ck68 = 0 time = 1380
.meas tran vdout0_9ck68 FIND v(dout0_9) AT=1380.1n

* CHECK dout0_10 Vdout0_10ck68 = 1.8 time = 1380
.meas tran vdout0_10ck68 FIND v(dout0_10) AT=1380.1n

* CHECK dout0_11 Vdout0_11ck68 = 1.8 time = 1380
.meas tran vdout0_11ck68 FIND v(dout0_11) AT=1380.1n

* CHECK dout0_12 Vdout0_12ck68 = 1.8 time = 1380
.meas tran vdout0_12ck68 FIND v(dout0_12) AT=1380.1n

* CHECK dout0_13 Vdout0_13ck68 = 1.8 time = 1380
.meas tran vdout0_13ck68 FIND v(dout0_13) AT=1380.1n

* CHECK dout0_14 Vdout0_14ck68 = 0 time = 1380
.meas tran vdout0_14ck68 FIND v(dout0_14) AT=1380.1n

* CHECK dout0_15 Vdout0_15ck68 = 1.8 time = 1380
.meas tran vdout0_15ck68 FIND v(dout0_15) AT=1380.1n

* CHECK dout0_0 Vdout0_0ck70 = 1.8 time = 1420
.meas tran vdout0_0ck70 FIND v(dout0_0) AT=1420.1n

* CHECK dout0_1 Vdout0_1ck70 = 0 time = 1420
.meas tran vdout0_1ck70 FIND v(dout0_1) AT=1420.1n

* CHECK dout0_2 Vdout0_2ck70 = 0 time = 1420
.meas tran vdout0_2ck70 FIND v(dout0_2) AT=1420.1n

* CHECK dout0_3 Vdout0_3ck70 = 0 time = 1420
.meas tran vdout0_3ck70 FIND v(dout0_3) AT=1420.1n

* CHECK dout0_4 Vdout0_4ck70 = 1.8 time = 1420
.meas tran vdout0_4ck70 FIND v(dout0_4) AT=1420.1n

* CHECK dout0_5 Vdout0_5ck70 = 1.8 time = 1420
.meas tran vdout0_5ck70 FIND v(dout0_5) AT=1420.1n

* CHECK dout0_6 Vdout0_6ck70 = 1.8 time = 1420
.meas tran vdout0_6ck70 FIND v(dout0_6) AT=1420.1n

* CHECK dout0_7 Vdout0_7ck70 = 1.8 time = 1420
.meas tran vdout0_7ck70 FIND v(dout0_7) AT=1420.1n

* CHECK dout0_8 Vdout0_8ck70 = 1.8 time = 1420
.meas tran vdout0_8ck70 FIND v(dout0_8) AT=1420.1n

* CHECK dout0_9 Vdout0_9ck70 = 0 time = 1420
.meas tran vdout0_9ck70 FIND v(dout0_9) AT=1420.1n

* CHECK dout0_10 Vdout0_10ck70 = 1.8 time = 1420
.meas tran vdout0_10ck70 FIND v(dout0_10) AT=1420.1n

* CHECK dout0_11 Vdout0_11ck70 = 1.8 time = 1420
.meas tran vdout0_11ck70 FIND v(dout0_11) AT=1420.1n

* CHECK dout0_12 Vdout0_12ck70 = 1.8 time = 1420
.meas tran vdout0_12ck70 FIND v(dout0_12) AT=1420.1n

* CHECK dout0_13 Vdout0_13ck70 = 1.8 time = 1420
.meas tran vdout0_13ck70 FIND v(dout0_13) AT=1420.1n

* CHECK dout0_14 Vdout0_14ck70 = 0 time = 1420
.meas tran vdout0_14ck70 FIND v(dout0_14) AT=1420.1n

* CHECK dout0_15 Vdout0_15ck70 = 1.8 time = 1420
.meas tran vdout0_15ck70 FIND v(dout0_15) AT=1420.1n

* CHECK dout0_0 Vdout0_0ck72 = 0 time = 1460
.meas tran vdout0_0ck72 FIND v(dout0_0) AT=1460.1n

* CHECK dout0_1 Vdout0_1ck72 = 1.8 time = 1460
.meas tran vdout0_1ck72 FIND v(dout0_1) AT=1460.1n

* CHECK dout0_2 Vdout0_2ck72 = 0 time = 1460
.meas tran vdout0_2ck72 FIND v(dout0_2) AT=1460.1n

* CHECK dout0_3 Vdout0_3ck72 = 0 time = 1460
.meas tran vdout0_3ck72 FIND v(dout0_3) AT=1460.1n

* CHECK dout0_4 Vdout0_4ck72 = 0 time = 1460
.meas tran vdout0_4ck72 FIND v(dout0_4) AT=1460.1n

* CHECK dout0_5 Vdout0_5ck72 = 0 time = 1460
.meas tran vdout0_5ck72 FIND v(dout0_5) AT=1460.1n

* CHECK dout0_6 Vdout0_6ck72 = 1.8 time = 1460
.meas tran vdout0_6ck72 FIND v(dout0_6) AT=1460.1n

* CHECK dout0_7 Vdout0_7ck72 = 1.8 time = 1460
.meas tran vdout0_7ck72 FIND v(dout0_7) AT=1460.1n

* CHECK dout0_8 Vdout0_8ck72 = 1.8 time = 1460
.meas tran vdout0_8ck72 FIND v(dout0_8) AT=1460.1n

* CHECK dout0_9 Vdout0_9ck72 = 1.8 time = 1460
.meas tran vdout0_9ck72 FIND v(dout0_9) AT=1460.1n

* CHECK dout0_10 Vdout0_10ck72 = 1.8 time = 1460
.meas tran vdout0_10ck72 FIND v(dout0_10) AT=1460.1n

* CHECK dout0_11 Vdout0_11ck72 = 0 time = 1460
.meas tran vdout0_11ck72 FIND v(dout0_11) AT=1460.1n

* CHECK dout0_12 Vdout0_12ck72 = 1.8 time = 1460
.meas tran vdout0_12ck72 FIND v(dout0_12) AT=1460.1n

* CHECK dout0_13 Vdout0_13ck72 = 1.8 time = 1460
.meas tran vdout0_13ck72 FIND v(dout0_13) AT=1460.1n

* CHECK dout0_14 Vdout0_14ck72 = 1.8 time = 1460
.meas tran vdout0_14ck72 FIND v(dout0_14) AT=1460.1n

* CHECK dout0_15 Vdout0_15ck72 = 0 time = 1460
.meas tran vdout0_15ck72 FIND v(dout0_15) AT=1460.1n

* CHECK dout0_0 Vdout0_0ck74 = 1.8 time = 1500
.meas tran vdout0_0ck74 FIND v(dout0_0) AT=1500.1n

* CHECK dout0_1 Vdout0_1ck74 = 1.8 time = 1500
.meas tran vdout0_1ck74 FIND v(dout0_1) AT=1500.1n

* CHECK dout0_2 Vdout0_2ck74 = 0 time = 1500
.meas tran vdout0_2ck74 FIND v(dout0_2) AT=1500.1n

* CHECK dout0_3 Vdout0_3ck74 = 1.8 time = 1500
.meas tran vdout0_3ck74 FIND v(dout0_3) AT=1500.1n

* CHECK dout0_4 Vdout0_4ck74 = 1.8 time = 1500
.meas tran vdout0_4ck74 FIND v(dout0_4) AT=1500.1n

* CHECK dout0_5 Vdout0_5ck74 = 0 time = 1500
.meas tran vdout0_5ck74 FIND v(dout0_5) AT=1500.1n

* CHECK dout0_6 Vdout0_6ck74 = 0 time = 1500
.meas tran vdout0_6ck74 FIND v(dout0_6) AT=1500.1n

* CHECK dout0_7 Vdout0_7ck74 = 1.8 time = 1500
.meas tran vdout0_7ck74 FIND v(dout0_7) AT=1500.1n

* CHECK dout0_8 Vdout0_8ck74 = 1.8 time = 1500
.meas tran vdout0_8ck74 FIND v(dout0_8) AT=1500.1n

* CHECK dout0_9 Vdout0_9ck74 = 1.8 time = 1500
.meas tran vdout0_9ck74 FIND v(dout0_9) AT=1500.1n

* CHECK dout0_10 Vdout0_10ck74 = 0 time = 1500
.meas tran vdout0_10ck74 FIND v(dout0_10) AT=1500.1n

* CHECK dout0_11 Vdout0_11ck74 = 0 time = 1500
.meas tran vdout0_11ck74 FIND v(dout0_11) AT=1500.1n

* CHECK dout0_12 Vdout0_12ck74 = 1.8 time = 1500
.meas tran vdout0_12ck74 FIND v(dout0_12) AT=1500.1n

* CHECK dout0_13 Vdout0_13ck74 = 1.8 time = 1500
.meas tran vdout0_13ck74 FIND v(dout0_13) AT=1500.1n

* CHECK dout0_14 Vdout0_14ck74 = 1.8 time = 1500
.meas tran vdout0_14ck74 FIND v(dout0_14) AT=1500.1n

* CHECK dout0_15 Vdout0_15ck74 = 0 time = 1500
.meas tran vdout0_15ck74 FIND v(dout0_15) AT=1500.1n

* CHECK dout0_0 Vdout0_0ck75 = 1.8 time = 1520
.meas tran vdout0_0ck75 FIND v(dout0_0) AT=1520.1n

* CHECK dout0_1 Vdout0_1ck75 = 0 time = 1520
.meas tran vdout0_1ck75 FIND v(dout0_1) AT=1520.1n

* CHECK dout0_2 Vdout0_2ck75 = 0 time = 1520
.meas tran vdout0_2ck75 FIND v(dout0_2) AT=1520.1n

* CHECK dout0_3 Vdout0_3ck75 = 0 time = 1520
.meas tran vdout0_3ck75 FIND v(dout0_3) AT=1520.1n

* CHECK dout0_4 Vdout0_4ck75 = 1.8 time = 1520
.meas tran vdout0_4ck75 FIND v(dout0_4) AT=1520.1n

* CHECK dout0_5 Vdout0_5ck75 = 1.8 time = 1520
.meas tran vdout0_5ck75 FIND v(dout0_5) AT=1520.1n

* CHECK dout0_6 Vdout0_6ck75 = 1.8 time = 1520
.meas tran vdout0_6ck75 FIND v(dout0_6) AT=1520.1n

* CHECK dout0_7 Vdout0_7ck75 = 1.8 time = 1520
.meas tran vdout0_7ck75 FIND v(dout0_7) AT=1520.1n

* CHECK dout0_8 Vdout0_8ck75 = 1.8 time = 1520
.meas tran vdout0_8ck75 FIND v(dout0_8) AT=1520.1n

* CHECK dout0_9 Vdout0_9ck75 = 0 time = 1520
.meas tran vdout0_9ck75 FIND v(dout0_9) AT=1520.1n

* CHECK dout0_10 Vdout0_10ck75 = 1.8 time = 1520
.meas tran vdout0_10ck75 FIND v(dout0_10) AT=1520.1n

* CHECK dout0_11 Vdout0_11ck75 = 1.8 time = 1520
.meas tran vdout0_11ck75 FIND v(dout0_11) AT=1520.1n

* CHECK dout0_12 Vdout0_12ck75 = 1.8 time = 1520
.meas tran vdout0_12ck75 FIND v(dout0_12) AT=1520.1n

* CHECK dout0_13 Vdout0_13ck75 = 1.8 time = 1520
.meas tran vdout0_13ck75 FIND v(dout0_13) AT=1520.1n

* CHECK dout0_14 Vdout0_14ck75 = 0 time = 1520
.meas tran vdout0_14ck75 FIND v(dout0_14) AT=1520.1n

* CHECK dout0_15 Vdout0_15ck75 = 1.8 time = 1520
.meas tran vdout0_15ck75 FIND v(dout0_15) AT=1520.1n

* CHECK dout0_0 Vdout0_0ck77 = 1.8 time = 1560
.meas tran vdout0_0ck77 FIND v(dout0_0) AT=1560.1n

* CHECK dout0_1 Vdout0_1ck77 = 1.8 time = 1560
.meas tran vdout0_1ck77 FIND v(dout0_1) AT=1560.1n

* CHECK dout0_2 Vdout0_2ck77 = 0 time = 1560
.meas tran vdout0_2ck77 FIND v(dout0_2) AT=1560.1n

* CHECK dout0_3 Vdout0_3ck77 = 0 time = 1560
.meas tran vdout0_3ck77 FIND v(dout0_3) AT=1560.1n

* CHECK dout0_4 Vdout0_4ck77 = 0 time = 1560
.meas tran vdout0_4ck77 FIND v(dout0_4) AT=1560.1n

* CHECK dout0_5 Vdout0_5ck77 = 1.8 time = 1560
.meas tran vdout0_5ck77 FIND v(dout0_5) AT=1560.1n

* CHECK dout0_6 Vdout0_6ck77 = 1.8 time = 1560
.meas tran vdout0_6ck77 FIND v(dout0_6) AT=1560.1n

* CHECK dout0_7 Vdout0_7ck77 = 1.8 time = 1560
.meas tran vdout0_7ck77 FIND v(dout0_7) AT=1560.1n

* CHECK dout0_8 Vdout0_8ck77 = 1.8 time = 1560
.meas tran vdout0_8ck77 FIND v(dout0_8) AT=1560.1n

* CHECK dout0_9 Vdout0_9ck77 = 1.8 time = 1560
.meas tran vdout0_9ck77 FIND v(dout0_9) AT=1560.1n

* CHECK dout0_10 Vdout0_10ck77 = 0 time = 1560
.meas tran vdout0_10ck77 FIND v(dout0_10) AT=1560.1n

* CHECK dout0_11 Vdout0_11ck77 = 0 time = 1560
.meas tran vdout0_11ck77 FIND v(dout0_11) AT=1560.1n

* CHECK dout0_12 Vdout0_12ck77 = 0 time = 1560
.meas tran vdout0_12ck77 FIND v(dout0_12) AT=1560.1n

* CHECK dout0_13 Vdout0_13ck77 = 1.8 time = 1560
.meas tran vdout0_13ck77 FIND v(dout0_13) AT=1560.1n

* CHECK dout0_14 Vdout0_14ck77 = 0 time = 1560
.meas tran vdout0_14ck77 FIND v(dout0_14) AT=1560.1n

* CHECK dout0_15 Vdout0_15ck77 = 0 time = 1560
.meas tran vdout0_15ck77 FIND v(dout0_15) AT=1560.1n

* CHECK dout0_0 Vdout0_0ck78 = 0 time = 1580
.meas tran vdout0_0ck78 FIND v(dout0_0) AT=1580.1n

* CHECK dout0_1 Vdout0_1ck78 = 0 time = 1580
.meas tran vdout0_1ck78 FIND v(dout0_1) AT=1580.1n

* CHECK dout0_2 Vdout0_2ck78 = 1.8 time = 1580
.meas tran vdout0_2ck78 FIND v(dout0_2) AT=1580.1n

* CHECK dout0_3 Vdout0_3ck78 = 0 time = 1580
.meas tran vdout0_3ck78 FIND v(dout0_3) AT=1580.1n

* CHECK dout0_4 Vdout0_4ck78 = 1.8 time = 1580
.meas tran vdout0_4ck78 FIND v(dout0_4) AT=1580.1n

* CHECK dout0_5 Vdout0_5ck78 = 0 time = 1580
.meas tran vdout0_5ck78 FIND v(dout0_5) AT=1580.1n

* CHECK dout0_6 Vdout0_6ck78 = 1.8 time = 1580
.meas tran vdout0_6ck78 FIND v(dout0_6) AT=1580.1n

* CHECK dout0_7 Vdout0_7ck78 = 1.8 time = 1580
.meas tran vdout0_7ck78 FIND v(dout0_7) AT=1580.1n

* CHECK dout0_8 Vdout0_8ck78 = 1.8 time = 1580
.meas tran vdout0_8ck78 FIND v(dout0_8) AT=1580.1n

* CHECK dout0_9 Vdout0_9ck78 = 1.8 time = 1580
.meas tran vdout0_9ck78 FIND v(dout0_9) AT=1580.1n

* CHECK dout0_10 Vdout0_10ck78 = 0 time = 1580
.meas tran vdout0_10ck78 FIND v(dout0_10) AT=1580.1n

* CHECK dout0_11 Vdout0_11ck78 = 0 time = 1580
.meas tran vdout0_11ck78 FIND v(dout0_11) AT=1580.1n

* CHECK dout0_12 Vdout0_12ck78 = 0 time = 1580
.meas tran vdout0_12ck78 FIND v(dout0_12) AT=1580.1n

* CHECK dout0_13 Vdout0_13ck78 = 0 time = 1580
.meas tran vdout0_13ck78 FIND v(dout0_13) AT=1580.1n

* CHECK dout0_14 Vdout0_14ck78 = 0 time = 1580
.meas tran vdout0_14ck78 FIND v(dout0_14) AT=1580.1n

* CHECK dout0_15 Vdout0_15ck78 = 1.8 time = 1580
.meas tran vdout0_15ck78 FIND v(dout0_15) AT=1580.1n

* CHECK dout0_0 Vdout0_0ck79 = 1.8 time = 1600
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=1600.1n

* CHECK dout0_1 Vdout0_1ck79 = 1.8 time = 1600
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=1600.1n

* CHECK dout0_2 Vdout0_2ck79 = 0 time = 1600
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=1600.1n

* CHECK dout0_3 Vdout0_3ck79 = 1.8 time = 1600
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=1600.1n

* CHECK dout0_4 Vdout0_4ck79 = 1.8 time = 1600
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=1600.1n

* CHECK dout0_5 Vdout0_5ck79 = 0 time = 1600
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=1600.1n

* CHECK dout0_6 Vdout0_6ck79 = 0 time = 1600
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=1600.1n

* CHECK dout0_7 Vdout0_7ck79 = 1.8 time = 1600
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=1600.1n

* CHECK dout0_8 Vdout0_8ck79 = 1.8 time = 1600
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=1600.1n

* CHECK dout0_9 Vdout0_9ck79 = 1.8 time = 1600
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=1600.1n

* CHECK dout0_10 Vdout0_10ck79 = 0 time = 1600
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=1600.1n

* CHECK dout0_11 Vdout0_11ck79 = 0 time = 1600
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=1600.1n

* CHECK dout0_12 Vdout0_12ck79 = 1.8 time = 1600
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=1600.1n

* CHECK dout0_13 Vdout0_13ck79 = 1.8 time = 1600
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=1600.1n

* CHECK dout0_14 Vdout0_14ck79 = 1.8 time = 1600
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=1600.1n

* CHECK dout0_15 Vdout0_15ck79 = 0 time = 1600
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=1600.1n

* CHECK dout0_0 Vdout0_0ck81 = 1.8 time = 1640
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=1640.1n

* CHECK dout0_1 Vdout0_1ck81 = 1.8 time = 1640
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=1640.1n

* CHECK dout0_2 Vdout0_2ck81 = 0 time = 1640
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=1640.1n

* CHECK dout0_3 Vdout0_3ck81 = 0 time = 1640
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=1640.1n

* CHECK dout0_4 Vdout0_4ck81 = 1.8 time = 1640
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=1640.1n

* CHECK dout0_5 Vdout0_5ck81 = 0 time = 1640
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=1640.1n

* CHECK dout0_6 Vdout0_6ck81 = 1.8 time = 1640
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=1640.1n

* CHECK dout0_7 Vdout0_7ck81 = 0 time = 1640
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=1640.1n

* CHECK dout0_8 Vdout0_8ck81 = 1.8 time = 1640
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=1640.1n

* CHECK dout0_9 Vdout0_9ck81 = 1.8 time = 1640
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=1640.1n

* CHECK dout0_10 Vdout0_10ck81 = 0 time = 1640
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=1640.1n

* CHECK dout0_11 Vdout0_11ck81 = 1.8 time = 1640
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=1640.1n

* CHECK dout0_12 Vdout0_12ck81 = 1.8 time = 1640
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=1640.1n

* CHECK dout0_13 Vdout0_13ck81 = 0 time = 1640
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=1640.1n

* CHECK dout0_14 Vdout0_14ck81 = 1.8 time = 1640
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=1640.1n

* CHECK dout0_15 Vdout0_15ck81 = 1.8 time = 1640
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=1640.1n

* CHECK dout0_0 Vdout0_0ck84 = 0 time = 1700
.meas tran vdout0_0ck84 FIND v(dout0_0) AT=1700.1n

* CHECK dout0_1 Vdout0_1ck84 = 0 time = 1700
.meas tran vdout0_1ck84 FIND v(dout0_1) AT=1700.1n

* CHECK dout0_2 Vdout0_2ck84 = 1.8 time = 1700
.meas tran vdout0_2ck84 FIND v(dout0_2) AT=1700.1n

* CHECK dout0_3 Vdout0_3ck84 = 0 time = 1700
.meas tran vdout0_3ck84 FIND v(dout0_3) AT=1700.1n

* CHECK dout0_4 Vdout0_4ck84 = 1.8 time = 1700
.meas tran vdout0_4ck84 FIND v(dout0_4) AT=1700.1n

* CHECK dout0_5 Vdout0_5ck84 = 0 time = 1700
.meas tran vdout0_5ck84 FIND v(dout0_5) AT=1700.1n

* CHECK dout0_6 Vdout0_6ck84 = 1.8 time = 1700
.meas tran vdout0_6ck84 FIND v(dout0_6) AT=1700.1n

* CHECK dout0_7 Vdout0_7ck84 = 1.8 time = 1700
.meas tran vdout0_7ck84 FIND v(dout0_7) AT=1700.1n

* CHECK dout0_8 Vdout0_8ck84 = 1.8 time = 1700
.meas tran vdout0_8ck84 FIND v(dout0_8) AT=1700.1n

* CHECK dout0_9 Vdout0_9ck84 = 1.8 time = 1700
.meas tran vdout0_9ck84 FIND v(dout0_9) AT=1700.1n

* CHECK dout0_10 Vdout0_10ck84 = 0 time = 1700
.meas tran vdout0_10ck84 FIND v(dout0_10) AT=1700.1n

* CHECK dout0_11 Vdout0_11ck84 = 0 time = 1700
.meas tran vdout0_11ck84 FIND v(dout0_11) AT=1700.1n

* CHECK dout0_12 Vdout0_12ck84 = 0 time = 1700
.meas tran vdout0_12ck84 FIND v(dout0_12) AT=1700.1n

* CHECK dout0_13 Vdout0_13ck84 = 0 time = 1700
.meas tran vdout0_13ck84 FIND v(dout0_13) AT=1700.1n

* CHECK dout0_14 Vdout0_14ck84 = 0 time = 1700
.meas tran vdout0_14ck84 FIND v(dout0_14) AT=1700.1n

* CHECK dout0_15 Vdout0_15ck84 = 1.8 time = 1700
.meas tran vdout0_15ck84 FIND v(dout0_15) AT=1700.1n

* CHECK dout0_0 Vdout0_0ck85 = 0 time = 1720
.meas tran vdout0_0ck85 FIND v(dout0_0) AT=1720.1n

* CHECK dout0_1 Vdout0_1ck85 = 0 time = 1720
.meas tran vdout0_1ck85 FIND v(dout0_1) AT=1720.1n

* CHECK dout0_2 Vdout0_2ck85 = 0 time = 1720
.meas tran vdout0_2ck85 FIND v(dout0_2) AT=1720.1n

* CHECK dout0_3 Vdout0_3ck85 = 1.8 time = 1720
.meas tran vdout0_3ck85 FIND v(dout0_3) AT=1720.1n

* CHECK dout0_4 Vdout0_4ck85 = 1.8 time = 1720
.meas tran vdout0_4ck85 FIND v(dout0_4) AT=1720.1n

* CHECK dout0_5 Vdout0_5ck85 = 0 time = 1720
.meas tran vdout0_5ck85 FIND v(dout0_5) AT=1720.1n

* CHECK dout0_6 Vdout0_6ck85 = 1.8 time = 1720
.meas tran vdout0_6ck85 FIND v(dout0_6) AT=1720.1n

* CHECK dout0_7 Vdout0_7ck85 = 1.8 time = 1720
.meas tran vdout0_7ck85 FIND v(dout0_7) AT=1720.1n

* CHECK dout0_8 Vdout0_8ck85 = 0 time = 1720
.meas tran vdout0_8ck85 FIND v(dout0_8) AT=1720.1n

* CHECK dout0_9 Vdout0_9ck85 = 1.8 time = 1720
.meas tran vdout0_9ck85 FIND v(dout0_9) AT=1720.1n

* CHECK dout0_10 Vdout0_10ck85 = 1.8 time = 1720
.meas tran vdout0_10ck85 FIND v(dout0_10) AT=1720.1n

* CHECK dout0_11 Vdout0_11ck85 = 0 time = 1720
.meas tran vdout0_11ck85 FIND v(dout0_11) AT=1720.1n

* CHECK dout0_12 Vdout0_12ck85 = 0 time = 1720
.meas tran vdout0_12ck85 FIND v(dout0_12) AT=1720.1n

* CHECK dout0_13 Vdout0_13ck85 = 0 time = 1720
.meas tran vdout0_13ck85 FIND v(dout0_13) AT=1720.1n

* CHECK dout0_14 Vdout0_14ck85 = 1.8 time = 1720
.meas tran vdout0_14ck85 FIND v(dout0_14) AT=1720.1n

* CHECK dout0_15 Vdout0_15ck85 = 0 time = 1720
.meas tran vdout0_15ck85 FIND v(dout0_15) AT=1720.1n

* CHECK dout0_0 Vdout0_0ck86 = 0 time = 1740
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=1740.1n

* CHECK dout0_1 Vdout0_1ck86 = 1.8 time = 1740
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=1740.1n

* CHECK dout0_2 Vdout0_2ck86 = 0 time = 1740
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=1740.1n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 1740
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=1740.1n

* CHECK dout0_4 Vdout0_4ck86 = 0 time = 1740
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=1740.1n

* CHECK dout0_5 Vdout0_5ck86 = 0 time = 1740
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=1740.1n

* CHECK dout0_6 Vdout0_6ck86 = 1.8 time = 1740
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=1740.1n

* CHECK dout0_7 Vdout0_7ck86 = 1.8 time = 1740
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=1740.1n

* CHECK dout0_8 Vdout0_8ck86 = 1.8 time = 1740
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=1740.1n

* CHECK dout0_9 Vdout0_9ck86 = 1.8 time = 1740
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=1740.1n

* CHECK dout0_10 Vdout0_10ck86 = 1.8 time = 1740
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=1740.1n

* CHECK dout0_11 Vdout0_11ck86 = 0 time = 1740
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=1740.1n

* CHECK dout0_12 Vdout0_12ck86 = 1.8 time = 1740
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=1740.1n

* CHECK dout0_13 Vdout0_13ck86 = 1.8 time = 1740
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=1740.1n

* CHECK dout0_14 Vdout0_14ck86 = 1.8 time = 1740
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=1740.1n

* CHECK dout0_15 Vdout0_15ck86 = 0 time = 1740
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=1740.1n

* CHECK dout0_0 Vdout0_0ck87 = 0 time = 1760
.meas tran vdout0_0ck87 FIND v(dout0_0) AT=1760.1n

* CHECK dout0_1 Vdout0_1ck87 = 0 time = 1760
.meas tran vdout0_1ck87 FIND v(dout0_1) AT=1760.1n

* CHECK dout0_2 Vdout0_2ck87 = 0 time = 1760
.meas tran vdout0_2ck87 FIND v(dout0_2) AT=1760.1n

* CHECK dout0_3 Vdout0_3ck87 = 1.8 time = 1760
.meas tran vdout0_3ck87 FIND v(dout0_3) AT=1760.1n

* CHECK dout0_4 Vdout0_4ck87 = 1.8 time = 1760
.meas tran vdout0_4ck87 FIND v(dout0_4) AT=1760.1n

* CHECK dout0_5 Vdout0_5ck87 = 0 time = 1760
.meas tran vdout0_5ck87 FIND v(dout0_5) AT=1760.1n

* CHECK dout0_6 Vdout0_6ck87 = 1.8 time = 1760
.meas tran vdout0_6ck87 FIND v(dout0_6) AT=1760.1n

* CHECK dout0_7 Vdout0_7ck87 = 1.8 time = 1760
.meas tran vdout0_7ck87 FIND v(dout0_7) AT=1760.1n

* CHECK dout0_8 Vdout0_8ck87 = 0 time = 1760
.meas tran vdout0_8ck87 FIND v(dout0_8) AT=1760.1n

* CHECK dout0_9 Vdout0_9ck87 = 1.8 time = 1760
.meas tran vdout0_9ck87 FIND v(dout0_9) AT=1760.1n

* CHECK dout0_10 Vdout0_10ck87 = 1.8 time = 1760
.meas tran vdout0_10ck87 FIND v(dout0_10) AT=1760.1n

* CHECK dout0_11 Vdout0_11ck87 = 0 time = 1760
.meas tran vdout0_11ck87 FIND v(dout0_11) AT=1760.1n

* CHECK dout0_12 Vdout0_12ck87 = 0 time = 1760
.meas tran vdout0_12ck87 FIND v(dout0_12) AT=1760.1n

* CHECK dout0_13 Vdout0_13ck87 = 0 time = 1760
.meas tran vdout0_13ck87 FIND v(dout0_13) AT=1760.1n

* CHECK dout0_14 Vdout0_14ck87 = 1.8 time = 1760
.meas tran vdout0_14ck87 FIND v(dout0_14) AT=1760.1n

* CHECK dout0_15 Vdout0_15ck87 = 0 time = 1760
.meas tran vdout0_15ck87 FIND v(dout0_15) AT=1760.1n

* CHECK dout0_0 Vdout0_0ck89 = 0 time = 1800
.meas tran vdout0_0ck89 FIND v(dout0_0) AT=1800.1n

* CHECK dout0_1 Vdout0_1ck89 = 0 time = 1800
.meas tran vdout0_1ck89 FIND v(dout0_1) AT=1800.1n

* CHECK dout0_2 Vdout0_2ck89 = 0 time = 1800
.meas tran vdout0_2ck89 FIND v(dout0_2) AT=1800.1n

* CHECK dout0_3 Vdout0_3ck89 = 1.8 time = 1800
.meas tran vdout0_3ck89 FIND v(dout0_3) AT=1800.1n

* CHECK dout0_4 Vdout0_4ck89 = 1.8 time = 1800
.meas tran vdout0_4ck89 FIND v(dout0_4) AT=1800.1n

* CHECK dout0_5 Vdout0_5ck89 = 0 time = 1800
.meas tran vdout0_5ck89 FIND v(dout0_5) AT=1800.1n

* CHECK dout0_6 Vdout0_6ck89 = 1.8 time = 1800
.meas tran vdout0_6ck89 FIND v(dout0_6) AT=1800.1n

* CHECK dout0_7 Vdout0_7ck89 = 1.8 time = 1800
.meas tran vdout0_7ck89 FIND v(dout0_7) AT=1800.1n

* CHECK dout0_8 Vdout0_8ck89 = 0 time = 1800
.meas tran vdout0_8ck89 FIND v(dout0_8) AT=1800.1n

* CHECK dout0_9 Vdout0_9ck89 = 1.8 time = 1800
.meas tran vdout0_9ck89 FIND v(dout0_9) AT=1800.1n

* CHECK dout0_10 Vdout0_10ck89 = 1.8 time = 1800
.meas tran vdout0_10ck89 FIND v(dout0_10) AT=1800.1n

* CHECK dout0_11 Vdout0_11ck89 = 0 time = 1800
.meas tran vdout0_11ck89 FIND v(dout0_11) AT=1800.1n

* CHECK dout0_12 Vdout0_12ck89 = 0 time = 1800
.meas tran vdout0_12ck89 FIND v(dout0_12) AT=1800.1n

* CHECK dout0_13 Vdout0_13ck89 = 0 time = 1800
.meas tran vdout0_13ck89 FIND v(dout0_13) AT=1800.1n

* CHECK dout0_14 Vdout0_14ck89 = 1.8 time = 1800
.meas tran vdout0_14ck89 FIND v(dout0_14) AT=1800.1n

* CHECK dout0_15 Vdout0_15ck89 = 0 time = 1800
.meas tran vdout0_15ck89 FIND v(dout0_15) AT=1800.1n

* CHECK dout0_0 Vdout0_0ck90 = 1.8 time = 1820
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=1820.1n

* CHECK dout0_1 Vdout0_1ck90 = 0 time = 1820
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=1820.1n

* CHECK dout0_2 Vdout0_2ck90 = 0 time = 1820
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=1820.1n

* CHECK dout0_3 Vdout0_3ck90 = 0 time = 1820
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=1820.1n

* CHECK dout0_4 Vdout0_4ck90 = 1.8 time = 1820
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=1820.1n

* CHECK dout0_5 Vdout0_5ck90 = 1.8 time = 1820
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=1820.1n

* CHECK dout0_6 Vdout0_6ck90 = 1.8 time = 1820
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=1820.1n

* CHECK dout0_7 Vdout0_7ck90 = 1.8 time = 1820
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=1820.1n

* CHECK dout0_8 Vdout0_8ck90 = 1.8 time = 1820
.meas tran vdout0_8ck90 FIND v(dout0_8) AT=1820.1n

* CHECK dout0_9 Vdout0_9ck90 = 0 time = 1820
.meas tran vdout0_9ck90 FIND v(dout0_9) AT=1820.1n

* CHECK dout0_10 Vdout0_10ck90 = 1.8 time = 1820
.meas tran vdout0_10ck90 FIND v(dout0_10) AT=1820.1n

* CHECK dout0_11 Vdout0_11ck90 = 1.8 time = 1820
.meas tran vdout0_11ck90 FIND v(dout0_11) AT=1820.1n

* CHECK dout0_12 Vdout0_12ck90 = 1.8 time = 1820
.meas tran vdout0_12ck90 FIND v(dout0_12) AT=1820.1n

* CHECK dout0_13 Vdout0_13ck90 = 1.8 time = 1820
.meas tran vdout0_13ck90 FIND v(dout0_13) AT=1820.1n

* CHECK dout0_14 Vdout0_14ck90 = 0 time = 1820
.meas tran vdout0_14ck90 FIND v(dout0_14) AT=1820.1n

* CHECK dout0_15 Vdout0_15ck90 = 1.8 time = 1820
.meas tran vdout0_15ck90 FIND v(dout0_15) AT=1820.1n

* CHECK dout0_0 Vdout0_0ck91 = 0 time = 1840
.meas tran vdout0_0ck91 FIND v(dout0_0) AT=1840.1n

* CHECK dout0_1 Vdout0_1ck91 = 1.8 time = 1840
.meas tran vdout0_1ck91 FIND v(dout0_1) AT=1840.1n

* CHECK dout0_2 Vdout0_2ck91 = 0 time = 1840
.meas tran vdout0_2ck91 FIND v(dout0_2) AT=1840.1n

* CHECK dout0_3 Vdout0_3ck91 = 0 time = 1840
.meas tran vdout0_3ck91 FIND v(dout0_3) AT=1840.1n

* CHECK dout0_4 Vdout0_4ck91 = 0 time = 1840
.meas tran vdout0_4ck91 FIND v(dout0_4) AT=1840.1n

* CHECK dout0_5 Vdout0_5ck91 = 0 time = 1840
.meas tran vdout0_5ck91 FIND v(dout0_5) AT=1840.1n

* CHECK dout0_6 Vdout0_6ck91 = 1.8 time = 1840
.meas tran vdout0_6ck91 FIND v(dout0_6) AT=1840.1n

* CHECK dout0_7 Vdout0_7ck91 = 1.8 time = 1840
.meas tran vdout0_7ck91 FIND v(dout0_7) AT=1840.1n

* CHECK dout0_8 Vdout0_8ck91 = 1.8 time = 1840
.meas tran vdout0_8ck91 FIND v(dout0_8) AT=1840.1n

* CHECK dout0_9 Vdout0_9ck91 = 1.8 time = 1840
.meas tran vdout0_9ck91 FIND v(dout0_9) AT=1840.1n

* CHECK dout0_10 Vdout0_10ck91 = 1.8 time = 1840
.meas tran vdout0_10ck91 FIND v(dout0_10) AT=1840.1n

* CHECK dout0_11 Vdout0_11ck91 = 0 time = 1840
.meas tran vdout0_11ck91 FIND v(dout0_11) AT=1840.1n

* CHECK dout0_12 Vdout0_12ck91 = 1.8 time = 1840
.meas tran vdout0_12ck91 FIND v(dout0_12) AT=1840.1n

* CHECK dout0_13 Vdout0_13ck91 = 1.8 time = 1840
.meas tran vdout0_13ck91 FIND v(dout0_13) AT=1840.1n

* CHECK dout0_14 Vdout0_14ck91 = 1.8 time = 1840
.meas tran vdout0_14ck91 FIND v(dout0_14) AT=1840.1n

* CHECK dout0_15 Vdout0_15ck91 = 0 time = 1840
.meas tran vdout0_15ck91 FIND v(dout0_15) AT=1840.1n

* CHECK dout0_0 Vdout0_0ck92 = 0 time = 1860
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=1860.1n

* CHECK dout0_1 Vdout0_1ck92 = 0 time = 1860
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=1860.1n

* CHECK dout0_2 Vdout0_2ck92 = 0 time = 1860
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=1860.1n

* CHECK dout0_3 Vdout0_3ck92 = 1.8 time = 1860
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=1860.1n

* CHECK dout0_4 Vdout0_4ck92 = 1.8 time = 1860
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=1860.1n

* CHECK dout0_5 Vdout0_5ck92 = 0 time = 1860
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=1860.1n

* CHECK dout0_6 Vdout0_6ck92 = 1.8 time = 1860
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=1860.1n

* CHECK dout0_7 Vdout0_7ck92 = 1.8 time = 1860
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=1860.1n

* CHECK dout0_8 Vdout0_8ck92 = 0 time = 1860
.meas tran vdout0_8ck92 FIND v(dout0_8) AT=1860.1n

* CHECK dout0_9 Vdout0_9ck92 = 1.8 time = 1860
.meas tran vdout0_9ck92 FIND v(dout0_9) AT=1860.1n

* CHECK dout0_10 Vdout0_10ck92 = 1.8 time = 1860
.meas tran vdout0_10ck92 FIND v(dout0_10) AT=1860.1n

* CHECK dout0_11 Vdout0_11ck92 = 0 time = 1860
.meas tran vdout0_11ck92 FIND v(dout0_11) AT=1860.1n

* CHECK dout0_12 Vdout0_12ck92 = 0 time = 1860
.meas tran vdout0_12ck92 FIND v(dout0_12) AT=1860.1n

* CHECK dout0_13 Vdout0_13ck92 = 0 time = 1860
.meas tran vdout0_13ck92 FIND v(dout0_13) AT=1860.1n

* CHECK dout0_14 Vdout0_14ck92 = 1.8 time = 1860
.meas tran vdout0_14ck92 FIND v(dout0_14) AT=1860.1n

* CHECK dout0_15 Vdout0_15ck92 = 0 time = 1860
.meas tran vdout0_15ck92 FIND v(dout0_15) AT=1860.1n

* CHECK dout0_0 Vdout0_0ck95 = 1.8 time = 1920
.meas tran vdout0_0ck95 FIND v(dout0_0) AT=1920.1n

* CHECK dout0_1 Vdout0_1ck95 = 1.8 time = 1920
.meas tran vdout0_1ck95 FIND v(dout0_1) AT=1920.1n

* CHECK dout0_2 Vdout0_2ck95 = 0 time = 1920
.meas tran vdout0_2ck95 FIND v(dout0_2) AT=1920.1n

* CHECK dout0_3 Vdout0_3ck95 = 0 time = 1920
.meas tran vdout0_3ck95 FIND v(dout0_3) AT=1920.1n

* CHECK dout0_4 Vdout0_4ck95 = 1.8 time = 1920
.meas tran vdout0_4ck95 FIND v(dout0_4) AT=1920.1n

* CHECK dout0_5 Vdout0_5ck95 = 0 time = 1920
.meas tran vdout0_5ck95 FIND v(dout0_5) AT=1920.1n

* CHECK dout0_6 Vdout0_6ck95 = 1.8 time = 1920
.meas tran vdout0_6ck95 FIND v(dout0_6) AT=1920.1n

* CHECK dout0_7 Vdout0_7ck95 = 0 time = 1920
.meas tran vdout0_7ck95 FIND v(dout0_7) AT=1920.1n

* CHECK dout0_8 Vdout0_8ck95 = 1.8 time = 1920
.meas tran vdout0_8ck95 FIND v(dout0_8) AT=1920.1n

* CHECK dout0_9 Vdout0_9ck95 = 1.8 time = 1920
.meas tran vdout0_9ck95 FIND v(dout0_9) AT=1920.1n

* CHECK dout0_10 Vdout0_10ck95 = 0 time = 1920
.meas tran vdout0_10ck95 FIND v(dout0_10) AT=1920.1n

* CHECK dout0_11 Vdout0_11ck95 = 1.8 time = 1920
.meas tran vdout0_11ck95 FIND v(dout0_11) AT=1920.1n

* CHECK dout0_12 Vdout0_12ck95 = 1.8 time = 1920
.meas tran vdout0_12ck95 FIND v(dout0_12) AT=1920.1n

* CHECK dout0_13 Vdout0_13ck95 = 0 time = 1920
.meas tran vdout0_13ck95 FIND v(dout0_13) AT=1920.1n

* CHECK dout0_14 Vdout0_14ck95 = 1.8 time = 1920
.meas tran vdout0_14ck95 FIND v(dout0_14) AT=1920.1n

* CHECK dout0_15 Vdout0_15ck95 = 1.8 time = 1920
.meas tran vdout0_15ck95 FIND v(dout0_15) AT=1920.1n

* CHECK dout0_0 Vdout0_0ck97 = 1.8 time = 1960
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=1960.1n

* CHECK dout0_1 Vdout0_1ck97 = 1.8 time = 1960
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=1960.1n

* CHECK dout0_2 Vdout0_2ck97 = 0 time = 1960
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=1960.1n

* CHECK dout0_3 Vdout0_3ck97 = 0 time = 1960
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=1960.1n

* CHECK dout0_4 Vdout0_4ck97 = 1.8 time = 1960
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=1960.1n

* CHECK dout0_5 Vdout0_5ck97 = 0 time = 1960
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=1960.1n

* CHECK dout0_6 Vdout0_6ck97 = 1.8 time = 1960
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=1960.1n

* CHECK dout0_7 Vdout0_7ck97 = 0 time = 1960
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=1960.1n

* CHECK dout0_8 Vdout0_8ck97 = 1.8 time = 1960
.meas tran vdout0_8ck97 FIND v(dout0_8) AT=1960.1n

* CHECK dout0_9 Vdout0_9ck97 = 1.8 time = 1960
.meas tran vdout0_9ck97 FIND v(dout0_9) AT=1960.1n

* CHECK dout0_10 Vdout0_10ck97 = 0 time = 1960
.meas tran vdout0_10ck97 FIND v(dout0_10) AT=1960.1n

* CHECK dout0_11 Vdout0_11ck97 = 1.8 time = 1960
.meas tran vdout0_11ck97 FIND v(dout0_11) AT=1960.1n

* CHECK dout0_12 Vdout0_12ck97 = 1.8 time = 1960
.meas tran vdout0_12ck97 FIND v(dout0_12) AT=1960.1n

* CHECK dout0_13 Vdout0_13ck97 = 0 time = 1960
.meas tran vdout0_13ck97 FIND v(dout0_13) AT=1960.1n

* CHECK dout0_14 Vdout0_14ck97 = 1.8 time = 1960
.meas tran vdout0_14ck97 FIND v(dout0_14) AT=1960.1n

* CHECK dout0_15 Vdout0_15ck97 = 1.8 time = 1960
.meas tran vdout0_15ck97 FIND v(dout0_15) AT=1960.1n

* CHECK dout0_0 Vdout0_0ck98 = 0 time = 1980
.meas tran vdout0_0ck98 FIND v(dout0_0) AT=1980.1n

* CHECK dout0_1 Vdout0_1ck98 = 1.8 time = 1980
.meas tran vdout0_1ck98 FIND v(dout0_1) AT=1980.1n

* CHECK dout0_2 Vdout0_2ck98 = 0 time = 1980
.meas tran vdout0_2ck98 FIND v(dout0_2) AT=1980.1n

* CHECK dout0_3 Vdout0_3ck98 = 0 time = 1980
.meas tran vdout0_3ck98 FIND v(dout0_3) AT=1980.1n

* CHECK dout0_4 Vdout0_4ck98 = 0 time = 1980
.meas tran vdout0_4ck98 FIND v(dout0_4) AT=1980.1n

* CHECK dout0_5 Vdout0_5ck98 = 0 time = 1980
.meas tran vdout0_5ck98 FIND v(dout0_5) AT=1980.1n

* CHECK dout0_6 Vdout0_6ck98 = 1.8 time = 1980
.meas tran vdout0_6ck98 FIND v(dout0_6) AT=1980.1n

* CHECK dout0_7 Vdout0_7ck98 = 1.8 time = 1980
.meas tran vdout0_7ck98 FIND v(dout0_7) AT=1980.1n

* CHECK dout0_8 Vdout0_8ck98 = 1.8 time = 1980
.meas tran vdout0_8ck98 FIND v(dout0_8) AT=1980.1n

* CHECK dout0_9 Vdout0_9ck98 = 1.8 time = 1980
.meas tran vdout0_9ck98 FIND v(dout0_9) AT=1980.1n

* CHECK dout0_10 Vdout0_10ck98 = 1.8 time = 1980
.meas tran vdout0_10ck98 FIND v(dout0_10) AT=1980.1n

* CHECK dout0_11 Vdout0_11ck98 = 0 time = 1980
.meas tran vdout0_11ck98 FIND v(dout0_11) AT=1980.1n

* CHECK dout0_12 Vdout0_12ck98 = 1.8 time = 1980
.meas tran vdout0_12ck98 FIND v(dout0_12) AT=1980.1n

* CHECK dout0_13 Vdout0_13ck98 = 1.8 time = 1980
.meas tran vdout0_13ck98 FIND v(dout0_13) AT=1980.1n

* CHECK dout0_14 Vdout0_14ck98 = 1.8 time = 1980
.meas tran vdout0_14ck98 FIND v(dout0_14) AT=1980.1n

* CHECK dout0_15 Vdout0_15ck98 = 0 time = 1980
.meas tran vdout0_15ck98 FIND v(dout0_15) AT=1980.1n

* CHECK dout0_0 Vdout0_0ck99 = 1.8 time = 2000
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=2000.1n

* CHECK dout0_1 Vdout0_1ck99 = 1.8 time = 2000
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=2000.1n

* CHECK dout0_2 Vdout0_2ck99 = 0 time = 2000
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=2000.1n

* CHECK dout0_3 Vdout0_3ck99 = 0 time = 2000
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=2000.1n

* CHECK dout0_4 Vdout0_4ck99 = 1.8 time = 2000
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=2000.1n

* CHECK dout0_5 Vdout0_5ck99 = 0 time = 2000
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=2000.1n

* CHECK dout0_6 Vdout0_6ck99 = 1.8 time = 2000
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=2000.1n

* CHECK dout0_7 Vdout0_7ck99 = 0 time = 2000
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=2000.1n

* CHECK dout0_8 Vdout0_8ck99 = 1.8 time = 2000
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=2000.1n

* CHECK dout0_9 Vdout0_9ck99 = 1.8 time = 2000
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=2000.1n

* CHECK dout0_10 Vdout0_10ck99 = 0 time = 2000
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=2000.1n

* CHECK dout0_11 Vdout0_11ck99 = 1.8 time = 2000
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=2000.1n

* CHECK dout0_12 Vdout0_12ck99 = 1.8 time = 2000
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=2000.1n

* CHECK dout0_13 Vdout0_13ck99 = 0 time = 2000
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=2000.1n

* CHECK dout0_14 Vdout0_14ck99 = 1.8 time = 2000
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=2000.1n

* CHECK dout0_15 Vdout0_15ck99 = 1.8 time = 2000
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=2000.1n

* CHECK dout0_0 Vdout0_0ck101 = 1.8 time = 2040
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=2040.1n

* CHECK dout0_1 Vdout0_1ck101 = 1.8 time = 2040
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=2040.1n

* CHECK dout0_2 Vdout0_2ck101 = 0 time = 2040
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=2040.1n

* CHECK dout0_3 Vdout0_3ck101 = 0 time = 2040
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=2040.1n

* CHECK dout0_4 Vdout0_4ck101 = 0 time = 2040
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=2040.1n

* CHECK dout0_5 Vdout0_5ck101 = 1.8 time = 2040
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=2040.1n

* CHECK dout0_6 Vdout0_6ck101 = 1.8 time = 2040
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=2040.1n

* CHECK dout0_7 Vdout0_7ck101 = 1.8 time = 2040
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=2040.1n

* CHECK dout0_8 Vdout0_8ck101 = 1.8 time = 2040
.meas tran vdout0_8ck101 FIND v(dout0_8) AT=2040.1n

* CHECK dout0_9 Vdout0_9ck101 = 1.8 time = 2040
.meas tran vdout0_9ck101 FIND v(dout0_9) AT=2040.1n

* CHECK dout0_10 Vdout0_10ck101 = 0 time = 2040
.meas tran vdout0_10ck101 FIND v(dout0_10) AT=2040.1n

* CHECK dout0_11 Vdout0_11ck101 = 0 time = 2040
.meas tran vdout0_11ck101 FIND v(dout0_11) AT=2040.1n

* CHECK dout0_12 Vdout0_12ck101 = 0 time = 2040
.meas tran vdout0_12ck101 FIND v(dout0_12) AT=2040.1n

* CHECK dout0_13 Vdout0_13ck101 = 1.8 time = 2040
.meas tran vdout0_13ck101 FIND v(dout0_13) AT=2040.1n

* CHECK dout0_14 Vdout0_14ck101 = 0 time = 2040
.meas tran vdout0_14ck101 FIND v(dout0_14) AT=2040.1n

* CHECK dout0_15 Vdout0_15ck101 = 0 time = 2040
.meas tran vdout0_15ck101 FIND v(dout0_15) AT=2040.1n

* CHECK dout0_0 Vdout0_0ck104 = 1.8 time = 2100
.meas tran vdout0_0ck104 FIND v(dout0_0) AT=2100.1n

* CHECK dout0_1 Vdout0_1ck104 = 0 time = 2100
.meas tran vdout0_1ck104 FIND v(dout0_1) AT=2100.1n

* CHECK dout0_2 Vdout0_2ck104 = 0 time = 2100
.meas tran vdout0_2ck104 FIND v(dout0_2) AT=2100.1n

* CHECK dout0_3 Vdout0_3ck104 = 0 time = 2100
.meas tran vdout0_3ck104 FIND v(dout0_3) AT=2100.1n

* CHECK dout0_4 Vdout0_4ck104 = 1.8 time = 2100
.meas tran vdout0_4ck104 FIND v(dout0_4) AT=2100.1n

* CHECK dout0_5 Vdout0_5ck104 = 1.8 time = 2100
.meas tran vdout0_5ck104 FIND v(dout0_5) AT=2100.1n

* CHECK dout0_6 Vdout0_6ck104 = 0 time = 2100
.meas tran vdout0_6ck104 FIND v(dout0_6) AT=2100.1n

* CHECK dout0_7 Vdout0_7ck104 = 1.8 time = 2100
.meas tran vdout0_7ck104 FIND v(dout0_7) AT=2100.1n

* CHECK dout0_8 Vdout0_8ck104 = 0 time = 2100
.meas tran vdout0_8ck104 FIND v(dout0_8) AT=2100.1n

* CHECK dout0_9 Vdout0_9ck104 = 1.8 time = 2100
.meas tran vdout0_9ck104 FIND v(dout0_9) AT=2100.1n

* CHECK dout0_10 Vdout0_10ck104 = 1.8 time = 2100
.meas tran vdout0_10ck104 FIND v(dout0_10) AT=2100.1n

* CHECK dout0_11 Vdout0_11ck104 = 1.8 time = 2100
.meas tran vdout0_11ck104 FIND v(dout0_11) AT=2100.1n

* CHECK dout0_12 Vdout0_12ck104 = 1.8 time = 2100
.meas tran vdout0_12ck104 FIND v(dout0_12) AT=2100.1n

* CHECK dout0_13 Vdout0_13ck104 = 0 time = 2100
.meas tran vdout0_13ck104 FIND v(dout0_13) AT=2100.1n

* CHECK dout0_14 Vdout0_14ck104 = 1.8 time = 2100
.meas tran vdout0_14ck104 FIND v(dout0_14) AT=2100.1n

* CHECK dout0_15 Vdout0_15ck104 = 0 time = 2100
.meas tran vdout0_15ck104 FIND v(dout0_15) AT=2100.1n

* CHECK dout0_0 Vdout0_0ck107 = 1.8 time = 2160
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=2160.1n

* CHECK dout0_1 Vdout0_1ck107 = 0 time = 2160
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=2160.1n

* CHECK dout0_2 Vdout0_2ck107 = 0 time = 2160
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=2160.1n

* CHECK dout0_3 Vdout0_3ck107 = 1.8 time = 2160
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=2160.1n

* CHECK dout0_4 Vdout0_4ck107 = 1.8 time = 2160
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=2160.1n

* CHECK dout0_5 Vdout0_5ck107 = 1.8 time = 2160
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=2160.1n

* CHECK dout0_6 Vdout0_6ck107 = 1.8 time = 2160
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=2160.1n

* CHECK dout0_7 Vdout0_7ck107 = 0 time = 2160
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=2160.1n

* CHECK dout0_8 Vdout0_8ck107 = 1.8 time = 2160
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=2160.1n

* CHECK dout0_9 Vdout0_9ck107 = 1.8 time = 2160
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=2160.1n

* CHECK dout0_10 Vdout0_10ck107 = 1.8 time = 2160
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=2160.1n

* CHECK dout0_11 Vdout0_11ck107 = 1.8 time = 2160
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=2160.1n

* CHECK dout0_12 Vdout0_12ck107 = 0 time = 2160
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=2160.1n

* CHECK dout0_13 Vdout0_13ck107 = 1.8 time = 2160
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=2160.1n

* CHECK dout0_14 Vdout0_14ck107 = 1.8 time = 2160
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=2160.1n

* CHECK dout0_15 Vdout0_15ck107 = 0 time = 2160
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=2160.1n

* CHECK dout0_0 Vdout0_0ck108 = 0 time = 2180
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=2180.1n

* CHECK dout0_1 Vdout0_1ck108 = 0 time = 2180
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=2180.1n

* CHECK dout0_2 Vdout0_2ck108 = 1.8 time = 2180
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=2180.1n

* CHECK dout0_3 Vdout0_3ck108 = 1.8 time = 2180
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=2180.1n

* CHECK dout0_4 Vdout0_4ck108 = 0 time = 2180
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=2180.1n

* CHECK dout0_5 Vdout0_5ck108 = 1.8 time = 2180
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=2180.1n

* CHECK dout0_6 Vdout0_6ck108 = 0 time = 2180
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=2180.1n

* CHECK dout0_7 Vdout0_7ck108 = 1.8 time = 2180
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=2180.1n

* CHECK dout0_8 Vdout0_8ck108 = 1.8 time = 2180
.meas tran vdout0_8ck108 FIND v(dout0_8) AT=2180.1n

* CHECK dout0_9 Vdout0_9ck108 = 1.8 time = 2180
.meas tran vdout0_9ck108 FIND v(dout0_9) AT=2180.1n

* CHECK dout0_10 Vdout0_10ck108 = 1.8 time = 2180
.meas tran vdout0_10ck108 FIND v(dout0_10) AT=2180.1n

* CHECK dout0_11 Vdout0_11ck108 = 0 time = 2180
.meas tran vdout0_11ck108 FIND v(dout0_11) AT=2180.1n

* CHECK dout0_12 Vdout0_12ck108 = 0 time = 2180
.meas tran vdout0_12ck108 FIND v(dout0_12) AT=2180.1n

* CHECK dout0_13 Vdout0_13ck108 = 0 time = 2180
.meas tran vdout0_13ck108 FIND v(dout0_13) AT=2180.1n

* CHECK dout0_14 Vdout0_14ck108 = 0 time = 2180
.meas tran vdout0_14ck108 FIND v(dout0_14) AT=2180.1n

* CHECK dout0_15 Vdout0_15ck108 = 1.8 time = 2180
.meas tran vdout0_15ck108 FIND v(dout0_15) AT=2180.1n

* CHECK dout0_0 Vdout0_0ck110 = 0 time = 2220
.meas tran vdout0_0ck110 FIND v(dout0_0) AT=2220.1n

* CHECK dout0_1 Vdout0_1ck110 = 0 time = 2220
.meas tran vdout0_1ck110 FIND v(dout0_1) AT=2220.1n

* CHECK dout0_2 Vdout0_2ck110 = 1.8 time = 2220
.meas tran vdout0_2ck110 FIND v(dout0_2) AT=2220.1n

* CHECK dout0_3 Vdout0_3ck110 = 1.8 time = 2220
.meas tran vdout0_3ck110 FIND v(dout0_3) AT=2220.1n

* CHECK dout0_4 Vdout0_4ck110 = 0 time = 2220
.meas tran vdout0_4ck110 FIND v(dout0_4) AT=2220.1n

* CHECK dout0_5 Vdout0_5ck110 = 1.8 time = 2220
.meas tran vdout0_5ck110 FIND v(dout0_5) AT=2220.1n

* CHECK dout0_6 Vdout0_6ck110 = 0 time = 2220
.meas tran vdout0_6ck110 FIND v(dout0_6) AT=2220.1n

* CHECK dout0_7 Vdout0_7ck110 = 1.8 time = 2220
.meas tran vdout0_7ck110 FIND v(dout0_7) AT=2220.1n

* CHECK dout0_8 Vdout0_8ck110 = 1.8 time = 2220
.meas tran vdout0_8ck110 FIND v(dout0_8) AT=2220.1n

* CHECK dout0_9 Vdout0_9ck110 = 1.8 time = 2220
.meas tran vdout0_9ck110 FIND v(dout0_9) AT=2220.1n

* CHECK dout0_10 Vdout0_10ck110 = 1.8 time = 2220
.meas tran vdout0_10ck110 FIND v(dout0_10) AT=2220.1n

* CHECK dout0_11 Vdout0_11ck110 = 0 time = 2220
.meas tran vdout0_11ck110 FIND v(dout0_11) AT=2220.1n

* CHECK dout0_12 Vdout0_12ck110 = 0 time = 2220
.meas tran vdout0_12ck110 FIND v(dout0_12) AT=2220.1n

* CHECK dout0_13 Vdout0_13ck110 = 0 time = 2220
.meas tran vdout0_13ck110 FIND v(dout0_13) AT=2220.1n

* CHECK dout0_14 Vdout0_14ck110 = 0 time = 2220
.meas tran vdout0_14ck110 FIND v(dout0_14) AT=2220.1n

* CHECK dout0_15 Vdout0_15ck110 = 1.8 time = 2220
.meas tran vdout0_15ck110 FIND v(dout0_15) AT=2220.1n

* CHECK dout0_0 Vdout0_0ck112 = 0 time = 2260
.meas tran vdout0_0ck112 FIND v(dout0_0) AT=2260.1n

* CHECK dout0_1 Vdout0_1ck112 = 0 time = 2260
.meas tran vdout0_1ck112 FIND v(dout0_1) AT=2260.1n

* CHECK dout0_2 Vdout0_2ck112 = 0 time = 2260
.meas tran vdout0_2ck112 FIND v(dout0_2) AT=2260.1n

* CHECK dout0_3 Vdout0_3ck112 = 1.8 time = 2260
.meas tran vdout0_3ck112 FIND v(dout0_3) AT=2260.1n

* CHECK dout0_4 Vdout0_4ck112 = 1.8 time = 2260
.meas tran vdout0_4ck112 FIND v(dout0_4) AT=2260.1n

* CHECK dout0_5 Vdout0_5ck112 = 0 time = 2260
.meas tran vdout0_5ck112 FIND v(dout0_5) AT=2260.1n

* CHECK dout0_6 Vdout0_6ck112 = 1.8 time = 2260
.meas tran vdout0_6ck112 FIND v(dout0_6) AT=2260.1n

* CHECK dout0_7 Vdout0_7ck112 = 1.8 time = 2260
.meas tran vdout0_7ck112 FIND v(dout0_7) AT=2260.1n

* CHECK dout0_8 Vdout0_8ck112 = 0 time = 2260
.meas tran vdout0_8ck112 FIND v(dout0_8) AT=2260.1n

* CHECK dout0_9 Vdout0_9ck112 = 1.8 time = 2260
.meas tran vdout0_9ck112 FIND v(dout0_9) AT=2260.1n

* CHECK dout0_10 Vdout0_10ck112 = 1.8 time = 2260
.meas tran vdout0_10ck112 FIND v(dout0_10) AT=2260.1n

* CHECK dout0_11 Vdout0_11ck112 = 0 time = 2260
.meas tran vdout0_11ck112 FIND v(dout0_11) AT=2260.1n

* CHECK dout0_12 Vdout0_12ck112 = 0 time = 2260
.meas tran vdout0_12ck112 FIND v(dout0_12) AT=2260.1n

* CHECK dout0_13 Vdout0_13ck112 = 0 time = 2260
.meas tran vdout0_13ck112 FIND v(dout0_13) AT=2260.1n

* CHECK dout0_14 Vdout0_14ck112 = 1.8 time = 2260
.meas tran vdout0_14ck112 FIND v(dout0_14) AT=2260.1n

* CHECK dout0_15 Vdout0_15ck112 = 0 time = 2260
.meas tran vdout0_15ck112 FIND v(dout0_15) AT=2260.1n

* CHECK dout0_0 Vdout0_0ck113 = 0 time = 2280
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=2280.1n

* CHECK dout0_1 Vdout0_1ck113 = 1.8 time = 2280
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=2280.1n

* CHECK dout0_2 Vdout0_2ck113 = 0 time = 2280
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=2280.1n

* CHECK dout0_3 Vdout0_3ck113 = 0 time = 2280
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=2280.1n

* CHECK dout0_4 Vdout0_4ck113 = 0 time = 2280
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=2280.1n

* CHECK dout0_5 Vdout0_5ck113 = 0 time = 2280
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=2280.1n

* CHECK dout0_6 Vdout0_6ck113 = 1.8 time = 2280
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=2280.1n

* CHECK dout0_7 Vdout0_7ck113 = 1.8 time = 2280
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=2280.1n

* CHECK dout0_8 Vdout0_8ck113 = 1.8 time = 2280
.meas tran vdout0_8ck113 FIND v(dout0_8) AT=2280.1n

* CHECK dout0_9 Vdout0_9ck113 = 1.8 time = 2280
.meas tran vdout0_9ck113 FIND v(dout0_9) AT=2280.1n

* CHECK dout0_10 Vdout0_10ck113 = 1.8 time = 2280
.meas tran vdout0_10ck113 FIND v(dout0_10) AT=2280.1n

* CHECK dout0_11 Vdout0_11ck113 = 0 time = 2280
.meas tran vdout0_11ck113 FIND v(dout0_11) AT=2280.1n

* CHECK dout0_12 Vdout0_12ck113 = 1.8 time = 2280
.meas tran vdout0_12ck113 FIND v(dout0_12) AT=2280.1n

* CHECK dout0_13 Vdout0_13ck113 = 1.8 time = 2280
.meas tran vdout0_13ck113 FIND v(dout0_13) AT=2280.1n

* CHECK dout0_14 Vdout0_14ck113 = 1.8 time = 2280
.meas tran vdout0_14ck113 FIND v(dout0_14) AT=2280.1n

* CHECK dout0_15 Vdout0_15ck113 = 0 time = 2280
.meas tran vdout0_15ck113 FIND v(dout0_15) AT=2280.1n

* CHECK dout0_0 Vdout0_0ck118 = 0 time = 2380
.meas tran vdout0_0ck118 FIND v(dout0_0) AT=2380.1n

* CHECK dout0_1 Vdout0_1ck118 = 0 time = 2380
.meas tran vdout0_1ck118 FIND v(dout0_1) AT=2380.1n

* CHECK dout0_2 Vdout0_2ck118 = 1.8 time = 2380
.meas tran vdout0_2ck118 FIND v(dout0_2) AT=2380.1n

* CHECK dout0_3 Vdout0_3ck118 = 0 time = 2380
.meas tran vdout0_3ck118 FIND v(dout0_3) AT=2380.1n

* CHECK dout0_4 Vdout0_4ck118 = 1.8 time = 2380
.meas tran vdout0_4ck118 FIND v(dout0_4) AT=2380.1n

* CHECK dout0_5 Vdout0_5ck118 = 0 time = 2380
.meas tran vdout0_5ck118 FIND v(dout0_5) AT=2380.1n

* CHECK dout0_6 Vdout0_6ck118 = 1.8 time = 2380
.meas tran vdout0_6ck118 FIND v(dout0_6) AT=2380.1n

* CHECK dout0_7 Vdout0_7ck118 = 1.8 time = 2380
.meas tran vdout0_7ck118 FIND v(dout0_7) AT=2380.1n

* CHECK dout0_8 Vdout0_8ck118 = 1.8 time = 2380
.meas tran vdout0_8ck118 FIND v(dout0_8) AT=2380.1n

* CHECK dout0_9 Vdout0_9ck118 = 1.8 time = 2380
.meas tran vdout0_9ck118 FIND v(dout0_9) AT=2380.1n

* CHECK dout0_10 Vdout0_10ck118 = 0 time = 2380
.meas tran vdout0_10ck118 FIND v(dout0_10) AT=2380.1n

* CHECK dout0_11 Vdout0_11ck118 = 0 time = 2380
.meas tran vdout0_11ck118 FIND v(dout0_11) AT=2380.1n

* CHECK dout0_12 Vdout0_12ck118 = 0 time = 2380
.meas tran vdout0_12ck118 FIND v(dout0_12) AT=2380.1n

* CHECK dout0_13 Vdout0_13ck118 = 0 time = 2380
.meas tran vdout0_13ck118 FIND v(dout0_13) AT=2380.1n

* CHECK dout0_14 Vdout0_14ck118 = 0 time = 2380
.meas tran vdout0_14ck118 FIND v(dout0_14) AT=2380.1n

* CHECK dout0_15 Vdout0_15ck118 = 1.8 time = 2380
.meas tran vdout0_15ck118 FIND v(dout0_15) AT=2380.1n

* CHECK dout0_0 Vdout0_0ck120 = 1.8 time = 2420
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=2420.1n

* CHECK dout0_1 Vdout0_1ck120 = 0 time = 2420
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=2420.1n

* CHECK dout0_2 Vdout0_2ck120 = 0 time = 2420
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=2420.1n

* CHECK dout0_3 Vdout0_3ck120 = 1.8 time = 2420
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=2420.1n

* CHECK dout0_4 Vdout0_4ck120 = 1.8 time = 2420
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=2420.1n

* CHECK dout0_5 Vdout0_5ck120 = 1.8 time = 2420
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=2420.1n

* CHECK dout0_6 Vdout0_6ck120 = 1.8 time = 2420
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=2420.1n

* CHECK dout0_7 Vdout0_7ck120 = 0 time = 2420
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=2420.1n

* CHECK dout0_8 Vdout0_8ck120 = 1.8 time = 2420
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=2420.1n

* CHECK dout0_9 Vdout0_9ck120 = 1.8 time = 2420
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=2420.1n

* CHECK dout0_10 Vdout0_10ck120 = 1.8 time = 2420
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=2420.1n

* CHECK dout0_11 Vdout0_11ck120 = 1.8 time = 2420
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=2420.1n

* CHECK dout0_12 Vdout0_12ck120 = 0 time = 2420
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=2420.1n

* CHECK dout0_13 Vdout0_13ck120 = 1.8 time = 2420
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=2420.1n

* CHECK dout0_14 Vdout0_14ck120 = 1.8 time = 2420
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=2420.1n

* CHECK dout0_15 Vdout0_15ck120 = 0 time = 2420
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=2420.1n

* CHECK dout0_0 Vdout0_0ck121 = 0 time = 2440
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=2440.1n

* CHECK dout0_1 Vdout0_1ck121 = 1.8 time = 2440
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=2440.1n

* CHECK dout0_2 Vdout0_2ck121 = 1.8 time = 2440
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=2440.1n

* CHECK dout0_3 Vdout0_3ck121 = 0 time = 2440
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=2440.1n

* CHECK dout0_4 Vdout0_4ck121 = 0 time = 2440
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=2440.1n

* CHECK dout0_5 Vdout0_5ck121 = 0 time = 2440
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=2440.1n

* CHECK dout0_6 Vdout0_6ck121 = 0 time = 2440
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=2440.1n

* CHECK dout0_7 Vdout0_7ck121 = 1.8 time = 2440
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=2440.1n

* CHECK dout0_8 Vdout0_8ck121 = 1.8 time = 2440
.meas tran vdout0_8ck121 FIND v(dout0_8) AT=2440.1n

* CHECK dout0_9 Vdout0_9ck121 = 0 time = 2440
.meas tran vdout0_9ck121 FIND v(dout0_9) AT=2440.1n

* CHECK dout0_10 Vdout0_10ck121 = 0 time = 2440
.meas tran vdout0_10ck121 FIND v(dout0_10) AT=2440.1n

* CHECK dout0_11 Vdout0_11ck121 = 1.8 time = 2440
.meas tran vdout0_11ck121 FIND v(dout0_11) AT=2440.1n

* CHECK dout0_12 Vdout0_12ck121 = 1.8 time = 2440
.meas tran vdout0_12ck121 FIND v(dout0_12) AT=2440.1n

* CHECK dout0_13 Vdout0_13ck121 = 0 time = 2440
.meas tran vdout0_13ck121 FIND v(dout0_13) AT=2440.1n

* CHECK dout0_14 Vdout0_14ck121 = 0 time = 2440
.meas tran vdout0_14ck121 FIND v(dout0_14) AT=2440.1n

* CHECK dout0_15 Vdout0_15ck121 = 0 time = 2440
.meas tran vdout0_15ck121 FIND v(dout0_15) AT=2440.1n

* CHECK dout0_0 Vdout0_0ck123 = 0 time = 2480
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=2480.1n

* CHECK dout0_1 Vdout0_1ck123 = 0 time = 2480
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=2480.1n

* CHECK dout0_2 Vdout0_2ck123 = 1.8 time = 2480
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=2480.1n

* CHECK dout0_3 Vdout0_3ck123 = 0 time = 2480
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=2480.1n

* CHECK dout0_4 Vdout0_4ck123 = 1.8 time = 2480
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=2480.1n

* CHECK dout0_5 Vdout0_5ck123 = 0 time = 2480
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=2480.1n

* CHECK dout0_6 Vdout0_6ck123 = 1.8 time = 2480
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=2480.1n

* CHECK dout0_7 Vdout0_7ck123 = 1.8 time = 2480
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=2480.1n

* CHECK dout0_8 Vdout0_8ck123 = 1.8 time = 2480
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=2480.1n

* CHECK dout0_9 Vdout0_9ck123 = 1.8 time = 2480
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=2480.1n

* CHECK dout0_10 Vdout0_10ck123 = 0 time = 2480
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=2480.1n

* CHECK dout0_11 Vdout0_11ck123 = 0 time = 2480
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=2480.1n

* CHECK dout0_12 Vdout0_12ck123 = 0 time = 2480
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=2480.1n

* CHECK dout0_13 Vdout0_13ck123 = 0 time = 2480
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=2480.1n

* CHECK dout0_14 Vdout0_14ck123 = 0 time = 2480
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=2480.1n

* CHECK dout0_15 Vdout0_15ck123 = 1.8 time = 2480
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=2480.1n

* CHECK dout0_0 Vdout0_0ck124 = 1.8 time = 2500
.meas tran vdout0_0ck124 FIND v(dout0_0) AT=2500.1n

* CHECK dout0_1 Vdout0_1ck124 = 0 time = 2500
.meas tran vdout0_1ck124 FIND v(dout0_1) AT=2500.1n

* CHECK dout0_2 Vdout0_2ck124 = 0 time = 2500
.meas tran vdout0_2ck124 FIND v(dout0_2) AT=2500.1n

* CHECK dout0_3 Vdout0_3ck124 = 1.8 time = 2500
.meas tran vdout0_3ck124 FIND v(dout0_3) AT=2500.1n

* CHECK dout0_4 Vdout0_4ck124 = 1.8 time = 2500
.meas tran vdout0_4ck124 FIND v(dout0_4) AT=2500.1n

* CHECK dout0_5 Vdout0_5ck124 = 1.8 time = 2500
.meas tran vdout0_5ck124 FIND v(dout0_5) AT=2500.1n

* CHECK dout0_6 Vdout0_6ck124 = 1.8 time = 2500
.meas tran vdout0_6ck124 FIND v(dout0_6) AT=2500.1n

* CHECK dout0_7 Vdout0_7ck124 = 0 time = 2500
.meas tran vdout0_7ck124 FIND v(dout0_7) AT=2500.1n

* CHECK dout0_8 Vdout0_8ck124 = 1.8 time = 2500
.meas tran vdout0_8ck124 FIND v(dout0_8) AT=2500.1n

* CHECK dout0_9 Vdout0_9ck124 = 1.8 time = 2500
.meas tran vdout0_9ck124 FIND v(dout0_9) AT=2500.1n

* CHECK dout0_10 Vdout0_10ck124 = 1.8 time = 2500
.meas tran vdout0_10ck124 FIND v(dout0_10) AT=2500.1n

* CHECK dout0_11 Vdout0_11ck124 = 1.8 time = 2500
.meas tran vdout0_11ck124 FIND v(dout0_11) AT=2500.1n

* CHECK dout0_12 Vdout0_12ck124 = 0 time = 2500
.meas tran vdout0_12ck124 FIND v(dout0_12) AT=2500.1n

* CHECK dout0_13 Vdout0_13ck124 = 1.8 time = 2500
.meas tran vdout0_13ck124 FIND v(dout0_13) AT=2500.1n

* CHECK dout0_14 Vdout0_14ck124 = 1.8 time = 2500
.meas tran vdout0_14ck124 FIND v(dout0_14) AT=2500.1n

* CHECK dout0_15 Vdout0_15ck124 = 0 time = 2500
.meas tran vdout0_15ck124 FIND v(dout0_15) AT=2500.1n

* CHECK dout0_0 Vdout0_0ck125 = 1.8 time = 2520
.meas tran vdout0_0ck125 FIND v(dout0_0) AT=2520.1n

* CHECK dout0_1 Vdout0_1ck125 = 0 time = 2520
.meas tran vdout0_1ck125 FIND v(dout0_1) AT=2520.1n

* CHECK dout0_2 Vdout0_2ck125 = 0 time = 2520
.meas tran vdout0_2ck125 FIND v(dout0_2) AT=2520.1n

* CHECK dout0_3 Vdout0_3ck125 = 0 time = 2520
.meas tran vdout0_3ck125 FIND v(dout0_3) AT=2520.1n

* CHECK dout0_4 Vdout0_4ck125 = 0 time = 2520
.meas tran vdout0_4ck125 FIND v(dout0_4) AT=2520.1n

* CHECK dout0_5 Vdout0_5ck125 = 1.8 time = 2520
.meas tran vdout0_5ck125 FIND v(dout0_5) AT=2520.1n

* CHECK dout0_6 Vdout0_6ck125 = 1.8 time = 2520
.meas tran vdout0_6ck125 FIND v(dout0_6) AT=2520.1n

* CHECK dout0_7 Vdout0_7ck125 = 0 time = 2520
.meas tran vdout0_7ck125 FIND v(dout0_7) AT=2520.1n

* CHECK dout0_8 Vdout0_8ck125 = 1.8 time = 2520
.meas tran vdout0_8ck125 FIND v(dout0_8) AT=2520.1n

* CHECK dout0_9 Vdout0_9ck125 = 1.8 time = 2520
.meas tran vdout0_9ck125 FIND v(dout0_9) AT=2520.1n

* CHECK dout0_10 Vdout0_10ck125 = 0 time = 2520
.meas tran vdout0_10ck125 FIND v(dout0_10) AT=2520.1n

* CHECK dout0_11 Vdout0_11ck125 = 1.8 time = 2520
.meas tran vdout0_11ck125 FIND v(dout0_11) AT=2520.1n

* CHECK dout0_12 Vdout0_12ck125 = 1.8 time = 2520
.meas tran vdout0_12ck125 FIND v(dout0_12) AT=2520.1n

* CHECK dout0_13 Vdout0_13ck125 = 0 time = 2520
.meas tran vdout0_13ck125 FIND v(dout0_13) AT=2520.1n

* CHECK dout0_14 Vdout0_14ck125 = 1.8 time = 2520
.meas tran vdout0_14ck125 FIND v(dout0_14) AT=2520.1n

* CHECK dout0_15 Vdout0_15ck125 = 0 time = 2520
.meas tran vdout0_15ck125 FIND v(dout0_15) AT=2520.1n

* CHECK dout0_0 Vdout0_0ck126 = 0 time = 2540
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=2540.1n

* CHECK dout0_1 Vdout0_1ck126 = 1.8 time = 2540
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=2540.1n

* CHECK dout0_2 Vdout0_2ck126 = 1.8 time = 2540
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=2540.1n

* CHECK dout0_3 Vdout0_3ck126 = 0 time = 2540
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=2540.1n

* CHECK dout0_4 Vdout0_4ck126 = 0 time = 2540
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=2540.1n

* CHECK dout0_5 Vdout0_5ck126 = 0 time = 2540
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=2540.1n

* CHECK dout0_6 Vdout0_6ck126 = 0 time = 2540
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=2540.1n

* CHECK dout0_7 Vdout0_7ck126 = 1.8 time = 2540
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=2540.1n

* CHECK dout0_8 Vdout0_8ck126 = 1.8 time = 2540
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=2540.1n

* CHECK dout0_9 Vdout0_9ck126 = 0 time = 2540
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=2540.1n

* CHECK dout0_10 Vdout0_10ck126 = 0 time = 2540
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=2540.1n

* CHECK dout0_11 Vdout0_11ck126 = 1.8 time = 2540
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=2540.1n

* CHECK dout0_12 Vdout0_12ck126 = 1.8 time = 2540
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=2540.1n

* CHECK dout0_13 Vdout0_13ck126 = 0 time = 2540
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=2540.1n

* CHECK dout0_14 Vdout0_14ck126 = 0 time = 2540
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=2540.1n

* CHECK dout0_15 Vdout0_15ck126 = 0 time = 2540
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=2540.1n

* CHECK dout0_0 Vdout0_0ck128 = 1.8 time = 2580
.meas tran vdout0_0ck128 FIND v(dout0_0) AT=2580.1n

* CHECK dout0_1 Vdout0_1ck128 = 1.8 time = 2580
.meas tran vdout0_1ck128 FIND v(dout0_1) AT=2580.1n

* CHECK dout0_2 Vdout0_2ck128 = 1.8 time = 2580
.meas tran vdout0_2ck128 FIND v(dout0_2) AT=2580.1n

* CHECK dout0_3 Vdout0_3ck128 = 0 time = 2580
.meas tran vdout0_3ck128 FIND v(dout0_3) AT=2580.1n

* CHECK dout0_4 Vdout0_4ck128 = 0 time = 2580
.meas tran vdout0_4ck128 FIND v(dout0_4) AT=2580.1n

* CHECK dout0_5 Vdout0_5ck128 = 0 time = 2580
.meas tran vdout0_5ck128 FIND v(dout0_5) AT=2580.1n

* CHECK dout0_6 Vdout0_6ck128 = 1.8 time = 2580
.meas tran vdout0_6ck128 FIND v(dout0_6) AT=2580.1n

* CHECK dout0_7 Vdout0_7ck128 = 1.8 time = 2580
.meas tran vdout0_7ck128 FIND v(dout0_7) AT=2580.1n

* CHECK dout0_8 Vdout0_8ck128 = 1.8 time = 2580
.meas tran vdout0_8ck128 FIND v(dout0_8) AT=2580.1n

* CHECK dout0_9 Vdout0_9ck128 = 1.8 time = 2580
.meas tran vdout0_9ck128 FIND v(dout0_9) AT=2580.1n

* CHECK dout0_10 Vdout0_10ck128 = 1.8 time = 2580
.meas tran vdout0_10ck128 FIND v(dout0_10) AT=2580.1n

* CHECK dout0_11 Vdout0_11ck128 = 0 time = 2580
.meas tran vdout0_11ck128 FIND v(dout0_11) AT=2580.1n

* CHECK dout0_12 Vdout0_12ck128 = 0 time = 2580
.meas tran vdout0_12ck128 FIND v(dout0_12) AT=2580.1n

* CHECK dout0_13 Vdout0_13ck128 = 0 time = 2580
.meas tran vdout0_13ck128 FIND v(dout0_13) AT=2580.1n

* CHECK dout0_14 Vdout0_14ck128 = 1.8 time = 2580
.meas tran vdout0_14ck128 FIND v(dout0_14) AT=2580.1n

* CHECK dout0_15 Vdout0_15ck128 = 0 time = 2580
.meas tran vdout0_15ck128 FIND v(dout0_15) AT=2580.1n

* CHECK dout0_0 Vdout0_0ck129 = 1.8 time = 2600
.meas tran vdout0_0ck129 FIND v(dout0_0) AT=2600.1n

* CHECK dout0_1 Vdout0_1ck129 = 1.8 time = 2600
.meas tran vdout0_1ck129 FIND v(dout0_1) AT=2600.1n

* CHECK dout0_2 Vdout0_2ck129 = 1.8 time = 2600
.meas tran vdout0_2ck129 FIND v(dout0_2) AT=2600.1n

* CHECK dout0_3 Vdout0_3ck129 = 0 time = 2600
.meas tran vdout0_3ck129 FIND v(dout0_3) AT=2600.1n

* CHECK dout0_4 Vdout0_4ck129 = 0 time = 2600
.meas tran vdout0_4ck129 FIND v(dout0_4) AT=2600.1n

* CHECK dout0_5 Vdout0_5ck129 = 0 time = 2600
.meas tran vdout0_5ck129 FIND v(dout0_5) AT=2600.1n

* CHECK dout0_6 Vdout0_6ck129 = 1.8 time = 2600
.meas tran vdout0_6ck129 FIND v(dout0_6) AT=2600.1n

* CHECK dout0_7 Vdout0_7ck129 = 1.8 time = 2600
.meas tran vdout0_7ck129 FIND v(dout0_7) AT=2600.1n

* CHECK dout0_8 Vdout0_8ck129 = 1.8 time = 2600
.meas tran vdout0_8ck129 FIND v(dout0_8) AT=2600.1n

* CHECK dout0_9 Vdout0_9ck129 = 1.8 time = 2600
.meas tran vdout0_9ck129 FIND v(dout0_9) AT=2600.1n

* CHECK dout0_10 Vdout0_10ck129 = 1.8 time = 2600
.meas tran vdout0_10ck129 FIND v(dout0_10) AT=2600.1n

* CHECK dout0_11 Vdout0_11ck129 = 0 time = 2600
.meas tran vdout0_11ck129 FIND v(dout0_11) AT=2600.1n

* CHECK dout0_12 Vdout0_12ck129 = 0 time = 2600
.meas tran vdout0_12ck129 FIND v(dout0_12) AT=2600.1n

* CHECK dout0_13 Vdout0_13ck129 = 0 time = 2600
.meas tran vdout0_13ck129 FIND v(dout0_13) AT=2600.1n

* CHECK dout0_14 Vdout0_14ck129 = 1.8 time = 2600
.meas tran vdout0_14ck129 FIND v(dout0_14) AT=2600.1n

* CHECK dout0_15 Vdout0_15ck129 = 0 time = 2600
.meas tran vdout0_15ck129 FIND v(dout0_15) AT=2600.1n

* CHECK dout0_0 Vdout0_0ck130 = 0 time = 2620
.meas tran vdout0_0ck130 FIND v(dout0_0) AT=2620.1n

* CHECK dout0_1 Vdout0_1ck130 = 0 time = 2620
.meas tran vdout0_1ck130 FIND v(dout0_1) AT=2620.1n

* CHECK dout0_2 Vdout0_2ck130 = 1.8 time = 2620
.meas tran vdout0_2ck130 FIND v(dout0_2) AT=2620.1n

* CHECK dout0_3 Vdout0_3ck130 = 0 time = 2620
.meas tran vdout0_3ck130 FIND v(dout0_3) AT=2620.1n

* CHECK dout0_4 Vdout0_4ck130 = 0 time = 2620
.meas tran vdout0_4ck130 FIND v(dout0_4) AT=2620.1n

* CHECK dout0_5 Vdout0_5ck130 = 1.8 time = 2620
.meas tran vdout0_5ck130 FIND v(dout0_5) AT=2620.1n

* CHECK dout0_6 Vdout0_6ck130 = 0 time = 2620
.meas tran vdout0_6ck130 FIND v(dout0_6) AT=2620.1n

* CHECK dout0_7 Vdout0_7ck130 = 1.8 time = 2620
.meas tran vdout0_7ck130 FIND v(dout0_7) AT=2620.1n

* CHECK dout0_8 Vdout0_8ck130 = 0 time = 2620
.meas tran vdout0_8ck130 FIND v(dout0_8) AT=2620.1n

* CHECK dout0_9 Vdout0_9ck130 = 0 time = 2620
.meas tran vdout0_9ck130 FIND v(dout0_9) AT=2620.1n

* CHECK dout0_10 Vdout0_10ck130 = 1.8 time = 2620
.meas tran vdout0_10ck130 FIND v(dout0_10) AT=2620.1n

* CHECK dout0_11 Vdout0_11ck130 = 1.8 time = 2620
.meas tran vdout0_11ck130 FIND v(dout0_11) AT=2620.1n

* CHECK dout0_12 Vdout0_12ck130 = 0 time = 2620
.meas tran vdout0_12ck130 FIND v(dout0_12) AT=2620.1n

* CHECK dout0_13 Vdout0_13ck130 = 1.8 time = 2620
.meas tran vdout0_13ck130 FIND v(dout0_13) AT=2620.1n

* CHECK dout0_14 Vdout0_14ck130 = 0 time = 2620
.meas tran vdout0_14ck130 FIND v(dout0_14) AT=2620.1n

* CHECK dout0_15 Vdout0_15ck130 = 0 time = 2620
.meas tran vdout0_15ck130 FIND v(dout0_15) AT=2620.1n

* CHECK dout0_0 Vdout0_0ck134 = 0 time = 2700
.meas tran vdout0_0ck134 FIND v(dout0_0) AT=2700.1n

* CHECK dout0_1 Vdout0_1ck134 = 1.8 time = 2700
.meas tran vdout0_1ck134 FIND v(dout0_1) AT=2700.1n

* CHECK dout0_2 Vdout0_2ck134 = 0 time = 2700
.meas tran vdout0_2ck134 FIND v(dout0_2) AT=2700.1n

* CHECK dout0_3 Vdout0_3ck134 = 1.8 time = 2700
.meas tran vdout0_3ck134 FIND v(dout0_3) AT=2700.1n

* CHECK dout0_4 Vdout0_4ck134 = 0 time = 2700
.meas tran vdout0_4ck134 FIND v(dout0_4) AT=2700.1n

* CHECK dout0_5 Vdout0_5ck134 = 1.8 time = 2700
.meas tran vdout0_5ck134 FIND v(dout0_5) AT=2700.1n

* CHECK dout0_6 Vdout0_6ck134 = 1.8 time = 2700
.meas tran vdout0_6ck134 FIND v(dout0_6) AT=2700.1n

* CHECK dout0_7 Vdout0_7ck134 = 0 time = 2700
.meas tran vdout0_7ck134 FIND v(dout0_7) AT=2700.1n

* CHECK dout0_8 Vdout0_8ck134 = 0 time = 2700
.meas tran vdout0_8ck134 FIND v(dout0_8) AT=2700.1n

* CHECK dout0_9 Vdout0_9ck134 = 0 time = 2700
.meas tran vdout0_9ck134 FIND v(dout0_9) AT=2700.1n

* CHECK dout0_10 Vdout0_10ck134 = 0 time = 2700
.meas tran vdout0_10ck134 FIND v(dout0_10) AT=2700.1n

* CHECK dout0_11 Vdout0_11ck134 = 1.8 time = 2700
.meas tran vdout0_11ck134 FIND v(dout0_11) AT=2700.1n

* CHECK dout0_12 Vdout0_12ck134 = 0 time = 2700
.meas tran vdout0_12ck134 FIND v(dout0_12) AT=2700.1n

* CHECK dout0_13 Vdout0_13ck134 = 0 time = 2700
.meas tran vdout0_13ck134 FIND v(dout0_13) AT=2700.1n

* CHECK dout0_14 Vdout0_14ck134 = 0 time = 2700
.meas tran vdout0_14ck134 FIND v(dout0_14) AT=2700.1n

* CHECK dout0_15 Vdout0_15ck134 = 1.8 time = 2700
.meas tran vdout0_15ck134 FIND v(dout0_15) AT=2700.1n

* CHECK dout0_0 Vdout0_0ck135 = 0 time = 2720
.meas tran vdout0_0ck135 FIND v(dout0_0) AT=2720.1n

* CHECK dout0_1 Vdout0_1ck135 = 1.8 time = 2720
.meas tran vdout0_1ck135 FIND v(dout0_1) AT=2720.1n

* CHECK dout0_2 Vdout0_2ck135 = 0 time = 2720
.meas tran vdout0_2ck135 FIND v(dout0_2) AT=2720.1n

* CHECK dout0_3 Vdout0_3ck135 = 1.8 time = 2720
.meas tran vdout0_3ck135 FIND v(dout0_3) AT=2720.1n

* CHECK dout0_4 Vdout0_4ck135 = 0 time = 2720
.meas tran vdout0_4ck135 FIND v(dout0_4) AT=2720.1n

* CHECK dout0_5 Vdout0_5ck135 = 1.8 time = 2720
.meas tran vdout0_5ck135 FIND v(dout0_5) AT=2720.1n

* CHECK dout0_6 Vdout0_6ck135 = 1.8 time = 2720
.meas tran vdout0_6ck135 FIND v(dout0_6) AT=2720.1n

* CHECK dout0_7 Vdout0_7ck135 = 0 time = 2720
.meas tran vdout0_7ck135 FIND v(dout0_7) AT=2720.1n

* CHECK dout0_8 Vdout0_8ck135 = 0 time = 2720
.meas tran vdout0_8ck135 FIND v(dout0_8) AT=2720.1n

* CHECK dout0_9 Vdout0_9ck135 = 0 time = 2720
.meas tran vdout0_9ck135 FIND v(dout0_9) AT=2720.1n

* CHECK dout0_10 Vdout0_10ck135 = 0 time = 2720
.meas tran vdout0_10ck135 FIND v(dout0_10) AT=2720.1n

* CHECK dout0_11 Vdout0_11ck135 = 1.8 time = 2720
.meas tran vdout0_11ck135 FIND v(dout0_11) AT=2720.1n

* CHECK dout0_12 Vdout0_12ck135 = 0 time = 2720
.meas tran vdout0_12ck135 FIND v(dout0_12) AT=2720.1n

* CHECK dout0_13 Vdout0_13ck135 = 0 time = 2720
.meas tran vdout0_13ck135 FIND v(dout0_13) AT=2720.1n

* CHECK dout0_14 Vdout0_14ck135 = 0 time = 2720
.meas tran vdout0_14ck135 FIND v(dout0_14) AT=2720.1n

* CHECK dout0_15 Vdout0_15ck135 = 1.8 time = 2720
.meas tran vdout0_15ck135 FIND v(dout0_15) AT=2720.1n

* CHECK dout0_0 Vdout0_0ck140 = 0 time = 2820
.meas tran vdout0_0ck140 FIND v(dout0_0) AT=2820.1n

* CHECK dout0_1 Vdout0_1ck140 = 1.8 time = 2820
.meas tran vdout0_1ck140 FIND v(dout0_1) AT=2820.1n

* CHECK dout0_2 Vdout0_2ck140 = 1.8 time = 2820
.meas tran vdout0_2ck140 FIND v(dout0_2) AT=2820.1n

* CHECK dout0_3 Vdout0_3ck140 = 1.8 time = 2820
.meas tran vdout0_3ck140 FIND v(dout0_3) AT=2820.1n

* CHECK dout0_4 Vdout0_4ck140 = 0 time = 2820
.meas tran vdout0_4ck140 FIND v(dout0_4) AT=2820.1n

* CHECK dout0_5 Vdout0_5ck140 = 0 time = 2820
.meas tran vdout0_5ck140 FIND v(dout0_5) AT=2820.1n

* CHECK dout0_6 Vdout0_6ck140 = 0 time = 2820
.meas tran vdout0_6ck140 FIND v(dout0_6) AT=2820.1n

* CHECK dout0_7 Vdout0_7ck140 = 0 time = 2820
.meas tran vdout0_7ck140 FIND v(dout0_7) AT=2820.1n

* CHECK dout0_8 Vdout0_8ck140 = 1.8 time = 2820
.meas tran vdout0_8ck140 FIND v(dout0_8) AT=2820.1n

* CHECK dout0_9 Vdout0_9ck140 = 1.8 time = 2820
.meas tran vdout0_9ck140 FIND v(dout0_9) AT=2820.1n

* CHECK dout0_10 Vdout0_10ck140 = 0 time = 2820
.meas tran vdout0_10ck140 FIND v(dout0_10) AT=2820.1n

* CHECK dout0_11 Vdout0_11ck140 = 0 time = 2820
.meas tran vdout0_11ck140 FIND v(dout0_11) AT=2820.1n

* CHECK dout0_12 Vdout0_12ck140 = 0 time = 2820
.meas tran vdout0_12ck140 FIND v(dout0_12) AT=2820.1n

* CHECK dout0_13 Vdout0_13ck140 = 1.8 time = 2820
.meas tran vdout0_13ck140 FIND v(dout0_13) AT=2820.1n

* CHECK dout0_14 Vdout0_14ck140 = 0 time = 2820
.meas tran vdout0_14ck140 FIND v(dout0_14) AT=2820.1n

* CHECK dout0_15 Vdout0_15ck140 = 0 time = 2820
.meas tran vdout0_15ck140 FIND v(dout0_15) AT=2820.1n

* CHECK dout0_0 Vdout0_0ck142 = 1.8 time = 2860
.meas tran vdout0_0ck142 FIND v(dout0_0) AT=2860.1n

* CHECK dout0_1 Vdout0_1ck142 = 1.8 time = 2860
.meas tran vdout0_1ck142 FIND v(dout0_1) AT=2860.1n

* CHECK dout0_2 Vdout0_2ck142 = 0 time = 2860
.meas tran vdout0_2ck142 FIND v(dout0_2) AT=2860.1n

* CHECK dout0_3 Vdout0_3ck142 = 0 time = 2860
.meas tran vdout0_3ck142 FIND v(dout0_3) AT=2860.1n

* CHECK dout0_4 Vdout0_4ck142 = 1.8 time = 2860
.meas tran vdout0_4ck142 FIND v(dout0_4) AT=2860.1n

* CHECK dout0_5 Vdout0_5ck142 = 0 time = 2860
.meas tran vdout0_5ck142 FIND v(dout0_5) AT=2860.1n

* CHECK dout0_6 Vdout0_6ck142 = 1.8 time = 2860
.meas tran vdout0_6ck142 FIND v(dout0_6) AT=2860.1n

* CHECK dout0_7 Vdout0_7ck142 = 1.8 time = 2860
.meas tran vdout0_7ck142 FIND v(dout0_7) AT=2860.1n

* CHECK dout0_8 Vdout0_8ck142 = 0 time = 2860
.meas tran vdout0_8ck142 FIND v(dout0_8) AT=2860.1n

* CHECK dout0_9 Vdout0_9ck142 = 1.8 time = 2860
.meas tran vdout0_9ck142 FIND v(dout0_9) AT=2860.1n

* CHECK dout0_10 Vdout0_10ck142 = 1.8 time = 2860
.meas tran vdout0_10ck142 FIND v(dout0_10) AT=2860.1n

* CHECK dout0_11 Vdout0_11ck142 = 0 time = 2860
.meas tran vdout0_11ck142 FIND v(dout0_11) AT=2860.1n

* CHECK dout0_12 Vdout0_12ck142 = 0 time = 2860
.meas tran vdout0_12ck142 FIND v(dout0_12) AT=2860.1n

* CHECK dout0_13 Vdout0_13ck142 = 0 time = 2860
.meas tran vdout0_13ck142 FIND v(dout0_13) AT=2860.1n

* CHECK dout0_14 Vdout0_14ck142 = 0 time = 2860
.meas tran vdout0_14ck142 FIND v(dout0_14) AT=2860.1n

* CHECK dout0_15 Vdout0_15ck142 = 0 time = 2860
.meas tran vdout0_15ck142 FIND v(dout0_15) AT=2860.1n

* CHECK dout0_0 Vdout0_0ck143 = 0 time = 2880
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=2880.1n

* CHECK dout0_1 Vdout0_1ck143 = 0 time = 2880
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=2880.1n

* CHECK dout0_2 Vdout0_2ck143 = 1.8 time = 2880
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=2880.1n

* CHECK dout0_3 Vdout0_3ck143 = 0 time = 2880
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=2880.1n

* CHECK dout0_4 Vdout0_4ck143 = 0 time = 2880
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=2880.1n

* CHECK dout0_5 Vdout0_5ck143 = 1.8 time = 2880
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=2880.1n

* CHECK dout0_6 Vdout0_6ck143 = 0 time = 2880
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=2880.1n

* CHECK dout0_7 Vdout0_7ck143 = 1.8 time = 2880
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=2880.1n

* CHECK dout0_8 Vdout0_8ck143 = 0 time = 2880
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=2880.1n

* CHECK dout0_9 Vdout0_9ck143 = 0 time = 2880
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=2880.1n

* CHECK dout0_10 Vdout0_10ck143 = 1.8 time = 2880
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=2880.1n

* CHECK dout0_11 Vdout0_11ck143 = 1.8 time = 2880
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=2880.1n

* CHECK dout0_12 Vdout0_12ck143 = 0 time = 2880
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=2880.1n

* CHECK dout0_13 Vdout0_13ck143 = 1.8 time = 2880
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=2880.1n

* CHECK dout0_14 Vdout0_14ck143 = 0 time = 2880
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=2880.1n

* CHECK dout0_15 Vdout0_15ck143 = 0 time = 2880
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=2880.1n

* CHECK dout0_0 Vdout0_0ck144 = 0 time = 2900
.meas tran vdout0_0ck144 FIND v(dout0_0) AT=2900.1n

* CHECK dout0_1 Vdout0_1ck144 = 1.8 time = 2900
.meas tran vdout0_1ck144 FIND v(dout0_1) AT=2900.1n

* CHECK dout0_2 Vdout0_2ck144 = 0 time = 2900
.meas tran vdout0_2ck144 FIND v(dout0_2) AT=2900.1n

* CHECK dout0_3 Vdout0_3ck144 = 1.8 time = 2900
.meas tran vdout0_3ck144 FIND v(dout0_3) AT=2900.1n

* CHECK dout0_4 Vdout0_4ck144 = 0 time = 2900
.meas tran vdout0_4ck144 FIND v(dout0_4) AT=2900.1n

* CHECK dout0_5 Vdout0_5ck144 = 1.8 time = 2900
.meas tran vdout0_5ck144 FIND v(dout0_5) AT=2900.1n

* CHECK dout0_6 Vdout0_6ck144 = 1.8 time = 2900
.meas tran vdout0_6ck144 FIND v(dout0_6) AT=2900.1n

* CHECK dout0_7 Vdout0_7ck144 = 0 time = 2900
.meas tran vdout0_7ck144 FIND v(dout0_7) AT=2900.1n

* CHECK dout0_8 Vdout0_8ck144 = 0 time = 2900
.meas tran vdout0_8ck144 FIND v(dout0_8) AT=2900.1n

* CHECK dout0_9 Vdout0_9ck144 = 0 time = 2900
.meas tran vdout0_9ck144 FIND v(dout0_9) AT=2900.1n

* CHECK dout0_10 Vdout0_10ck144 = 0 time = 2900
.meas tran vdout0_10ck144 FIND v(dout0_10) AT=2900.1n

* CHECK dout0_11 Vdout0_11ck144 = 1.8 time = 2900
.meas tran vdout0_11ck144 FIND v(dout0_11) AT=2900.1n

* CHECK dout0_12 Vdout0_12ck144 = 0 time = 2900
.meas tran vdout0_12ck144 FIND v(dout0_12) AT=2900.1n

* CHECK dout0_13 Vdout0_13ck144 = 0 time = 2900
.meas tran vdout0_13ck144 FIND v(dout0_13) AT=2900.1n

* CHECK dout0_14 Vdout0_14ck144 = 0 time = 2900
.meas tran vdout0_14ck144 FIND v(dout0_14) AT=2900.1n

* CHECK dout0_15 Vdout0_15ck144 = 1.8 time = 2900
.meas tran vdout0_15ck144 FIND v(dout0_15) AT=2900.1n

* CHECK dout0_0 Vdout0_0ck145 = 0 time = 2920
.meas tran vdout0_0ck145 FIND v(dout0_0) AT=2920.1n

* CHECK dout0_1 Vdout0_1ck145 = 1.8 time = 2920
.meas tran vdout0_1ck145 FIND v(dout0_1) AT=2920.1n

* CHECK dout0_2 Vdout0_2ck145 = 0 time = 2920
.meas tran vdout0_2ck145 FIND v(dout0_2) AT=2920.1n

* CHECK dout0_3 Vdout0_3ck145 = 1.8 time = 2920
.meas tran vdout0_3ck145 FIND v(dout0_3) AT=2920.1n

* CHECK dout0_4 Vdout0_4ck145 = 0 time = 2920
.meas tran vdout0_4ck145 FIND v(dout0_4) AT=2920.1n

* CHECK dout0_5 Vdout0_5ck145 = 1.8 time = 2920
.meas tran vdout0_5ck145 FIND v(dout0_5) AT=2920.1n

* CHECK dout0_6 Vdout0_6ck145 = 1.8 time = 2920
.meas tran vdout0_6ck145 FIND v(dout0_6) AT=2920.1n

* CHECK dout0_7 Vdout0_7ck145 = 0 time = 2920
.meas tran vdout0_7ck145 FIND v(dout0_7) AT=2920.1n

* CHECK dout0_8 Vdout0_8ck145 = 0 time = 2920
.meas tran vdout0_8ck145 FIND v(dout0_8) AT=2920.1n

* CHECK dout0_9 Vdout0_9ck145 = 0 time = 2920
.meas tran vdout0_9ck145 FIND v(dout0_9) AT=2920.1n

* CHECK dout0_10 Vdout0_10ck145 = 0 time = 2920
.meas tran vdout0_10ck145 FIND v(dout0_10) AT=2920.1n

* CHECK dout0_11 Vdout0_11ck145 = 1.8 time = 2920
.meas tran vdout0_11ck145 FIND v(dout0_11) AT=2920.1n

* CHECK dout0_12 Vdout0_12ck145 = 0 time = 2920
.meas tran vdout0_12ck145 FIND v(dout0_12) AT=2920.1n

* CHECK dout0_13 Vdout0_13ck145 = 0 time = 2920
.meas tran vdout0_13ck145 FIND v(dout0_13) AT=2920.1n

* CHECK dout0_14 Vdout0_14ck145 = 0 time = 2920
.meas tran vdout0_14ck145 FIND v(dout0_14) AT=2920.1n

* CHECK dout0_15 Vdout0_15ck145 = 1.8 time = 2920
.meas tran vdout0_15ck145 FIND v(dout0_15) AT=2920.1n

* CHECK dout0_0 Vdout0_0ck146 = 0 time = 2940
.meas tran vdout0_0ck146 FIND v(dout0_0) AT=2940.1n

* CHECK dout0_1 Vdout0_1ck146 = 0 time = 2940
.meas tran vdout0_1ck146 FIND v(dout0_1) AT=2940.1n

* CHECK dout0_2 Vdout0_2ck146 = 1.8 time = 2940
.meas tran vdout0_2ck146 FIND v(dout0_2) AT=2940.1n

* CHECK dout0_3 Vdout0_3ck146 = 1.8 time = 2940
.meas tran vdout0_3ck146 FIND v(dout0_3) AT=2940.1n

* CHECK dout0_4 Vdout0_4ck146 = 0 time = 2940
.meas tran vdout0_4ck146 FIND v(dout0_4) AT=2940.1n

* CHECK dout0_5 Vdout0_5ck146 = 1.8 time = 2940
.meas tran vdout0_5ck146 FIND v(dout0_5) AT=2940.1n

* CHECK dout0_6 Vdout0_6ck146 = 0 time = 2940
.meas tran vdout0_6ck146 FIND v(dout0_6) AT=2940.1n

* CHECK dout0_7 Vdout0_7ck146 = 1.8 time = 2940
.meas tran vdout0_7ck146 FIND v(dout0_7) AT=2940.1n

* CHECK dout0_8 Vdout0_8ck146 = 1.8 time = 2940
.meas tran vdout0_8ck146 FIND v(dout0_8) AT=2940.1n

* CHECK dout0_9 Vdout0_9ck146 = 1.8 time = 2940
.meas tran vdout0_9ck146 FIND v(dout0_9) AT=2940.1n

* CHECK dout0_10 Vdout0_10ck146 = 1.8 time = 2940
.meas tran vdout0_10ck146 FIND v(dout0_10) AT=2940.1n

* CHECK dout0_11 Vdout0_11ck146 = 0 time = 2940
.meas tran vdout0_11ck146 FIND v(dout0_11) AT=2940.1n

* CHECK dout0_12 Vdout0_12ck146 = 0 time = 2940
.meas tran vdout0_12ck146 FIND v(dout0_12) AT=2940.1n

* CHECK dout0_13 Vdout0_13ck146 = 0 time = 2940
.meas tran vdout0_13ck146 FIND v(dout0_13) AT=2940.1n

* CHECK dout0_14 Vdout0_14ck146 = 0 time = 2940
.meas tran vdout0_14ck146 FIND v(dout0_14) AT=2940.1n

* CHECK dout0_15 Vdout0_15ck146 = 1.8 time = 2940
.meas tran vdout0_15ck146 FIND v(dout0_15) AT=2940.1n

* CHECK dout0_0 Vdout0_0ck148 = 0 time = 2980
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=2980.1n

* CHECK dout0_1 Vdout0_1ck148 = 1.8 time = 2980
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=2980.1n

* CHECK dout0_2 Vdout0_2ck148 = 0 time = 2980
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=2980.1n

* CHECK dout0_3 Vdout0_3ck148 = 1.8 time = 2980
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=2980.1n

* CHECK dout0_4 Vdout0_4ck148 = 0 time = 2980
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=2980.1n

* CHECK dout0_5 Vdout0_5ck148 = 1.8 time = 2980
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=2980.1n

* CHECK dout0_6 Vdout0_6ck148 = 1.8 time = 2980
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=2980.1n

* CHECK dout0_7 Vdout0_7ck148 = 0 time = 2980
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=2980.1n

* CHECK dout0_8 Vdout0_8ck148 = 0 time = 2980
.meas tran vdout0_8ck148 FIND v(dout0_8) AT=2980.1n

* CHECK dout0_9 Vdout0_9ck148 = 0 time = 2980
.meas tran vdout0_9ck148 FIND v(dout0_9) AT=2980.1n

* CHECK dout0_10 Vdout0_10ck148 = 0 time = 2980
.meas tran vdout0_10ck148 FIND v(dout0_10) AT=2980.1n

* CHECK dout0_11 Vdout0_11ck148 = 1.8 time = 2980
.meas tran vdout0_11ck148 FIND v(dout0_11) AT=2980.1n

* CHECK dout0_12 Vdout0_12ck148 = 0 time = 2980
.meas tran vdout0_12ck148 FIND v(dout0_12) AT=2980.1n

* CHECK dout0_13 Vdout0_13ck148 = 0 time = 2980
.meas tran vdout0_13ck148 FIND v(dout0_13) AT=2980.1n

* CHECK dout0_14 Vdout0_14ck148 = 0 time = 2980
.meas tran vdout0_14ck148 FIND v(dout0_14) AT=2980.1n

* CHECK dout0_15 Vdout0_15ck148 = 1.8 time = 2980
.meas tran vdout0_15ck148 FIND v(dout0_15) AT=2980.1n

* CHECK dout0_0 Vdout0_0ck149 = 0 time = 3000
.meas tran vdout0_0ck149 FIND v(dout0_0) AT=3000.1n

* CHECK dout0_1 Vdout0_1ck149 = 0 time = 3000
.meas tran vdout0_1ck149 FIND v(dout0_1) AT=3000.1n

* CHECK dout0_2 Vdout0_2ck149 = 1.8 time = 3000
.meas tran vdout0_2ck149 FIND v(dout0_2) AT=3000.1n

* CHECK dout0_3 Vdout0_3ck149 = 0 time = 3000
.meas tran vdout0_3ck149 FIND v(dout0_3) AT=3000.1n

* CHECK dout0_4 Vdout0_4ck149 = 1.8 time = 3000
.meas tran vdout0_4ck149 FIND v(dout0_4) AT=3000.1n

* CHECK dout0_5 Vdout0_5ck149 = 1.8 time = 3000
.meas tran vdout0_5ck149 FIND v(dout0_5) AT=3000.1n

* CHECK dout0_6 Vdout0_6ck149 = 0 time = 3000
.meas tran vdout0_6ck149 FIND v(dout0_6) AT=3000.1n

* CHECK dout0_7 Vdout0_7ck149 = 1.8 time = 3000
.meas tran vdout0_7ck149 FIND v(dout0_7) AT=3000.1n

* CHECK dout0_8 Vdout0_8ck149 = 0 time = 3000
.meas tran vdout0_8ck149 FIND v(dout0_8) AT=3000.1n

* CHECK dout0_9 Vdout0_9ck149 = 1.8 time = 3000
.meas tran vdout0_9ck149 FIND v(dout0_9) AT=3000.1n

* CHECK dout0_10 Vdout0_10ck149 = 1.8 time = 3000
.meas tran vdout0_10ck149 FIND v(dout0_10) AT=3000.1n

* CHECK dout0_11 Vdout0_11ck149 = 0 time = 3000
.meas tran vdout0_11ck149 FIND v(dout0_11) AT=3000.1n

* CHECK dout0_12 Vdout0_12ck149 = 0 time = 3000
.meas tran vdout0_12ck149 FIND v(dout0_12) AT=3000.1n

* CHECK dout0_13 Vdout0_13ck149 = 0 time = 3000
.meas tran vdout0_13ck149 FIND v(dout0_13) AT=3000.1n

* CHECK dout0_14 Vdout0_14ck149 = 0 time = 3000
.meas tran vdout0_14ck149 FIND v(dout0_14) AT=3000.1n

* CHECK dout0_15 Vdout0_15ck149 = 1.8 time = 3000
.meas tran vdout0_15ck149 FIND v(dout0_15) AT=3000.1n

* CHECK dout0_0 Vdout0_0ck152 = 0 time = 3060
.meas tran vdout0_0ck152 FIND v(dout0_0) AT=3060.1n

* CHECK dout0_1 Vdout0_1ck152 = 0 time = 3060
.meas tran vdout0_1ck152 FIND v(dout0_1) AT=3060.1n

* CHECK dout0_2 Vdout0_2ck152 = 1.8 time = 3060
.meas tran vdout0_2ck152 FIND v(dout0_2) AT=3060.1n

* CHECK dout0_3 Vdout0_3ck152 = 0 time = 3060
.meas tran vdout0_3ck152 FIND v(dout0_3) AT=3060.1n

* CHECK dout0_4 Vdout0_4ck152 = 0 time = 3060
.meas tran vdout0_4ck152 FIND v(dout0_4) AT=3060.1n

* CHECK dout0_5 Vdout0_5ck152 = 1.8 time = 3060
.meas tran vdout0_5ck152 FIND v(dout0_5) AT=3060.1n

* CHECK dout0_6 Vdout0_6ck152 = 0 time = 3060
.meas tran vdout0_6ck152 FIND v(dout0_6) AT=3060.1n

* CHECK dout0_7 Vdout0_7ck152 = 1.8 time = 3060
.meas tran vdout0_7ck152 FIND v(dout0_7) AT=3060.1n

* CHECK dout0_8 Vdout0_8ck152 = 0 time = 3060
.meas tran vdout0_8ck152 FIND v(dout0_8) AT=3060.1n

* CHECK dout0_9 Vdout0_9ck152 = 0 time = 3060
.meas tran vdout0_9ck152 FIND v(dout0_9) AT=3060.1n

* CHECK dout0_10 Vdout0_10ck152 = 1.8 time = 3060
.meas tran vdout0_10ck152 FIND v(dout0_10) AT=3060.1n

* CHECK dout0_11 Vdout0_11ck152 = 1.8 time = 3060
.meas tran vdout0_11ck152 FIND v(dout0_11) AT=3060.1n

* CHECK dout0_12 Vdout0_12ck152 = 0 time = 3060
.meas tran vdout0_12ck152 FIND v(dout0_12) AT=3060.1n

* CHECK dout0_13 Vdout0_13ck152 = 1.8 time = 3060
.meas tran vdout0_13ck152 FIND v(dout0_13) AT=3060.1n

* CHECK dout0_14 Vdout0_14ck152 = 0 time = 3060
.meas tran vdout0_14ck152 FIND v(dout0_14) AT=3060.1n

* CHECK dout0_15 Vdout0_15ck152 = 0 time = 3060
.meas tran vdout0_15ck152 FIND v(dout0_15) AT=3060.1n

* CHECK dout0_0 Vdout0_0ck153 = 0 time = 3080
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=3080.1n

* CHECK dout0_1 Vdout0_1ck153 = 0 time = 3080
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=3080.1n

* CHECK dout0_2 Vdout0_2ck153 = 1.8 time = 3080
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=3080.1n

* CHECK dout0_3 Vdout0_3ck153 = 0 time = 3080
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=3080.1n

* CHECK dout0_4 Vdout0_4ck153 = 0 time = 3080
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=3080.1n

* CHECK dout0_5 Vdout0_5ck153 = 1.8 time = 3080
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=3080.1n

* CHECK dout0_6 Vdout0_6ck153 = 0 time = 3080
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=3080.1n

* CHECK dout0_7 Vdout0_7ck153 = 1.8 time = 3080
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=3080.1n

* CHECK dout0_8 Vdout0_8ck153 = 0 time = 3080
.meas tran vdout0_8ck153 FIND v(dout0_8) AT=3080.1n

* CHECK dout0_9 Vdout0_9ck153 = 0 time = 3080
.meas tran vdout0_9ck153 FIND v(dout0_9) AT=3080.1n

* CHECK dout0_10 Vdout0_10ck153 = 1.8 time = 3080
.meas tran vdout0_10ck153 FIND v(dout0_10) AT=3080.1n

* CHECK dout0_11 Vdout0_11ck153 = 1.8 time = 3080
.meas tran vdout0_11ck153 FIND v(dout0_11) AT=3080.1n

* CHECK dout0_12 Vdout0_12ck153 = 0 time = 3080
.meas tran vdout0_12ck153 FIND v(dout0_12) AT=3080.1n

* CHECK dout0_13 Vdout0_13ck153 = 1.8 time = 3080
.meas tran vdout0_13ck153 FIND v(dout0_13) AT=3080.1n

* CHECK dout0_14 Vdout0_14ck153 = 0 time = 3080
.meas tran vdout0_14ck153 FIND v(dout0_14) AT=3080.1n

* CHECK dout0_15 Vdout0_15ck153 = 0 time = 3080
.meas tran vdout0_15ck153 FIND v(dout0_15) AT=3080.1n

* CHECK dout0_0 Vdout0_0ck158 = 0 time = 3180
.meas tran vdout0_0ck158 FIND v(dout0_0) AT=3180.1n

* CHECK dout0_1 Vdout0_1ck158 = 0 time = 3180
.meas tran vdout0_1ck158 FIND v(dout0_1) AT=3180.1n

* CHECK dout0_2 Vdout0_2ck158 = 1.8 time = 3180
.meas tran vdout0_2ck158 FIND v(dout0_2) AT=3180.1n

* CHECK dout0_3 Vdout0_3ck158 = 0 time = 3180
.meas tran vdout0_3ck158 FIND v(dout0_3) AT=3180.1n

* CHECK dout0_4 Vdout0_4ck158 = 0 time = 3180
.meas tran vdout0_4ck158 FIND v(dout0_4) AT=3180.1n

* CHECK dout0_5 Vdout0_5ck158 = 1.8 time = 3180
.meas tran vdout0_5ck158 FIND v(dout0_5) AT=3180.1n

* CHECK dout0_6 Vdout0_6ck158 = 0 time = 3180
.meas tran vdout0_6ck158 FIND v(dout0_6) AT=3180.1n

* CHECK dout0_7 Vdout0_7ck158 = 1.8 time = 3180
.meas tran vdout0_7ck158 FIND v(dout0_7) AT=3180.1n

* CHECK dout0_8 Vdout0_8ck158 = 0 time = 3180
.meas tran vdout0_8ck158 FIND v(dout0_8) AT=3180.1n

* CHECK dout0_9 Vdout0_9ck158 = 0 time = 3180
.meas tran vdout0_9ck158 FIND v(dout0_9) AT=3180.1n

* CHECK dout0_10 Vdout0_10ck158 = 1.8 time = 3180
.meas tran vdout0_10ck158 FIND v(dout0_10) AT=3180.1n

* CHECK dout0_11 Vdout0_11ck158 = 1.8 time = 3180
.meas tran vdout0_11ck158 FIND v(dout0_11) AT=3180.1n

* CHECK dout0_12 Vdout0_12ck158 = 0 time = 3180
.meas tran vdout0_12ck158 FIND v(dout0_12) AT=3180.1n

* CHECK dout0_13 Vdout0_13ck158 = 1.8 time = 3180
.meas tran vdout0_13ck158 FIND v(dout0_13) AT=3180.1n

* CHECK dout0_14 Vdout0_14ck158 = 0 time = 3180
.meas tran vdout0_14ck158 FIND v(dout0_14) AT=3180.1n

* CHECK dout0_15 Vdout0_15ck158 = 0 time = 3180
.meas tran vdout0_15ck158 FIND v(dout0_15) AT=3180.1n

* CHECK dout0_0 Vdout0_0ck160 = 0 time = 3220
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=3220.1n

* CHECK dout0_1 Vdout0_1ck160 = 0 time = 3220
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=3220.1n

* CHECK dout0_2 Vdout0_2ck160 = 1.8 time = 3220
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=3220.1n

* CHECK dout0_3 Vdout0_3ck160 = 0 time = 3220
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=3220.1n

* CHECK dout0_4 Vdout0_4ck160 = 0 time = 3220
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=3220.1n

* CHECK dout0_5 Vdout0_5ck160 = 1.8 time = 3220
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=3220.1n

* CHECK dout0_6 Vdout0_6ck160 = 0 time = 3220
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=3220.1n

* CHECK dout0_7 Vdout0_7ck160 = 1.8 time = 3220
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=3220.1n

* CHECK dout0_8 Vdout0_8ck160 = 0 time = 3220
.meas tran vdout0_8ck160 FIND v(dout0_8) AT=3220.1n

* CHECK dout0_9 Vdout0_9ck160 = 0 time = 3220
.meas tran vdout0_9ck160 FIND v(dout0_9) AT=3220.1n

* CHECK dout0_10 Vdout0_10ck160 = 1.8 time = 3220
.meas tran vdout0_10ck160 FIND v(dout0_10) AT=3220.1n

* CHECK dout0_11 Vdout0_11ck160 = 1.8 time = 3220
.meas tran vdout0_11ck160 FIND v(dout0_11) AT=3220.1n

* CHECK dout0_12 Vdout0_12ck160 = 0 time = 3220
.meas tran vdout0_12ck160 FIND v(dout0_12) AT=3220.1n

* CHECK dout0_13 Vdout0_13ck160 = 1.8 time = 3220
.meas tran vdout0_13ck160 FIND v(dout0_13) AT=3220.1n

* CHECK dout0_14 Vdout0_14ck160 = 0 time = 3220
.meas tran vdout0_14ck160 FIND v(dout0_14) AT=3220.1n

* CHECK dout0_15 Vdout0_15ck160 = 0 time = 3220
.meas tran vdout0_15ck160 FIND v(dout0_15) AT=3220.1n

* CHECK dout0_0 Vdout0_0ck161 = 1.8 time = 3240
.meas tran vdout0_0ck161 FIND v(dout0_0) AT=3240.1n

* CHECK dout0_1 Vdout0_1ck161 = 1.8 time = 3240
.meas tran vdout0_1ck161 FIND v(dout0_1) AT=3240.1n

* CHECK dout0_2 Vdout0_2ck161 = 0 time = 3240
.meas tran vdout0_2ck161 FIND v(dout0_2) AT=3240.1n

* CHECK dout0_3 Vdout0_3ck161 = 0 time = 3240
.meas tran vdout0_3ck161 FIND v(dout0_3) AT=3240.1n

* CHECK dout0_4 Vdout0_4ck161 = 0 time = 3240
.meas tran vdout0_4ck161 FIND v(dout0_4) AT=3240.1n

* CHECK dout0_5 Vdout0_5ck161 = 1.8 time = 3240
.meas tran vdout0_5ck161 FIND v(dout0_5) AT=3240.1n

* CHECK dout0_6 Vdout0_6ck161 = 0 time = 3240
.meas tran vdout0_6ck161 FIND v(dout0_6) AT=3240.1n

* CHECK dout0_7 Vdout0_7ck161 = 0 time = 3240
.meas tran vdout0_7ck161 FIND v(dout0_7) AT=3240.1n

* CHECK dout0_8 Vdout0_8ck161 = 0 time = 3240
.meas tran vdout0_8ck161 FIND v(dout0_8) AT=3240.1n

* CHECK dout0_9 Vdout0_9ck161 = 1.8 time = 3240
.meas tran vdout0_9ck161 FIND v(dout0_9) AT=3240.1n

* CHECK dout0_10 Vdout0_10ck161 = 0 time = 3240
.meas tran vdout0_10ck161 FIND v(dout0_10) AT=3240.1n

* CHECK dout0_11 Vdout0_11ck161 = 0 time = 3240
.meas tran vdout0_11ck161 FIND v(dout0_11) AT=3240.1n

* CHECK dout0_12 Vdout0_12ck161 = 0 time = 3240
.meas tran vdout0_12ck161 FIND v(dout0_12) AT=3240.1n

* CHECK dout0_13 Vdout0_13ck161 = 1.8 time = 3240
.meas tran vdout0_13ck161 FIND v(dout0_13) AT=3240.1n

* CHECK dout0_14 Vdout0_14ck161 = 1.8 time = 3240
.meas tran vdout0_14ck161 FIND v(dout0_14) AT=3240.1n

* CHECK dout0_15 Vdout0_15ck161 = 0 time = 3240
.meas tran vdout0_15ck161 FIND v(dout0_15) AT=3240.1n

* CHECK dout0_0 Vdout0_0ck162 = 1.8 time = 3260
.meas tran vdout0_0ck162 FIND v(dout0_0) AT=3260.1n

* CHECK dout0_1 Vdout0_1ck162 = 1.8 time = 3260
.meas tran vdout0_1ck162 FIND v(dout0_1) AT=3260.1n

* CHECK dout0_2 Vdout0_2ck162 = 0 time = 3260
.meas tran vdout0_2ck162 FIND v(dout0_2) AT=3260.1n

* CHECK dout0_3 Vdout0_3ck162 = 0 time = 3260
.meas tran vdout0_3ck162 FIND v(dout0_3) AT=3260.1n

* CHECK dout0_4 Vdout0_4ck162 = 0 time = 3260
.meas tran vdout0_4ck162 FIND v(dout0_4) AT=3260.1n

* CHECK dout0_5 Vdout0_5ck162 = 1.8 time = 3260
.meas tran vdout0_5ck162 FIND v(dout0_5) AT=3260.1n

* CHECK dout0_6 Vdout0_6ck162 = 0 time = 3260
.meas tran vdout0_6ck162 FIND v(dout0_6) AT=3260.1n

* CHECK dout0_7 Vdout0_7ck162 = 0 time = 3260
.meas tran vdout0_7ck162 FIND v(dout0_7) AT=3260.1n

* CHECK dout0_8 Vdout0_8ck162 = 0 time = 3260
.meas tran vdout0_8ck162 FIND v(dout0_8) AT=3260.1n

* CHECK dout0_9 Vdout0_9ck162 = 1.8 time = 3260
.meas tran vdout0_9ck162 FIND v(dout0_9) AT=3260.1n

* CHECK dout0_10 Vdout0_10ck162 = 0 time = 3260
.meas tran vdout0_10ck162 FIND v(dout0_10) AT=3260.1n

* CHECK dout0_11 Vdout0_11ck162 = 0 time = 3260
.meas tran vdout0_11ck162 FIND v(dout0_11) AT=3260.1n

* CHECK dout0_12 Vdout0_12ck162 = 0 time = 3260
.meas tran vdout0_12ck162 FIND v(dout0_12) AT=3260.1n

* CHECK dout0_13 Vdout0_13ck162 = 1.8 time = 3260
.meas tran vdout0_13ck162 FIND v(dout0_13) AT=3260.1n

* CHECK dout0_14 Vdout0_14ck162 = 1.8 time = 3260
.meas tran vdout0_14ck162 FIND v(dout0_14) AT=3260.1n

* CHECK dout0_15 Vdout0_15ck162 = 0 time = 3260
.meas tran vdout0_15ck162 FIND v(dout0_15) AT=3260.1n

* CHECK dout0_0 Vdout0_0ck166 = 0 time = 3340
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=3340.1n

* CHECK dout0_1 Vdout0_1ck166 = 1.8 time = 3340
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=3340.1n

* CHECK dout0_2 Vdout0_2ck166 = 1.8 time = 3340
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=3340.1n

* CHECK dout0_3 Vdout0_3ck166 = 1.8 time = 3340
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=3340.1n

* CHECK dout0_4 Vdout0_4ck166 = 0 time = 3340
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=3340.1n

* CHECK dout0_5 Vdout0_5ck166 = 0 time = 3340
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=3340.1n

* CHECK dout0_6 Vdout0_6ck166 = 0 time = 3340
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=3340.1n

* CHECK dout0_7 Vdout0_7ck166 = 0 time = 3340
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=3340.1n

* CHECK dout0_8 Vdout0_8ck166 = 1.8 time = 3340
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=3340.1n

* CHECK dout0_9 Vdout0_9ck166 = 1.8 time = 3340
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=3340.1n

* CHECK dout0_10 Vdout0_10ck166 = 0 time = 3340
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=3340.1n

* CHECK dout0_11 Vdout0_11ck166 = 0 time = 3340
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=3340.1n

* CHECK dout0_12 Vdout0_12ck166 = 0 time = 3340
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=3340.1n

* CHECK dout0_13 Vdout0_13ck166 = 1.8 time = 3340
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=3340.1n

* CHECK dout0_14 Vdout0_14ck166 = 0 time = 3340
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=3340.1n

* CHECK dout0_15 Vdout0_15ck166 = 0 time = 3340
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=3340.1n

* CHECK dout0_0 Vdout0_0ck168 = 0 time = 3380
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=3380.1n

* CHECK dout0_1 Vdout0_1ck168 = 0 time = 3380
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=3380.1n

* CHECK dout0_2 Vdout0_2ck168 = 1.8 time = 3380
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=3380.1n

* CHECK dout0_3 Vdout0_3ck168 = 0 time = 3380
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=3380.1n

* CHECK dout0_4 Vdout0_4ck168 = 0 time = 3380
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=3380.1n

* CHECK dout0_5 Vdout0_5ck168 = 1.8 time = 3380
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=3380.1n

* CHECK dout0_6 Vdout0_6ck168 = 0 time = 3380
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=3380.1n

* CHECK dout0_7 Vdout0_7ck168 = 1.8 time = 3380
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=3380.1n

* CHECK dout0_8 Vdout0_8ck168 = 0 time = 3380
.meas tran vdout0_8ck168 FIND v(dout0_8) AT=3380.1n

* CHECK dout0_9 Vdout0_9ck168 = 0 time = 3380
.meas tran vdout0_9ck168 FIND v(dout0_9) AT=3380.1n

* CHECK dout0_10 Vdout0_10ck168 = 1.8 time = 3380
.meas tran vdout0_10ck168 FIND v(dout0_10) AT=3380.1n

* CHECK dout0_11 Vdout0_11ck168 = 1.8 time = 3380
.meas tran vdout0_11ck168 FIND v(dout0_11) AT=3380.1n

* CHECK dout0_12 Vdout0_12ck168 = 0 time = 3380
.meas tran vdout0_12ck168 FIND v(dout0_12) AT=3380.1n

* CHECK dout0_13 Vdout0_13ck168 = 1.8 time = 3380
.meas tran vdout0_13ck168 FIND v(dout0_13) AT=3380.1n

* CHECK dout0_14 Vdout0_14ck168 = 0 time = 3380
.meas tran vdout0_14ck168 FIND v(dout0_14) AT=3380.1n

* CHECK dout0_15 Vdout0_15ck168 = 0 time = 3380
.meas tran vdout0_15ck168 FIND v(dout0_15) AT=3380.1n

* CHECK dout0_0 Vdout0_0ck169 = 0 time = 3400
.meas tran vdout0_0ck169 FIND v(dout0_0) AT=3400.1n

* CHECK dout0_1 Vdout0_1ck169 = 1.8 time = 3400
.meas tran vdout0_1ck169 FIND v(dout0_1) AT=3400.1n

* CHECK dout0_2 Vdout0_2ck169 = 0 time = 3400
.meas tran vdout0_2ck169 FIND v(dout0_2) AT=3400.1n

* CHECK dout0_3 Vdout0_3ck169 = 1.8 time = 3400
.meas tran vdout0_3ck169 FIND v(dout0_3) AT=3400.1n

* CHECK dout0_4 Vdout0_4ck169 = 0 time = 3400
.meas tran vdout0_4ck169 FIND v(dout0_4) AT=3400.1n

* CHECK dout0_5 Vdout0_5ck169 = 1.8 time = 3400
.meas tran vdout0_5ck169 FIND v(dout0_5) AT=3400.1n

* CHECK dout0_6 Vdout0_6ck169 = 1.8 time = 3400
.meas tran vdout0_6ck169 FIND v(dout0_6) AT=3400.1n

* CHECK dout0_7 Vdout0_7ck169 = 0 time = 3400
.meas tran vdout0_7ck169 FIND v(dout0_7) AT=3400.1n

* CHECK dout0_8 Vdout0_8ck169 = 0 time = 3400
.meas tran vdout0_8ck169 FIND v(dout0_8) AT=3400.1n

* CHECK dout0_9 Vdout0_9ck169 = 0 time = 3400
.meas tran vdout0_9ck169 FIND v(dout0_9) AT=3400.1n

* CHECK dout0_10 Vdout0_10ck169 = 0 time = 3400
.meas tran vdout0_10ck169 FIND v(dout0_10) AT=3400.1n

* CHECK dout0_11 Vdout0_11ck169 = 1.8 time = 3400
.meas tran vdout0_11ck169 FIND v(dout0_11) AT=3400.1n

* CHECK dout0_12 Vdout0_12ck169 = 0 time = 3400
.meas tran vdout0_12ck169 FIND v(dout0_12) AT=3400.1n

* CHECK dout0_13 Vdout0_13ck169 = 0 time = 3400
.meas tran vdout0_13ck169 FIND v(dout0_13) AT=3400.1n

* CHECK dout0_14 Vdout0_14ck169 = 0 time = 3400
.meas tran vdout0_14ck169 FIND v(dout0_14) AT=3400.1n

* CHECK dout0_15 Vdout0_15ck169 = 1.8 time = 3400
.meas tran vdout0_15ck169 FIND v(dout0_15) AT=3400.1n

* CHECK dout0_0 Vdout0_0ck172 = 0 time = 3460
.meas tran vdout0_0ck172 FIND v(dout0_0) AT=3460.1n

* CHECK dout0_1 Vdout0_1ck172 = 0 time = 3460
.meas tran vdout0_1ck172 FIND v(dout0_1) AT=3460.1n

* CHECK dout0_2 Vdout0_2ck172 = 1.8 time = 3460
.meas tran vdout0_2ck172 FIND v(dout0_2) AT=3460.1n

* CHECK dout0_3 Vdout0_3ck172 = 0 time = 3460
.meas tran vdout0_3ck172 FIND v(dout0_3) AT=3460.1n

* CHECK dout0_4 Vdout0_4ck172 = 0 time = 3460
.meas tran vdout0_4ck172 FIND v(dout0_4) AT=3460.1n

* CHECK dout0_5 Vdout0_5ck172 = 1.8 time = 3460
.meas tran vdout0_5ck172 FIND v(dout0_5) AT=3460.1n

* CHECK dout0_6 Vdout0_6ck172 = 1.8 time = 3460
.meas tran vdout0_6ck172 FIND v(dout0_6) AT=3460.1n

* CHECK dout0_7 Vdout0_7ck172 = 0 time = 3460
.meas tran vdout0_7ck172 FIND v(dout0_7) AT=3460.1n

* CHECK dout0_8 Vdout0_8ck172 = 0 time = 3460
.meas tran vdout0_8ck172 FIND v(dout0_8) AT=3460.1n

* CHECK dout0_9 Vdout0_9ck172 = 0 time = 3460
.meas tran vdout0_9ck172 FIND v(dout0_9) AT=3460.1n

* CHECK dout0_10 Vdout0_10ck172 = 0 time = 3460
.meas tran vdout0_10ck172 FIND v(dout0_10) AT=3460.1n

* CHECK dout0_11 Vdout0_11ck172 = 0 time = 3460
.meas tran vdout0_11ck172 FIND v(dout0_11) AT=3460.1n

* CHECK dout0_12 Vdout0_12ck172 = 1.8 time = 3460
.meas tran vdout0_12ck172 FIND v(dout0_12) AT=3460.1n

* CHECK dout0_13 Vdout0_13ck172 = 1.8 time = 3460
.meas tran vdout0_13ck172 FIND v(dout0_13) AT=3460.1n

* CHECK dout0_14 Vdout0_14ck172 = 0 time = 3460
.meas tran vdout0_14ck172 FIND v(dout0_14) AT=3460.1n

* CHECK dout0_15 Vdout0_15ck172 = 1.8 time = 3460
.meas tran vdout0_15ck172 FIND v(dout0_15) AT=3460.1n

* CHECK dout0_0 Vdout0_0ck175 = 0 time = 3520
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=3520.1n

* CHECK dout0_1 Vdout0_1ck175 = 1.8 time = 3520
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=3520.1n

* CHECK dout0_2 Vdout0_2ck175 = 0 time = 3520
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=3520.1n

* CHECK dout0_3 Vdout0_3ck175 = 1.8 time = 3520
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=3520.1n

* CHECK dout0_4 Vdout0_4ck175 = 0 time = 3520
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=3520.1n

* CHECK dout0_5 Vdout0_5ck175 = 1.8 time = 3520
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=3520.1n

* CHECK dout0_6 Vdout0_6ck175 = 1.8 time = 3520
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=3520.1n

* CHECK dout0_7 Vdout0_7ck175 = 0 time = 3520
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=3520.1n

* CHECK dout0_8 Vdout0_8ck175 = 0 time = 3520
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=3520.1n

* CHECK dout0_9 Vdout0_9ck175 = 0 time = 3520
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=3520.1n

* CHECK dout0_10 Vdout0_10ck175 = 0 time = 3520
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=3520.1n

* CHECK dout0_11 Vdout0_11ck175 = 1.8 time = 3520
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=3520.1n

* CHECK dout0_12 Vdout0_12ck175 = 0 time = 3520
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=3520.1n

* CHECK dout0_13 Vdout0_13ck175 = 0 time = 3520
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=3520.1n

* CHECK dout0_14 Vdout0_14ck175 = 0 time = 3520
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=3520.1n

* CHECK dout0_15 Vdout0_15ck175 = 1.8 time = 3520
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=3520.1n

* CHECK dout0_0 Vdout0_0ck176 = 1.8 time = 3540
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=3540.1n

* CHECK dout0_1 Vdout0_1ck176 = 1.8 time = 3540
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=3540.1n

* CHECK dout0_2 Vdout0_2ck176 = 0 time = 3540
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=3540.1n

* CHECK dout0_3 Vdout0_3ck176 = 0 time = 3540
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=3540.1n

* CHECK dout0_4 Vdout0_4ck176 = 0 time = 3540
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=3540.1n

* CHECK dout0_5 Vdout0_5ck176 = 1.8 time = 3540
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=3540.1n

* CHECK dout0_6 Vdout0_6ck176 = 0 time = 3540
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=3540.1n

* CHECK dout0_7 Vdout0_7ck176 = 0 time = 3540
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=3540.1n

* CHECK dout0_8 Vdout0_8ck176 = 0 time = 3540
.meas tran vdout0_8ck176 FIND v(dout0_8) AT=3540.1n

* CHECK dout0_9 Vdout0_9ck176 = 1.8 time = 3540
.meas tran vdout0_9ck176 FIND v(dout0_9) AT=3540.1n

* CHECK dout0_10 Vdout0_10ck176 = 0 time = 3540
.meas tran vdout0_10ck176 FIND v(dout0_10) AT=3540.1n

* CHECK dout0_11 Vdout0_11ck176 = 0 time = 3540
.meas tran vdout0_11ck176 FIND v(dout0_11) AT=3540.1n

* CHECK dout0_12 Vdout0_12ck176 = 0 time = 3540
.meas tran vdout0_12ck176 FIND v(dout0_12) AT=3540.1n

* CHECK dout0_13 Vdout0_13ck176 = 1.8 time = 3540
.meas tran vdout0_13ck176 FIND v(dout0_13) AT=3540.1n

* CHECK dout0_14 Vdout0_14ck176 = 1.8 time = 3540
.meas tran vdout0_14ck176 FIND v(dout0_14) AT=3540.1n

* CHECK dout0_15 Vdout0_15ck176 = 0 time = 3540
.meas tran vdout0_15ck176 FIND v(dout0_15) AT=3540.1n

* CHECK dout0_0 Vdout0_0ck178 = 0 time = 3580
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=3580.1n

* CHECK dout0_1 Vdout0_1ck178 = 0 time = 3580
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=3580.1n

* CHECK dout0_2 Vdout0_2ck178 = 1.8 time = 3580
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=3580.1n

* CHECK dout0_3 Vdout0_3ck178 = 0 time = 3580
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=3580.1n

* CHECK dout0_4 Vdout0_4ck178 = 1.8 time = 3580
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=3580.1n

* CHECK dout0_5 Vdout0_5ck178 = 1.8 time = 3580
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=3580.1n

* CHECK dout0_6 Vdout0_6ck178 = 0 time = 3580
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=3580.1n

* CHECK dout0_7 Vdout0_7ck178 = 1.8 time = 3580
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=3580.1n

* CHECK dout0_8 Vdout0_8ck178 = 0 time = 3580
.meas tran vdout0_8ck178 FIND v(dout0_8) AT=3580.1n

* CHECK dout0_9 Vdout0_9ck178 = 1.8 time = 3580
.meas tran vdout0_9ck178 FIND v(dout0_9) AT=3580.1n

* CHECK dout0_10 Vdout0_10ck178 = 1.8 time = 3580
.meas tran vdout0_10ck178 FIND v(dout0_10) AT=3580.1n

* CHECK dout0_11 Vdout0_11ck178 = 0 time = 3580
.meas tran vdout0_11ck178 FIND v(dout0_11) AT=3580.1n

* CHECK dout0_12 Vdout0_12ck178 = 0 time = 3580
.meas tran vdout0_12ck178 FIND v(dout0_12) AT=3580.1n

* CHECK dout0_13 Vdout0_13ck178 = 0 time = 3580
.meas tran vdout0_13ck178 FIND v(dout0_13) AT=3580.1n

* CHECK dout0_14 Vdout0_14ck178 = 0 time = 3580
.meas tran vdout0_14ck178 FIND v(dout0_14) AT=3580.1n

* CHECK dout0_15 Vdout0_15ck178 = 1.8 time = 3580
.meas tran vdout0_15ck178 FIND v(dout0_15) AT=3580.1n

* CHECK dout0_0 Vdout0_0ck180 = 0 time = 3620
.meas tran vdout0_0ck180 FIND v(dout0_0) AT=3620.1n

* CHECK dout0_1 Vdout0_1ck180 = 0 time = 3620
.meas tran vdout0_1ck180 FIND v(dout0_1) AT=3620.1n

* CHECK dout0_2 Vdout0_2ck180 = 0 time = 3620
.meas tran vdout0_2ck180 FIND v(dout0_2) AT=3620.1n

* CHECK dout0_3 Vdout0_3ck180 = 1.8 time = 3620
.meas tran vdout0_3ck180 FIND v(dout0_3) AT=3620.1n

* CHECK dout0_4 Vdout0_4ck180 = 1.8 time = 3620
.meas tran vdout0_4ck180 FIND v(dout0_4) AT=3620.1n

* CHECK dout0_5 Vdout0_5ck180 = 0 time = 3620
.meas tran vdout0_5ck180 FIND v(dout0_5) AT=3620.1n

* CHECK dout0_6 Vdout0_6ck180 = 1.8 time = 3620
.meas tran vdout0_6ck180 FIND v(dout0_6) AT=3620.1n

* CHECK dout0_7 Vdout0_7ck180 = 1.8 time = 3620
.meas tran vdout0_7ck180 FIND v(dout0_7) AT=3620.1n

* CHECK dout0_8 Vdout0_8ck180 = 0 time = 3620
.meas tran vdout0_8ck180 FIND v(dout0_8) AT=3620.1n

* CHECK dout0_9 Vdout0_9ck180 = 1.8 time = 3620
.meas tran vdout0_9ck180 FIND v(dout0_9) AT=3620.1n

* CHECK dout0_10 Vdout0_10ck180 = 1.8 time = 3620
.meas tran vdout0_10ck180 FIND v(dout0_10) AT=3620.1n

* CHECK dout0_11 Vdout0_11ck180 = 1.8 time = 3620
.meas tran vdout0_11ck180 FIND v(dout0_11) AT=3620.1n

* CHECK dout0_12 Vdout0_12ck180 = 0 time = 3620
.meas tran vdout0_12ck180 FIND v(dout0_12) AT=3620.1n

* CHECK dout0_13 Vdout0_13ck180 = 0 time = 3620
.meas tran vdout0_13ck180 FIND v(dout0_13) AT=3620.1n

* CHECK dout0_14 Vdout0_14ck180 = 0 time = 3620
.meas tran vdout0_14ck180 FIND v(dout0_14) AT=3620.1n

* CHECK dout0_15 Vdout0_15ck180 = 0 time = 3620
.meas tran vdout0_15ck180 FIND v(dout0_15) AT=3620.1n

* CHECK dout0_0 Vdout0_0ck181 = 0 time = 3640
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=3640.1n

* CHECK dout0_1 Vdout0_1ck181 = 1.8 time = 3640
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=3640.1n

* CHECK dout0_2 Vdout0_2ck181 = 1.8 time = 3640
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=3640.1n

* CHECK dout0_3 Vdout0_3ck181 = 0 time = 3640
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=3640.1n

* CHECK dout0_4 Vdout0_4ck181 = 0 time = 3640
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=3640.1n

* CHECK dout0_5 Vdout0_5ck181 = 1.8 time = 3640
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=3640.1n

* CHECK dout0_6 Vdout0_6ck181 = 0 time = 3640
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=3640.1n

* CHECK dout0_7 Vdout0_7ck181 = 1.8 time = 3640
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=3640.1n

* CHECK dout0_8 Vdout0_8ck181 = 1.8 time = 3640
.meas tran vdout0_8ck181 FIND v(dout0_8) AT=3640.1n

* CHECK dout0_9 Vdout0_9ck181 = 0 time = 3640
.meas tran vdout0_9ck181 FIND v(dout0_9) AT=3640.1n

* CHECK dout0_10 Vdout0_10ck181 = 0 time = 3640
.meas tran vdout0_10ck181 FIND v(dout0_10) AT=3640.1n

* CHECK dout0_11 Vdout0_11ck181 = 0 time = 3640
.meas tran vdout0_11ck181 FIND v(dout0_11) AT=3640.1n

* CHECK dout0_12 Vdout0_12ck181 = 1.8 time = 3640
.meas tran vdout0_12ck181 FIND v(dout0_12) AT=3640.1n

* CHECK dout0_13 Vdout0_13ck181 = 0 time = 3640
.meas tran vdout0_13ck181 FIND v(dout0_13) AT=3640.1n

* CHECK dout0_14 Vdout0_14ck181 = 0 time = 3640
.meas tran vdout0_14ck181 FIND v(dout0_14) AT=3640.1n

* CHECK dout0_15 Vdout0_15ck181 = 0 time = 3640
.meas tran vdout0_15ck181 FIND v(dout0_15) AT=3640.1n

* CHECK dout0_0 Vdout0_0ck183 = 0 time = 3680
.meas tran vdout0_0ck183 FIND v(dout0_0) AT=3680.1n

* CHECK dout0_1 Vdout0_1ck183 = 0 time = 3680
.meas tran vdout0_1ck183 FIND v(dout0_1) AT=3680.1n

* CHECK dout0_2 Vdout0_2ck183 = 0 time = 3680
.meas tran vdout0_2ck183 FIND v(dout0_2) AT=3680.1n

* CHECK dout0_3 Vdout0_3ck183 = 1.8 time = 3680
.meas tran vdout0_3ck183 FIND v(dout0_3) AT=3680.1n

* CHECK dout0_4 Vdout0_4ck183 = 1.8 time = 3680
.meas tran vdout0_4ck183 FIND v(dout0_4) AT=3680.1n

* CHECK dout0_5 Vdout0_5ck183 = 0 time = 3680
.meas tran vdout0_5ck183 FIND v(dout0_5) AT=3680.1n

* CHECK dout0_6 Vdout0_6ck183 = 1.8 time = 3680
.meas tran vdout0_6ck183 FIND v(dout0_6) AT=3680.1n

* CHECK dout0_7 Vdout0_7ck183 = 1.8 time = 3680
.meas tran vdout0_7ck183 FIND v(dout0_7) AT=3680.1n

* CHECK dout0_8 Vdout0_8ck183 = 0 time = 3680
.meas tran vdout0_8ck183 FIND v(dout0_8) AT=3680.1n

* CHECK dout0_9 Vdout0_9ck183 = 1.8 time = 3680
.meas tran vdout0_9ck183 FIND v(dout0_9) AT=3680.1n

* CHECK dout0_10 Vdout0_10ck183 = 1.8 time = 3680
.meas tran vdout0_10ck183 FIND v(dout0_10) AT=3680.1n

* CHECK dout0_11 Vdout0_11ck183 = 1.8 time = 3680
.meas tran vdout0_11ck183 FIND v(dout0_11) AT=3680.1n

* CHECK dout0_12 Vdout0_12ck183 = 0 time = 3680
.meas tran vdout0_12ck183 FIND v(dout0_12) AT=3680.1n

* CHECK dout0_13 Vdout0_13ck183 = 0 time = 3680
.meas tran vdout0_13ck183 FIND v(dout0_13) AT=3680.1n

* CHECK dout0_14 Vdout0_14ck183 = 0 time = 3680
.meas tran vdout0_14ck183 FIND v(dout0_14) AT=3680.1n

* CHECK dout0_15 Vdout0_15ck183 = 0 time = 3680
.meas tran vdout0_15ck183 FIND v(dout0_15) AT=3680.1n

* CHECK dout0_0 Vdout0_0ck184 = 0 time = 3700
.meas tran vdout0_0ck184 FIND v(dout0_0) AT=3700.1n

* CHECK dout0_1 Vdout0_1ck184 = 0 time = 3700
.meas tran vdout0_1ck184 FIND v(dout0_1) AT=3700.1n

* CHECK dout0_2 Vdout0_2ck184 = 1.8 time = 3700
.meas tran vdout0_2ck184 FIND v(dout0_2) AT=3700.1n

* CHECK dout0_3 Vdout0_3ck184 = 0 time = 3700
.meas tran vdout0_3ck184 FIND v(dout0_3) AT=3700.1n

* CHECK dout0_4 Vdout0_4ck184 = 0 time = 3700
.meas tran vdout0_4ck184 FIND v(dout0_4) AT=3700.1n

* CHECK dout0_5 Vdout0_5ck184 = 1.8 time = 3700
.meas tran vdout0_5ck184 FIND v(dout0_5) AT=3700.1n

* CHECK dout0_6 Vdout0_6ck184 = 1.8 time = 3700
.meas tran vdout0_6ck184 FIND v(dout0_6) AT=3700.1n

* CHECK dout0_7 Vdout0_7ck184 = 0 time = 3700
.meas tran vdout0_7ck184 FIND v(dout0_7) AT=3700.1n

* CHECK dout0_8 Vdout0_8ck184 = 0 time = 3700
.meas tran vdout0_8ck184 FIND v(dout0_8) AT=3700.1n

* CHECK dout0_9 Vdout0_9ck184 = 0 time = 3700
.meas tran vdout0_9ck184 FIND v(dout0_9) AT=3700.1n

* CHECK dout0_10 Vdout0_10ck184 = 0 time = 3700
.meas tran vdout0_10ck184 FIND v(dout0_10) AT=3700.1n

* CHECK dout0_11 Vdout0_11ck184 = 0 time = 3700
.meas tran vdout0_11ck184 FIND v(dout0_11) AT=3700.1n

* CHECK dout0_12 Vdout0_12ck184 = 1.8 time = 3700
.meas tran vdout0_12ck184 FIND v(dout0_12) AT=3700.1n

* CHECK dout0_13 Vdout0_13ck184 = 1.8 time = 3700
.meas tran vdout0_13ck184 FIND v(dout0_13) AT=3700.1n

* CHECK dout0_14 Vdout0_14ck184 = 0 time = 3700
.meas tran vdout0_14ck184 FIND v(dout0_14) AT=3700.1n

* CHECK dout0_15 Vdout0_15ck184 = 1.8 time = 3700
.meas tran vdout0_15ck184 FIND v(dout0_15) AT=3700.1n

* CHECK dout0_0 Vdout0_0ck185 = 0 time = 3720
.meas tran vdout0_0ck185 FIND v(dout0_0) AT=3720.1n

* CHECK dout0_1 Vdout0_1ck185 = 1.8 time = 3720
.meas tran vdout0_1ck185 FIND v(dout0_1) AT=3720.1n

* CHECK dout0_2 Vdout0_2ck185 = 1.8 time = 3720
.meas tran vdout0_2ck185 FIND v(dout0_2) AT=3720.1n

* CHECK dout0_3 Vdout0_3ck185 = 0 time = 3720
.meas tran vdout0_3ck185 FIND v(dout0_3) AT=3720.1n

* CHECK dout0_4 Vdout0_4ck185 = 0 time = 3720
.meas tran vdout0_4ck185 FIND v(dout0_4) AT=3720.1n

* CHECK dout0_5 Vdout0_5ck185 = 1.8 time = 3720
.meas tran vdout0_5ck185 FIND v(dout0_5) AT=3720.1n

* CHECK dout0_6 Vdout0_6ck185 = 0 time = 3720
.meas tran vdout0_6ck185 FIND v(dout0_6) AT=3720.1n

* CHECK dout0_7 Vdout0_7ck185 = 1.8 time = 3720
.meas tran vdout0_7ck185 FIND v(dout0_7) AT=3720.1n

* CHECK dout0_8 Vdout0_8ck185 = 1.8 time = 3720
.meas tran vdout0_8ck185 FIND v(dout0_8) AT=3720.1n

* CHECK dout0_9 Vdout0_9ck185 = 0 time = 3720
.meas tran vdout0_9ck185 FIND v(dout0_9) AT=3720.1n

* CHECK dout0_10 Vdout0_10ck185 = 0 time = 3720
.meas tran vdout0_10ck185 FIND v(dout0_10) AT=3720.1n

* CHECK dout0_11 Vdout0_11ck185 = 0 time = 3720
.meas tran vdout0_11ck185 FIND v(dout0_11) AT=3720.1n

* CHECK dout0_12 Vdout0_12ck185 = 1.8 time = 3720
.meas tran vdout0_12ck185 FIND v(dout0_12) AT=3720.1n

* CHECK dout0_13 Vdout0_13ck185 = 0 time = 3720
.meas tran vdout0_13ck185 FIND v(dout0_13) AT=3720.1n

* CHECK dout0_14 Vdout0_14ck185 = 0 time = 3720
.meas tran vdout0_14ck185 FIND v(dout0_14) AT=3720.1n

* CHECK dout0_15 Vdout0_15ck185 = 0 time = 3720
.meas tran vdout0_15ck185 FIND v(dout0_15) AT=3720.1n

* CHECK dout0_0 Vdout0_0ck186 = 0 time = 3740
.meas tran vdout0_0ck186 FIND v(dout0_0) AT=3740.1n

* CHECK dout0_1 Vdout0_1ck186 = 1.8 time = 3740
.meas tran vdout0_1ck186 FIND v(dout0_1) AT=3740.1n

* CHECK dout0_2 Vdout0_2ck186 = 1.8 time = 3740
.meas tran vdout0_2ck186 FIND v(dout0_2) AT=3740.1n

* CHECK dout0_3 Vdout0_3ck186 = 1.8 time = 3740
.meas tran vdout0_3ck186 FIND v(dout0_3) AT=3740.1n

* CHECK dout0_4 Vdout0_4ck186 = 0 time = 3740
.meas tran vdout0_4ck186 FIND v(dout0_4) AT=3740.1n

* CHECK dout0_5 Vdout0_5ck186 = 0 time = 3740
.meas tran vdout0_5ck186 FIND v(dout0_5) AT=3740.1n

* CHECK dout0_6 Vdout0_6ck186 = 0 time = 3740
.meas tran vdout0_6ck186 FIND v(dout0_6) AT=3740.1n

* CHECK dout0_7 Vdout0_7ck186 = 0 time = 3740
.meas tran vdout0_7ck186 FIND v(dout0_7) AT=3740.1n

* CHECK dout0_8 Vdout0_8ck186 = 1.8 time = 3740
.meas tran vdout0_8ck186 FIND v(dout0_8) AT=3740.1n

* CHECK dout0_9 Vdout0_9ck186 = 1.8 time = 3740
.meas tran vdout0_9ck186 FIND v(dout0_9) AT=3740.1n

* CHECK dout0_10 Vdout0_10ck186 = 0 time = 3740
.meas tran vdout0_10ck186 FIND v(dout0_10) AT=3740.1n

* CHECK dout0_11 Vdout0_11ck186 = 0 time = 3740
.meas tran vdout0_11ck186 FIND v(dout0_11) AT=3740.1n

* CHECK dout0_12 Vdout0_12ck186 = 0 time = 3740
.meas tran vdout0_12ck186 FIND v(dout0_12) AT=3740.1n

* CHECK dout0_13 Vdout0_13ck186 = 1.8 time = 3740
.meas tran vdout0_13ck186 FIND v(dout0_13) AT=3740.1n

* CHECK dout0_14 Vdout0_14ck186 = 0 time = 3740
.meas tran vdout0_14ck186 FIND v(dout0_14) AT=3740.1n

* CHECK dout0_15 Vdout0_15ck186 = 0 time = 3740
.meas tran vdout0_15ck186 FIND v(dout0_15) AT=3740.1n

* CHECK dout0_0 Vdout0_0ck187 = 0 time = 3760
.meas tran vdout0_0ck187 FIND v(dout0_0) AT=3760.1n

* CHECK dout0_1 Vdout0_1ck187 = 1.8 time = 3760
.meas tran vdout0_1ck187 FIND v(dout0_1) AT=3760.1n

* CHECK dout0_2 Vdout0_2ck187 = 1.8 time = 3760
.meas tran vdout0_2ck187 FIND v(dout0_2) AT=3760.1n

* CHECK dout0_3 Vdout0_3ck187 = 0 time = 3760
.meas tran vdout0_3ck187 FIND v(dout0_3) AT=3760.1n

* CHECK dout0_4 Vdout0_4ck187 = 0 time = 3760
.meas tran vdout0_4ck187 FIND v(dout0_4) AT=3760.1n

* CHECK dout0_5 Vdout0_5ck187 = 1.8 time = 3760
.meas tran vdout0_5ck187 FIND v(dout0_5) AT=3760.1n

* CHECK dout0_6 Vdout0_6ck187 = 0 time = 3760
.meas tran vdout0_6ck187 FIND v(dout0_6) AT=3760.1n

* CHECK dout0_7 Vdout0_7ck187 = 1.8 time = 3760
.meas tran vdout0_7ck187 FIND v(dout0_7) AT=3760.1n

* CHECK dout0_8 Vdout0_8ck187 = 1.8 time = 3760
.meas tran vdout0_8ck187 FIND v(dout0_8) AT=3760.1n

* CHECK dout0_9 Vdout0_9ck187 = 0 time = 3760
.meas tran vdout0_9ck187 FIND v(dout0_9) AT=3760.1n

* CHECK dout0_10 Vdout0_10ck187 = 0 time = 3760
.meas tran vdout0_10ck187 FIND v(dout0_10) AT=3760.1n

* CHECK dout0_11 Vdout0_11ck187 = 0 time = 3760
.meas tran vdout0_11ck187 FIND v(dout0_11) AT=3760.1n

* CHECK dout0_12 Vdout0_12ck187 = 1.8 time = 3760
.meas tran vdout0_12ck187 FIND v(dout0_12) AT=3760.1n

* CHECK dout0_13 Vdout0_13ck187 = 0 time = 3760
.meas tran vdout0_13ck187 FIND v(dout0_13) AT=3760.1n

* CHECK dout0_14 Vdout0_14ck187 = 0 time = 3760
.meas tran vdout0_14ck187 FIND v(dout0_14) AT=3760.1n

* CHECK dout0_15 Vdout0_15ck187 = 0 time = 3760
.meas tran vdout0_15ck187 FIND v(dout0_15) AT=3760.1n

* CHECK dout0_0 Vdout0_0ck188 = 1.8 time = 3780
.meas tran vdout0_0ck188 FIND v(dout0_0) AT=3780.1n

* CHECK dout0_1 Vdout0_1ck188 = 0 time = 3780
.meas tran vdout0_1ck188 FIND v(dout0_1) AT=3780.1n

* CHECK dout0_2 Vdout0_2ck188 = 1.8 time = 3780
.meas tran vdout0_2ck188 FIND v(dout0_2) AT=3780.1n

* CHECK dout0_3 Vdout0_3ck188 = 0 time = 3780
.meas tran vdout0_3ck188 FIND v(dout0_3) AT=3780.1n

* CHECK dout0_4 Vdout0_4ck188 = 0 time = 3780
.meas tran vdout0_4ck188 FIND v(dout0_4) AT=3780.1n

* CHECK dout0_5 Vdout0_5ck188 = 0 time = 3780
.meas tran vdout0_5ck188 FIND v(dout0_5) AT=3780.1n

* CHECK dout0_6 Vdout0_6ck188 = 0 time = 3780
.meas tran vdout0_6ck188 FIND v(dout0_6) AT=3780.1n

* CHECK dout0_7 Vdout0_7ck188 = 0 time = 3780
.meas tran vdout0_7ck188 FIND v(dout0_7) AT=3780.1n

* CHECK dout0_8 Vdout0_8ck188 = 0 time = 3780
.meas tran vdout0_8ck188 FIND v(dout0_8) AT=3780.1n

* CHECK dout0_9 Vdout0_9ck188 = 0 time = 3780
.meas tran vdout0_9ck188 FIND v(dout0_9) AT=3780.1n

* CHECK dout0_10 Vdout0_10ck188 = 1.8 time = 3780
.meas tran vdout0_10ck188 FIND v(dout0_10) AT=3780.1n

* CHECK dout0_11 Vdout0_11ck188 = 0 time = 3780
.meas tran vdout0_11ck188 FIND v(dout0_11) AT=3780.1n

* CHECK dout0_12 Vdout0_12ck188 = 0 time = 3780
.meas tran vdout0_12ck188 FIND v(dout0_12) AT=3780.1n

* CHECK dout0_13 Vdout0_13ck188 = 0 time = 3780
.meas tran vdout0_13ck188 FIND v(dout0_13) AT=3780.1n

* CHECK dout0_14 Vdout0_14ck188 = 0 time = 3780
.meas tran vdout0_14ck188 FIND v(dout0_14) AT=3780.1n

* CHECK dout0_15 Vdout0_15ck188 = 0 time = 3780
.meas tran vdout0_15ck188 FIND v(dout0_15) AT=3780.1n

* CHECK dout0_0 Vdout0_0ck194 = 0 time = 3900
.meas tran vdout0_0ck194 FIND v(dout0_0) AT=3900.1n

* CHECK dout0_1 Vdout0_1ck194 = 0 time = 3900
.meas tran vdout0_1ck194 FIND v(dout0_1) AT=3900.1n

* CHECK dout0_2 Vdout0_2ck194 = 1.8 time = 3900
.meas tran vdout0_2ck194 FIND v(dout0_2) AT=3900.1n

* CHECK dout0_3 Vdout0_3ck194 = 0 time = 3900
.meas tran vdout0_3ck194 FIND v(dout0_3) AT=3900.1n

* CHECK dout0_4 Vdout0_4ck194 = 1.8 time = 3900
.meas tran vdout0_4ck194 FIND v(dout0_4) AT=3900.1n

* CHECK dout0_5 Vdout0_5ck194 = 1.8 time = 3900
.meas tran vdout0_5ck194 FIND v(dout0_5) AT=3900.1n

* CHECK dout0_6 Vdout0_6ck194 = 0 time = 3900
.meas tran vdout0_6ck194 FIND v(dout0_6) AT=3900.1n

* CHECK dout0_7 Vdout0_7ck194 = 1.8 time = 3900
.meas tran vdout0_7ck194 FIND v(dout0_7) AT=3900.1n

* CHECK dout0_8 Vdout0_8ck194 = 0 time = 3900
.meas tran vdout0_8ck194 FIND v(dout0_8) AT=3900.1n

* CHECK dout0_9 Vdout0_9ck194 = 1.8 time = 3900
.meas tran vdout0_9ck194 FIND v(dout0_9) AT=3900.1n

* CHECK dout0_10 Vdout0_10ck194 = 1.8 time = 3900
.meas tran vdout0_10ck194 FIND v(dout0_10) AT=3900.1n

* CHECK dout0_11 Vdout0_11ck194 = 0 time = 3900
.meas tran vdout0_11ck194 FIND v(dout0_11) AT=3900.1n

* CHECK dout0_12 Vdout0_12ck194 = 0 time = 3900
.meas tran vdout0_12ck194 FIND v(dout0_12) AT=3900.1n

* CHECK dout0_13 Vdout0_13ck194 = 0 time = 3900
.meas tran vdout0_13ck194 FIND v(dout0_13) AT=3900.1n

* CHECK dout0_14 Vdout0_14ck194 = 0 time = 3900
.meas tran vdout0_14ck194 FIND v(dout0_14) AT=3900.1n

* CHECK dout0_15 Vdout0_15ck194 = 1.8 time = 3900
.meas tran vdout0_15ck194 FIND v(dout0_15) AT=3900.1n

* CHECK dout0_0 Vdout0_0ck197 = 0 time = 3960
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=3960.1n

* CHECK dout0_1 Vdout0_1ck197 = 1.8 time = 3960
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=3960.1n

* CHECK dout0_2 Vdout0_2ck197 = 0 time = 3960
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=3960.1n

* CHECK dout0_3 Vdout0_3ck197 = 1.8 time = 3960
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=3960.1n

* CHECK dout0_4 Vdout0_4ck197 = 0 time = 3960
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=3960.1n

* CHECK dout0_5 Vdout0_5ck197 = 1.8 time = 3960
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=3960.1n

* CHECK dout0_6 Vdout0_6ck197 = 1.8 time = 3960
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=3960.1n

* CHECK dout0_7 Vdout0_7ck197 = 0 time = 3960
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=3960.1n

* CHECK dout0_8 Vdout0_8ck197 = 0 time = 3960
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=3960.1n

* CHECK dout0_9 Vdout0_9ck197 = 0 time = 3960
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=3960.1n

* CHECK dout0_10 Vdout0_10ck197 = 0 time = 3960
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=3960.1n

* CHECK dout0_11 Vdout0_11ck197 = 1.8 time = 3960
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=3960.1n

* CHECK dout0_12 Vdout0_12ck197 = 0 time = 3960
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=3960.1n

* CHECK dout0_13 Vdout0_13ck197 = 0 time = 3960
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=3960.1n

* CHECK dout0_14 Vdout0_14ck197 = 0 time = 3960
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=3960.1n

* CHECK dout0_15 Vdout0_15ck197 = 1.8 time = 3960
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=3960.1n

* CHECK dout0_0 Vdout0_0ck204 = 0 time = 4100
.meas tran vdout0_0ck204 FIND v(dout0_0) AT=4100.1n

* CHECK dout0_1 Vdout0_1ck204 = 1.8 time = 4100
.meas tran vdout0_1ck204 FIND v(dout0_1) AT=4100.1n

* CHECK dout0_2 Vdout0_2ck204 = 1.8 time = 4100
.meas tran vdout0_2ck204 FIND v(dout0_2) AT=4100.1n

* CHECK dout0_3 Vdout0_3ck204 = 1.8 time = 4100
.meas tran vdout0_3ck204 FIND v(dout0_3) AT=4100.1n

* CHECK dout0_4 Vdout0_4ck204 = 0 time = 4100
.meas tran vdout0_4ck204 FIND v(dout0_4) AT=4100.1n

* CHECK dout0_5 Vdout0_5ck204 = 0 time = 4100
.meas tran vdout0_5ck204 FIND v(dout0_5) AT=4100.1n

* CHECK dout0_6 Vdout0_6ck204 = 0 time = 4100
.meas tran vdout0_6ck204 FIND v(dout0_6) AT=4100.1n

* CHECK dout0_7 Vdout0_7ck204 = 0 time = 4100
.meas tran vdout0_7ck204 FIND v(dout0_7) AT=4100.1n

* CHECK dout0_8 Vdout0_8ck204 = 1.8 time = 4100
.meas tran vdout0_8ck204 FIND v(dout0_8) AT=4100.1n

* CHECK dout0_9 Vdout0_9ck204 = 1.8 time = 4100
.meas tran vdout0_9ck204 FIND v(dout0_9) AT=4100.1n

* CHECK dout0_10 Vdout0_10ck204 = 0 time = 4100
.meas tran vdout0_10ck204 FIND v(dout0_10) AT=4100.1n

* CHECK dout0_11 Vdout0_11ck204 = 0 time = 4100
.meas tran vdout0_11ck204 FIND v(dout0_11) AT=4100.1n

* CHECK dout0_12 Vdout0_12ck204 = 0 time = 4100
.meas tran vdout0_12ck204 FIND v(dout0_12) AT=4100.1n

* CHECK dout0_13 Vdout0_13ck204 = 1.8 time = 4100
.meas tran vdout0_13ck204 FIND v(dout0_13) AT=4100.1n

* CHECK dout0_14 Vdout0_14ck204 = 0 time = 4100
.meas tran vdout0_14ck204 FIND v(dout0_14) AT=4100.1n

* CHECK dout0_15 Vdout0_15ck204 = 0 time = 4100
.meas tran vdout0_15ck204 FIND v(dout0_15) AT=4100.1n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
